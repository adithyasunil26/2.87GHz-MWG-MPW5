* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[5] io_analog[6] io_analog[7]
+ io_analog[8] io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
C0 pd_1/tspc_r_0/z5 pd_1/tspc_r_1/z5 0.02fF
C1 pd_0/and_pd_0/Z1 pd_0/UP 0.06fF
C2 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/nand_1/z1 0.22fF
C3 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/tspc_0/D 0.04fF
C4 divbuf_9/OUT4 divbuf_9/OUT 1.11fF
C5 divbuf_1/OUT2 divbuf_1/OUT5 0.02fF
C6 divbuf_0/IN divbuf_0/a_492_n240# 0.13fF
C7 ro_complete_0/a2 ro_complete_0/cbank_0/switch_2/vin 0.14fF
C8 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a4 0.09fF
C9 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/a5 0.09fF
C10 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z3 0.33fF
C11 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C12 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/z5 0.20fF
C13 divider_0/prescaler_0/tspc_1/Z4 divider_0/clk 0.12fF
C14 divbuf_4/OUT3 divbuf_4/OUT4 5.16fF
C15 divbuf_4/OUT2 divbuf_4/OUT5 0.02fF
C16 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/Q 0.04fF
C17 divider_1/prescaler_0/tspc_1/Z3 divider_1/clk 0.45fF
C18 divbuf_8/OUT2 divbuf_8/OUT3 1.37fF
C19 divbuf_18/OUT3 divbuf_18/OUT5 0.01fF
C20 divider_2/tspc_0/Z3 divider_2/tspc_1/Q 0.45fF
C21 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z3 0.16fF
C22 divider_2/nor_0/A divider_2/tspc_2/Z2 0.23fF
C23 divbuf_2/IN divbuf_2/OUT5 0.00fF
C24 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/and_pd_0/Z1 0.18fF
C25 divider_0/prescaler_0/tspc_1/Q divider_0/clk 0.60fF
C26 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C27 divider_1/nor_1/Z1 divider_1/nor_1/B 0.06fF
C28 divbuf_5/OUT3 divbuf_5/OUT4 5.16fF
C29 divbuf_5/OUT2 divbuf_5/OUT5 0.02fF
C30 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C31 divbuf_7/a_492_n240# divbuf_7/OUT2 0.42fF
C32 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C33 divbuf_17/OUT4 divbuf_17/OUT5 20.26fF
C34 divbuf_12/OUT5 divbuf_12/OUT 43.38fF
C35 pd_0/R pd_0/and_pd_0/Z1 0.02fF
C36 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/z5 0.20fF
C37 divider_2/nor_0/B divider_2/tspc_1/Z4 0.21fF
C38 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z4 0.12fF
C39 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z2 1.07fF
C40 divider_2/and_0/out1 divider_2/and_0/Z1 0.36fF
C41 divbuf_15/OUT5 divbuf_15/a_492_n240# 0.01fF
C42 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_1/Q 0.21fF
C43 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_2/D 0.16fF
C44 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/D 0.03fF
C45 divbuf_25/OUT2 divbuf_25/OUT5 0.02fF
C46 ro_complete_1/a4 ro_complete_1/cbank_2/v 0.05fF
C47 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_0/vin 0.19fF
C48 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_1/Q 0.13fF
C49 divider_1/prescaler_0/m1_2700_2190# divider_1/and_0/OUT 0.14fF
C50 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z4 0.15fF
C51 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C52 pll_full_0/ro_complete_0/a0 pll_full_0/divider_0/clk 0.11fF
C53 divbuf_11/IN divbuf_11/OUT5 0.00fF
C54 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z4 0.00fF
C55 divbuf_17/OUT3 divbuf_17/OUT5 0.01fF
C56 divbuf_9/a_492_n240# divbuf_9/IN 0.13fF
C57 pd_1/DIV pd_1/tspc_r_0/Z3 0.65fF
C58 pd_0/and_pd_0/Out1 pd_0/and_pd_0/Z1 0.18fF
C59 pd_0/tspc_r_0/Qbar1 pd_0/R 0.01fF
C60 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/Qbar 0.01fF
C61 divider_2/prescaler_0/tspc_1/Z2 divider_2/clk 0.11fF
C62 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Qbar1 0.12fF
C63 ro_complete_0/a0 ro_complete_0/cbank_2/switch_5/vin 0.09fF
C64 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C65 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a4 0.09fF
C66 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a5 0.09fF
C67 divider_1/prescaler_0/tspc_2/Z4 divider_1/prescaler_0/tspc_2/D 0.11fF
C68 divider_1/prescaler_0/tspc_0/Z4 divider_1/clk 0.12fF
C69 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C70 divbuf_17/OUT4 divbuf_17/OUT 1.11fF
C71 divider_2/mc2 divider_2/prescaler_0/tspc_2/a_630_n680# 0.33fF
C72 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z4 0.12fF
C73 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/a_630_n680# 0.19fF
C74 divbuf_13/OUT2 divbuf_13/OUT3 1.37fF
C75 cp_0/upbar cp_0/down 0.02fF
C76 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/tspc_r_0/Z2 0.71fF
C77 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/v 1.30fF
C78 divider_0/mc2 divider_0/prescaler_0/tspc_2/a_630_n680# 0.33fF
C79 divbuf_2/OUT4 divbuf_2/OUT 1.11fF
C80 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/a1 0.14fF
C81 divider_0/prescaler_0/tspc_2/Z4 divider_0/clk 0.12fF
C82 divider_1/tspc_0/a_630_n680# divider_1/Out 0.04fF
C83 divbuf_5/a_492_n240# divbuf_5/IN 0.13fF
C84 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C85 pd_0/DIV pd_0/tspc_r_0/Z4 0.02fF
C86 divider_2/prescaler_0/Out divider_2/tspc_2/Z4 0.12fF
C87 divider_1/prescaler_0/tspc_2/Z3 divider_1/clk 0.45fF
C88 divbuf_21/OUT3 divbuf_21/OUT4 5.16fF
C89 divbuf_21/OUT2 divbuf_21/OUT5 0.02fF
C90 divbuf_12/a_492_n240# divbuf_12/OUT2 0.42fF
C91 pd_0/REF pd_0/tspc_r_1/Qbar1 0.12fF
C92 io_clamp_low[2] io_analog[6] 0.53fF
C93 divbuf_17/OUT3 divbuf_17/OUT 0.26fF
C94 divbuf_24/OUT5 divbuf_24/OUT 43.38fF
C95 filter_0/a_4216_n5230# filter_0/v 0.19fF
C96 pd_1/tspc_r_1/z5 pd_1/UP 0.03fF
C97 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z4 0.14fF
C98 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/switch_0/vin 0.19fF
C99 ro_complete_1/a5 ro_complete_1/cbank_2/switch_0/vin 0.09fF
C100 divider_0/tspc_2/Z2 divider_0/tspc_2/Z4 0.36fF
C101 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Z4 0.65fF
C102 pll_full_0/ro_complete_0/a3 pll_full_0/divider_0/clk 0.11fF
C103 divider_1/tspc_2/Z2 divider_1/tspc_2/Z3 0.16fF
C104 divider_1/nor_0/A divider_1/tspc_2/Z4 0.21fF
C105 divbuf_23/IN divbuf_23/OUT5 0.00fF
C106 pd_1/tspc_r_0/Qbar1 pd_1/DIV 0.12fF
C107 divider_2/tspc_1/Z3 divider_2/tspc_1/Z4 0.65fF
C108 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Q 0.04fF
C109 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_492_n240# 0.00fF
C110 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C111 divbuf_2/OUT3 divbuf_2/OUT5 0.01fF
C112 divider_0/prescaler_0/Out divider_0/nor_0/A 0.15fF
C113 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Z4 0.65fF
C114 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/clk 0.14fF
C115 divider_0/nor_1/Z1 divider_0/and_0/B 0.78fF
C116 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C117 divider_1/prescaler_0/Out divider_1/tspc_2/a_630_n680# 0.01fF
C118 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z4 0.00fF
C119 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Q 0.21fF
C120 divbuf_10/OUT3 divbuf_10/OUT5 0.01fF
C121 divbuf_10/OUT2 divbuf_10/OUT 0.06fF
C122 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C123 divbuf_19/OUT5 divbuf_19/OUT 43.38fF
C124 divider_1/and_0/B divider_1/and_0/Z1 0.07fF
C125 pd_1/R pd_1/UP 0.45fF
C126 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z1 0.09fF
C127 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/nand_1/z1 0.01fF
C128 divider_2/prescaler_0/tspc_2/Z2 divider_2/clk 0.11fF
C129 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z4 0.08fF
C130 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z3 0.05fF
C131 ro_complete_0/cbank_1/v ro_complete_0/cbank_2/v 1.36fF
C132 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C133 divbuf_4/OUT4 divbuf_4/OUT5 20.26fF
C134 divbuf_4/OUT3 divbuf_4/OUT 0.26fF
C135 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C136 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z3 0.33fF
C137 divbuf_16/OUT2 divbuf_16/OUT5 0.02fF
C138 divider_1/prescaler_0/tspc_1/Z4 divider_1/clk 0.12fF
C139 pd_0/tspc_r_0/Z4 pd_0/tspc_r_0/z5 0.04fF
C140 divbuf_18/IN divbuf_18/a_492_n240# 0.13fF
C141 divider_2/tspc_0/a_630_n680# divider_2/tspc_1/Q 0.01fF
C142 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z4 0.36fF
C143 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_0/D 0.09fF
C144 divbuf_8/OUT3 divbuf_8/OUT4 5.16fF
C145 divbuf_8/OUT2 divbuf_8/OUT5 0.02fF
C146 pd_1/tspc_r_1/Z3 pd_1/UP 0.03fF
C147 divbuf_24/a_492_n240# divbuf_24/OUT2 0.42fF
C148 divider_2/tspc_2/Z1 divider_2/tspc_2/Z3 0.06fF
C149 divider_0/tspc_0/Z2 divider_0/nor_1/B 0.40fF
C150 divider_0/tspc_0/Z3 divider_0/Out 0.05fF
C151 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z3 0.33fF
C152 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_0/vin 0.19fF
C153 pll_full_0/pd_0/tspc_r_1/z5 pll_full_0/pd_0/UP 0.03fF
C154 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/a0 0.13fF
C155 divider_0/and_0/OUT divider_0/and_0/Z1 0.04fF
C156 divider_0/prescaler_0/tspc_2/Q divider_0/clk 0.05fF
C157 divbuf_5/OUT4 divbuf_5/OUT5 20.26fF
C158 divbuf_5/OUT3 divbuf_5/OUT 0.26fF
C159 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C160 divbuf_16/OUT3 divbuf_16/OUT2 1.37fF
C161 divbuf_16/IN divbuf_16/OUT5 0.00fF
C162 divider_1/prescaler_0/tspc_1/Q divider_1/clk 0.60fF
C163 cp_0/a_1710_0# cp_0/a_10_n50# 0.04fF
C164 pd_1/tspc_r_0/Z2 pd_1/DIV 0.19fF
C165 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C166 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z3 0.16fF
C167 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/nand_0/z1 0.07fF
C168 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/D 0.05fF
C169 divbuf_1/OUT5 divbuf_1/OUT 43.38fF
C170 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C171 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/v 1.30fF
C172 ro_complete_1/a1 ro_complete_1/cbank_1/v 0.05fF
C173 divider_1/mc2 divider_1/and_0/out1 0.06fF
C174 divbuf_14/OUT4 divbuf_14/OUT3 5.16fF
C175 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_1/B 0.47fF
C176 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/Z4 0.65fF
C177 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z2 0.19fF
C178 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_1/Q 0.21fF
C179 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_2/D 0.16fF
C180 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/D 0.03fF
C181 divbuf_11/OUT3 divbuf_11/OUT5 0.01fF
C182 divbuf_11/OUT2 divbuf_11/OUT 0.06fF
C183 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divider_0/tspc_2/Z4 0.65fF
C184 cp_0/a_1710_0# cp_0/down 0.32fF
C185 pd_1/DOWN pd_1/tspc_r_1/Qbar 0.02fF
C186 pd_1/R pd_1/and_pd_0/Out1 0.33fF
C187 pd_0/tspc_r_1/z5 pd_0/UP 0.03fF
C188 divider_0/nor_0/Z1 divider_0/nor_0/B 0.06fF
C189 divider_1/mc2 divider_1/nor_0/B 0.06fF
C190 divbuf_14/OUT2 divbuf_14/OUT3 1.37fF
C191 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Q 0.05fF
C192 divider_0/prescaler_0/m1_2700_2190# divider_0/clk 0.01fF
C193 ro_complete_0/a0 ro_complete_0/cbank_2/v 0.05fF
C194 divbuf_20/a_492_n240# divbuf_20/OUT5 0.01fF
C195 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C196 divbuf_16/OUT3 divbuf_16/OUT5 0.01fF
C197 divbuf_18/OUT2 divbuf_18/a_492_n240# 0.42fF
C198 divider_2/and_0/OUT divider_2/and_0/B 0.01fF
C199 divbuf_13/OUT3 divbuf_13/OUT4 5.16fF
C200 divbuf_13/OUT2 divbuf_13/OUT5 0.02fF
C201 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z4 0.01fF
C202 ro_complete_1/a4 ro_complete_1/cbank_2/switch_1/vin 0.09fF
C203 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/v 1.30fF
C204 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C205 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_1/Q 0.14fF
C206 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/Out 0.04fF
C207 divbuf_21/OUT4 divbuf_21/OUT5 20.26fF
C208 divbuf_21/OUT3 divbuf_21/OUT 0.26fF
C209 divider_2/prescaler_0/tspc_0/Z3 divider_2/clk 0.64fF
C210 divider_1/prescaler_0/tspc_2/Z4 divider_1/clk 0.12fF
C211 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/a_630_n680# 0.19fF
C212 pll_full_0/pd_0/DOWN pll_full_0/pd_0/REF 1.48fF
C213 ro_complete_0/a4 ro_complete_0/cbank_2/switch_0/vin 0.12fF
C214 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Q 0.15fF
C215 divider_0/prescaler_0/tspc_0/Z2 divider_0/and_0/OUT 0.06fF
C216 divbuf_3/OUT2 divbuf_3/OUT3 1.37fF
C217 ro_complete_1/a3 ro_complete_1/cbank_2/switch_2/vin 0.09fF
C218 divbuf_6/a_492_n240# divbuf_6/OUT 0.00fF
C219 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/B 0.18fF
C220 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C221 divbuf_17/OUT2 divbuf_17/a_492_n240# 0.42fF
C222 divbuf_19/OUT2 divbuf_19/a_492_n240# 0.42fF
C223 divider_1/tspc_2/Z2 divider_1/tspc_2/Z4 0.36fF
C224 pd_1/R pd_1/tspc_r_1/Z2 0.21fF
C225 pd_1/DOWN pd_1/tspc_r_0/Z3 0.03fF
C226 divbuf_23/OUT3 divbuf_23/OUT5 0.01fF
C227 divbuf_23/OUT2 divbuf_23/OUT 0.06fF
C228 pll_full_0/pd_0/R pll_full_0/pd_0/REF 0.61fF
C229 divbuf_15/OUT2 divbuf_15/OUT3 1.37fF
C230 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/a3 0.13fF
C231 ro_complete_0/a3 ro_complete_0/cbank_2/v 0.05fF
C232 divbuf_15/IN divbuf_15/a_492_n240# 0.13fF
C233 divbuf_25/OUT3 divbuf_25/OUT5 0.01fF
C234 divbuf_25/a_492_n240# divbuf_25/IN 0.13fF
C235 divider_0/prescaler_0/Out divider_0/tspc_2/Z2 0.11fF
C236 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/clk 0.01fF
C237 divider_2/Out divider_2/nor_1/B 0.22fF
C238 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z2 0.01fF
C239 divbuf_3/OUT3 divbuf_3/OUT 0.26fF
C240 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/v 1.30fF
C241 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C242 divbuf_10/OUT4 divbuf_10/OUT 1.11fF
C243 divider_1/prescaler_0/Out divider_1/nor_0/A 0.15fF
C244 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Z4 0.65fF
C245 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/clk 0.14fF
C246 divider_1/nor_1/Z1 divider_1/and_0/B 0.78fF
C247 divbuf_22/a_492_n240# divbuf_22/OUT5 0.01fF
C248 pd_1/DOWN pd_1/and_pd_0/Z1 0.07fF
C249 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z2 0.25fF
C250 divider_2/prescaler_0/tspc_0/D divider_2/prescaler_0/nand_1/z1 0.21fF
C251 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z4 0.12fF
C252 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z2 1.07fF
C253 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/v 1.30fF
C254 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_2/Q 0.19fF
C255 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/clk 0.01fF
C256 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT5 0.01fF
C257 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z4 0.08fF
C258 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z3 0.05fF
C259 divbuf_4/OUT5 divbuf_4/OUT 43.38fF
C260 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C261 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/a_630_n680# 0.04fF
C262 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C263 divbuf_17/OUT2 divbuf_17/OUT5 0.02fF
C264 divbuf_8/OUT4 divbuf_8/OUT5 20.26fF
C265 divbuf_8/OUT3 divbuf_8/OUT 0.26fF
C266 pd_0/R pd_0/REF 0.61fF
C267 divider_2/tspc_2/Z1 divider_2/tspc_2/Z4 0.00fF
C268 ro_complete_0/a3 ro_complete_0/cbank_1/switch_2/vin 0.09fF
C269 divider_0/nor_0/B divider_0/tspc_2/Q 0.22fF
C270 divider_0/tspc_0/a_630_n680# divider_0/nor_1/B 0.35fF
C271 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z4 0.08fF
C272 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z3 0.05fF
C273 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_4/vin 0.20fF
C274 divider_0/tspc_2/a_630_n680# divider_0/nor_0/A 0.35fF
C275 divider_0/prescaler_0/tspc_0/D divider_0/clk 0.29fF
C276 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C277 divider_1/tspc_0/Z2 divider_1/nor_1/B 0.40fF
C278 divider_1/tspc_0/Z3 divider_1/Out 0.05fF
C279 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z3 0.33fF
C280 divbuf_5/OUT5 divbuf_5/OUT 43.38fF
C281 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z1 0.03fF
C282 pll_full_0/ro_complete_0/a4 pll_full_0/divider_0/clk 0.01fF
C283 pd_0/tspc_r_0/Z3 pd_0/DIV 0.65fF
C284 divbuf_7/a_492_n240# divbuf_7/OUT 0.00fF
C285 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/nor_0/A 0.03fF
C286 divider_1/and_0/OUT divider_1/and_0/Z1 0.04fF
C287 divider_1/prescaler_0/tspc_2/Q divider_1/clk 0.05fF
C288 pd_1/tspc_r_0/Qbar1 pd_1/DOWN 0.11fF
C289 pd_1/R pd_1/DIV 0.51fF
C290 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z4 0.36fF
C291 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT3 0.26fF
C292 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_5/vin 0.20fF
C293 pll_full_0/pd_0/DIV pll_full_0/divider_0/and_0/OUT 0.01fF
C294 divbuf_15/OUT2 divbuf_15/a_492_n240# 0.42fF
C295 divider_0/tspc_1/a_630_n680# divider_0/nor_1/B 0.00fF
C296 divider_0/prescaler_0/tspc_1/Z2 divider_0/and_0/OUT 0.06fF
C297 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z3 0.33fF
C298 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Q 0.38fF
C299 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_0/D 0.11fF
C300 divider_0/nor_0/Z1 divider_0/and_0/A 0.80fF
C301 ro_complete_1/a5 ro_complete_1/cbank_2/v 0.08fF
C302 divider_1/mc2 divider_1/and_0/A 0.16fF
C303 divider_0/and_0/out1 divider_0/and_0/A 0.01fF
C304 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C305 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/nand_0/z1 0.07fF
C306 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/D 0.05fF
C307 divbuf_10/a_492_n240# divbuf_10/IN 0.13fF
C308 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z2 0.30fF
C309 divbuf_11/OUT4 divbuf_11/OUT 1.11fF
C310 divbuf_18/OUT2 divbuf_18/OUT 0.06fF
C311 divbuf_17/OUT2 divbuf_17/OUT 0.06fF
C312 divbuf_16/OUT5 divbuf_16/OUT4 20.26fF
C313 divbuf_9/a_492_n240# divbuf_9/OUT5 0.01fF
C314 divider_0/tspc_0/Z2 divider_0/tspc_0/a_630_n680# 0.01fF
C315 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z1 0.09fF
C316 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z2 0.19fF
C317 divbuf_1/OUT2 divbuf_1/OUT3 1.37fF
C318 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/clk 0.01fF
C319 divider_0/nor_0/B divider_0/and_0/A 0.26fF
C320 divbuf_4/a_492_n240# divbuf_4/OUT2 0.42fF
C321 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_1/Q 0.13fF
C322 divbuf_16/OUT3 divbuf_16/OUT4 5.16fF
C323 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Q 0.05fF
C324 divider_1/prescaler_0/m1_2700_2190# divider_1/clk 0.01fF
C325 divbuf_20/OUT2 divbuf_20/OUT3 1.37fF
C326 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z3 0.45fF
C327 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_0/A 1.21fF
C328 divider_2/tspc_0/Z2 divider_2/nor_1/B 0.40fF
C329 divbuf_13/OUT4 divbuf_13/OUT5 20.26fF
C330 divbuf_13/OUT3 divbuf_13/OUT 0.26fF
C331 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/a1 0.14fF
C332 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/v 1.30fF
C333 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/a3 0.09fF
C334 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/UP 0.11fF
C335 ro_complete_1/a2 ro_complete_1/cbank_2/v 0.05fF
C336 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C337 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/Out 0.05fF
C338 divider_0/nor_1/B divider_0/and_0/B 0.29fF
C339 divbuf_5/a_492_n240# divbuf_5/OUT5 0.01fF
C340 io_clamp_low[2] io_clamp_high[2] 0.53fF
C341 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/a_630_n680# 0.05fF
C342 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z4 0.01fF
C343 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z3 0.16fF
C344 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C345 divider_2/prescaler_0/tspc_0/Z4 divider_2/clk 0.12fF
C346 divbuf_21/OUT5 divbuf_21/OUT 43.38fF
C347 pd_1/tspc_r_0/Qbar pd_1/tspc_r_0/Qbar1 0.01fF
C348 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z1 0.09fF
C349 pd_0/REF pd_0/tspc_r_1/Z2 0.19fF
C350 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/z5 0.11fF
C351 divbuf_12/a_492_n240# divbuf_12/OUT 0.00fF
C352 io_clamp_high[1] io_analog[5] 0.53fF
C353 divider_0/tspc_1/Z1 divider_0/tspc_1/Z2 1.07fF
C354 divider_0/nor_0/B divider_0/tspc_1/Z3 0.38fF
C355 divider_0/tspc_1/Q divider_0/nor_1/B 0.22fF
C356 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/v 1.30fF
C357 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/cbank_0/v 1.30fF
C358 divbuf_3/OUT2 divbuf_3/OUT5 0.02fF
C359 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/a0 0.09fF
C360 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT 43.38fF
C361 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C362 pd_0/DOWN pd_0/tspc_r_1/Qbar 0.02fF
C363 divbuf_6/IN divbuf_6/OUT5 0.00fF
C364 divider_1/nor_0/Z1 divider_1/and_0/B 0.18fF
C365 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Q 0.15fF
C366 divider_1/prescaler_0/tspc_0/Z2 divider_1/and_0/OUT 0.06fF
C367 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_2/Q 0.01fF
C368 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/a_630_n680# 0.35fF
C369 pll_full_0/ro_complete_0/a1 pll_full_0/divider_0/clk 0.11fF
C370 divbuf_11/a_492_n240# divbuf_11/IN 0.13fF
C371 pd_0/tspc_r_1/Qbar1 pd_0/UP 0.11fF
C372 divbuf_23/OUT4 divbuf_23/OUT 1.11fF
C373 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar1 0.30fF
C374 divbuf_25/OUT4 divbuf_25/OUT 1.11fF
C375 divider_0/prescaler_0/tspc_2/Z2 divider_0/and_0/OUT 0.05fF
C376 divbuf_3/OUT5 divbuf_3/OUT 43.38fF
C377 divbuf_19/IN divbuf_19/OUT5 0.00fF
C378 divbuf_17/OUT4 divbuf_17/OUT3 5.16fF
C379 divider_1/prescaler_0/Out divider_1/tspc_2/Z2 0.11fF
C380 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/clk 0.01fF
C381 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z2 0.14fF
C382 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C383 divider_2/mc2 divider_2/nor_1/B 0.15fF
C384 divbuf_22/OUT2 divbuf_22/OUT3 1.37fF
C385 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/B 0.18fF
C386 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/Qbar 0.01fF
C387 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/Z3 0.38fF
C388 pd_0/DIV pd_0/tspc_r_0/Z2 0.19fF
C389 divider_0/tspc_0/Z2 divider_0/tspc_1/Q 0.14fF
C390 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z3 0.16fF
C391 divbuf_16/a_492_n240# divbuf_16/OUT2 0.42fF
C392 divider_0/tspc_1/Z2 divider_0/nor_0/A 0.15fF
C393 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_0/D 0.32fF
C394 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/clk 0.01fF
C395 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/cbank_0/v 1.30fF
C396 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C397 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C398 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/a3 0.09fF
C399 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z4 0.12fF
C400 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z2 1.07fF
C401 divbuf_21/a_492_n240# divbuf_21/OUT2 0.42fF
C402 divbuf_18/OUT2 divbuf_18/OUT3 1.37fF
C403 divider_2/nor_1/Z1 divider_2/nor_0/B 0.18fF
C404 divider_2/prescaler_0/Out divider_2/tspc_2/a_630_n680# 0.01fF
C405 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_2/Q 0.19fF
C406 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/clk 0.01fF
C407 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/B 0.31fF
C408 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/nor_0/A 0.55fF
C409 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C410 pd_0/R pd_0/tspc_r_1/Qbar1 0.30fF
C411 divider_2/nor_1/B divider_2/nor_0/B 0.47fF
C412 divider_2/tspc_0/Z2 divider_2/tspc_0/Z1 1.07fF
C413 divbuf_8/OUT5 divbuf_8/OUT 43.38fF
C414 divider_2/tspc_2/Z3 divider_2/tspc_2/Z4 0.65fF
C415 divbuf_24/a_492_n240# divbuf_24/OUT 0.00fF
C416 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z3 0.33fF
C417 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z4 0.12fF
C418 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z2 1.07fF
C419 ro_complete_0/a3 ro_complete_0/cbank_2/switch_1/vin 0.13fF
C420 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C421 divbuf_16/a_492_n240# divbuf_16/IN 0.13fF
C422 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z2 0.01fF
C423 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C424 pd_0/DOWN pd_0/tspc_r_0/z5 0.03fF
C425 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Q 0.51fF
C426 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z4 0.36fF
C427 divider_1/nor_0/B divider_1/tspc_2/Q 0.22fF
C428 divider_1/tspc_0/a_630_n680# divider_1/nor_1/B 0.35fF
C429 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z4 0.08fF
C430 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z3 0.05fF
C431 divbuf_7/IN divbuf_7/OUT5 0.00fF
C432 divider_1/tspc_2/a_630_n680# divider_1/nor_0/A 0.35fF
C433 divider_1/prescaler_0/tspc_0/D divider_1/clk 0.29fF
C434 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/clk 0.06fF
C435 divbuf_23/a_492_n240# divbuf_23/IN 0.13fF
C436 divbuf_15/OUT4 divbuf_15/OUT 1.11fF
C437 divider_0/tspc_2/Q divider_0/tspc_1/Z3 0.45fF
C438 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z2 0.01fF
C439 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z4 0.08fF
C440 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z3 0.05fF
C441 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Q 0.04fF
C442 ro_complete_0/a4 ro_complete_0/cbank_2/v 0.05fF
C443 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/v 1.30fF
C444 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT2 0.42fF
C445 divider_2/tspc_0/Z4 divider_2/tspc_0/Z2 0.36fF
C446 divider_2/Out divider_2/tspc_0/Z3 0.05fF
C447 divbuf_16/a_492_n240# divbuf_16/OUT5 0.01fF
C448 ro_complete_1/a0 ro_complete_1/cbank_2/switch_4/vin 0.13fF
C449 ro_complete_1/cbank_0/v ro_complete_1/cbank_1/v 1.27fF
C450 pd_0/DOWN pd_0/and_pd_0/Z1 0.07fF
C451 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z3 0.06fF
C452 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C453 divider_1/tspc_1/a_630_n680# divider_1/nor_1/B 0.00fF
C454 divider_1/prescaler_0/tspc_1/Z2 divider_1/and_0/OUT 0.06fF
C455 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z3 0.33fF
C456 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Q 0.38fF
C457 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/D 0.11fF
C458 divbuf_18/IN divbuf_18/OUT5 0.00fF
C459 divider_2/tspc_1/a_630_n680# divider_2/nor_1/B 0.00fF
C460 divider_1/and_0/out1 divider_1/and_0/A 0.01fF
C461 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/A 0.01fF
C462 divbuf_9/OUT2 divbuf_9/OUT3 1.37fF
C463 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C464 ro_complete_0/cbank_2/switch_2/vin ro_complete_0/cbank_2/v 1.30fF
C465 divider_1/tspc_0/Z2 divider_1/tspc_0/a_630_n680# 0.01fF
C466 pd_0/DOWN pd_0/tspc_r_0/Qbar1 0.11fF
C467 divbuf_20/OUT3 divbuf_20/OUT4 5.16fF
C468 divbuf_20/OUT2 divbuf_20/OUT5 0.02fF
C469 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/nor_0/A 0.01fF
C470 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z4 0.12fF
C471 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z3 0.16fF
C472 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C473 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_1/Q 0.21fF
C474 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/clk 0.01fF
C475 divider_1/nor_0/B divider_1/and_0/A 0.26fF
C476 divbuf_8/a_492_n240# divbuf_8/OUT2 0.42fF
C477 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z2 0.01fF
C478 pd_1/tspc_r_1/Z4 pd_1/tspc_r_1/z5 0.04fF
C479 divbuf_13/OUT5 divbuf_13/OUT 43.38fF
C480 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/a1 0.14fF
C481 pll_full_0/pd_0/REF pll_full_0/divbuf_1/a_492_n240# 0.13fF
C482 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z1 0.08fF
C483 divider_0/mc2 divider_0/nor_1/B 0.15fF
C484 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/cbank_0/v 1.30fF
C485 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C486 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C487 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/a_630_n680# 0.12fF
C488 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C489 divider_1/nor_1/B divider_1/and_0/B 0.29fF
C490 divbuf_12/IN divbuf_12/OUT5 0.00fF
C491 pd_1/R pd_1/DOWN 0.36fF
C492 io_clamp_low[0] io_analog[4] 0.53fF
C493 pd_1/and_pd_0/Out1 pd_1/UP 0.33fF
C494 divbuf_1/OUT2 divbuf_1/a_492_n240# 0.42fF
C495 ro_complete_0/a5 ro_complete_0/cbank_2/switch_0/vin 0.09fF
C496 divider_0/nor_0/B divider_0/tspc_1/Z4 0.21fF
C497 divider_0/tspc_0/Z3 divider_0/nor_1/B 0.38fF
C498 divider_0/nor_0/A divider_0/and_0/B 0.08fF
C499 divbuf_1/OUT divbuf_1/OUT3 0.26fF
C500 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C501 divider_1/tspc_1/Z1 divider_1/tspc_1/Z2 1.07fF
C502 divider_1/nor_0/B divider_1/tspc_1/Z3 0.38fF
C503 divider_1/tspc_1/Q divider_1/nor_1/B 0.22fF
C504 divbuf_6/OUT3 divbuf_6/OUT5 0.01fF
C505 divbuf_6/OUT2 divbuf_6/OUT 0.06fF
C506 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C507 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z1 0.03fF
C508 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z3 0.05fF
C509 divbuf_18/OUT2 divbuf_18/OUT5 0.02fF
C510 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/Z3 0.20fF
C511 pd_1/tspc_r_0/z5 pd_1/DIV 0.04fF
C512 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/DOWN 0.03fF
C513 divbuf_19/OUT5 divbuf_19/OUT3 0.01fF
C514 divider_2/nor_0/B divider_2/tspc_2/a_630_n680# 0.01fF
C515 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/D 0.03fF
C516 pll_full_0/pd_0/DOWN pll_full_0/pd_0/UP 4.58fF
C517 ro_complete_0/a1 ro_complete_0/cbank_2/v 0.05fF
C518 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Q 0.20fF
C519 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/D 0.09fF
C520 divider_0/prescaler_0/tspc_0/Z2 divider_0/clk 0.11fF
C521 divider_2/tspc_0/Z4 divider_2/nor_0/B 0.02fF
C522 pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C523 divbuf_19/OUT2 divbuf_19/OUT 0.06fF
C524 divider_1/prescaler_0/tspc_2/Z2 divider_1/and_0/OUT 0.05fF
C525 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z3 0.05fF
C526 divbuf_22/OUT3 divbuf_22/OUT4 5.16fF
C527 divbuf_22/OUT2 divbuf_22/OUT5 0.02fF
C528 pll_full_0/divider_0/and_0/A pll_full_0/divider_0/and_0/B 0.18fF
C529 divider_2/tspc_0/Z2 divider_2/tspc_0/Z3 0.16fF
C530 divbuf_13/a_492_n240# divbuf_13/OUT2 0.42fF
C531 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z4 0.20fF
C532 pd_1/REF pd_1/tspc_r_1/z5 0.04fF
C533 pd_1/tspc_r_1/Z1 pd_1/tspc_r_1/Z2 0.71fF
C534 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/R 0.27fF
C535 divider_2/prescaler_0/tspc_1/Q divider_2/nor_0/A 0.03fF
C536 pll_full_0/pd_0/R pll_full_0/pd_0/UP 0.46fF
C537 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C538 divider_0/tspc_0/Z2 divider_0/tspc_0/Z3 0.16fF
C539 divider_0/tspc_0/a_630_n680# divider_0/tspc_1/Q 0.01fF
C540 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z4 0.36fF
C541 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/Out 0.05fF
C542 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z1 0.09fF
C543 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT5 0.01fF
C544 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT 0.06fF
C545 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C546 divider_1/mc2 divider_1/prescaler_0/tspc_2/a_630_n680# 0.33fF
C547 divbuf_25/a_492_n240# divbuf_25/OUT 0.00fF
C548 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/nand_1/z1 0.22fF
C549 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/tspc_0/D 0.04fF
C550 divider_1/tspc_0/Z2 divider_1/tspc_1/Q 0.14fF
C551 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z3 0.16fF
C552 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_0/B 0.18fF
C553 divider_2/prescaler_0/Out divider_2/nor_0/A 0.15fF
C554 divider_1/tspc_1/Z2 divider_1/nor_0/A 0.15fF
C555 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_0/D 0.32fF
C556 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/clk 0.01fF
C557 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C558 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Qbar1 0.12fF
C559 divbuf_24/IN divbuf_24/OUT5 0.00fF
C560 pll_full_0/pd_0/DOWN pll_full_0/pd_0/R 0.36fF
C561 divbuf_2/IN divbuf_2/a_492_n240# 0.13fF
C562 ro_complete_0/a2 ro_complete_0/cbank_1/v 0.05fF
C563 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/a0 0.13fF
C564 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/UP 0.33fF
C565 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z4 0.08fF
C566 divider_0/tspc_1/Q divider_0/tspc_1/a_630_n680# 0.04fF
C567 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z3 0.16fF
C568 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C569 divider_0/nor_0/A divider_0/tspc_2/Z2 0.23fF
C570 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z4 0.12fF
C571 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z2 1.07fF
C572 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C573 pll_full_0/ro_complete_0/a5 pll_full_0/divider_0/clk 0.15fF
C574 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z2 0.01fF
C575 divbuf_7/OUT3 divbuf_7/OUT5 0.01fF
C576 divbuf_7/OUT2 divbuf_7/OUT 0.06fF
C577 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/out1 0.31fF
C578 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/clk 0.26fF
C579 pd_1/R pd_1/REF 0.61fF
C580 pd_0/R pd_0/UP 0.45fF
C581 pd_0/tspc_r_1/Z4 pd_0/tspc_r_1/z5 0.04fF
C582 divider_2/nor_0/Z1 divider_2/and_0/B 0.18fF
C583 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Out1 0.12fF
C584 divbuf_1/OUT5 divbuf_1/OUT4 20.26fF
C585 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/v 1.43fF
C586 divider_0/tspc_2/Q divider_0/tspc_1/Z4 0.15fF
C587 divider_0/tspc_0/Z4 divider_0/nor_1/B 0.22fF
C588 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z4 0.12fF
C589 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z2 1.07fF
C590 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/IN 0.00fF
C591 pll_full_0/ro_complete_0/a1 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C592 divider_2/Out divider_2/tspc_0/a_630_n680# 0.04fF
C593 divider_0/and_0/out1 divider_0/and_0/Z1 0.36fF
C594 divider_1/tspc_2/Q divider_1/tspc_1/Z3 0.45fF
C595 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z2 0.01fF
C596 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z4 0.08fF
C597 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z3 0.05fF
C598 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Q 0.04fF
C599 divbuf_10/a_492_n240# divbuf_10/OUT5 0.01fF
C600 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_1/Z3 0.05fF
C601 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z4 0.00fF
C602 pll_full_0/divbuf_0/IN pll_full_0/divider_0/nor_1/B 0.27fF
C603 divider_2/tspc_2/Q divider_2/nor_0/B 0.22fF
C604 pd_1/REF pd_1/tspc_r_1/Z3 0.65fF
C605 pd_0/and_pd_0/Out1 pd_0/UP 0.33fF
C606 divbuf_9/OUT3 divbuf_9/OUT4 5.16fF
C607 divbuf_9/OUT2 divbuf_9/OUT5 0.02fF
C608 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C609 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C610 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/switch_5/vin 0.20fF
C611 pll_full_0/pd_0/DIV pll_full_0/divider_0/clk 2.26fF
C612 divbuf_25/a_492_n240# divbuf_25/OUT2 0.42fF
C613 divider_0/tspc_2/Q divider_0/tspc_2/Z3 0.05fF
C614 divider_0/prescaler_0/tspc_1/Z2 divider_0/clk 0.11fF
C615 divbuf_4/a_492_n240# divbuf_4/OUT 0.00fF
C616 pll_full_0/filter_0/a_4216_n5230# pll_full_0/divider_0/clk 1.58fF
C617 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/a_630_n680# 0.19fF
C618 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/D 0.05fF
C619 divbuf_20/OUT4 divbuf_20/OUT5 20.26fF
C620 divbuf_20/OUT3 divbuf_20/OUT 0.26fF
C621 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z4 0.36fF
C622 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C623 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/clk 0.64fF
C624 divider_0/tspc_0/Z2 divider_0/tspc_0/Z4 0.36fF
C625 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z3 0.11fF
C626 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C627 ro_complete_0/a4 ro_complete_0/cbank_2/switch_1/vin 0.09fF
C628 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/v 1.30fF
C629 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/switch_5/vin 0.20fF
C630 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/a0 0.13fF
C631 io_clamp_low[1] io_clamp_high[1] 0.53fF
C632 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C633 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C634 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/divider_0/clk 1.46fF
C635 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z2 0.16fF
C636 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z1 0.08fF
C637 divider_2/tspc_2/Q divider_2/tspc_1/a_630_n680# 0.01fF
C638 pll_full_0/divider_0/tspc_1/Z4 pll_full_0/divider_0/nor_0/A 0.02fF
C639 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z4 0.14fF
C640 pd_0/R pd_0/and_pd_0/Out1 0.33fF
C641 pd_0/REF pd_0/tspc_r_1/Z4 0.02fF
C642 divider_2/mc2 divider_2/nor_0/A 0.04fF
C643 divider_2/nor_0/B divider_2/tspc_1/Z2 0.30fF
C644 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z2 0.01fF
C645 divbuf_12/OUT3 divbuf_12/OUT5 0.01fF
C646 divbuf_12/OUT2 divbuf_12/OUT 0.06fF
C647 divider_2/and_0/out1 divider_2/and_0/B 0.18fF
C648 divider_0/mc2 divider_0/nor_0/A 0.04fF
C649 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C650 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C651 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/v 1.30fF
C652 divbuf_6/OUT4 divbuf_6/OUT 1.11fF
C653 pd_0/tspc_r_0/Z1 pd_0/tspc_r_0/Z2 0.71fF
C654 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_0/Z4 0.02fF
C655 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C656 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/divider_0/clk 1.27fF
C657 divbuf_17/OUT2 divbuf_17/OUT3 1.37fF
C658 divider_1/nor_0/B divider_1/tspc_1/Z4 0.21fF
C659 divider_1/tspc_0/Z3 divider_1/nor_1/B 0.38fF
C660 divbuf_11/a_492_n240# divbuf_11/OUT5 0.01fF
C661 divider_1/nor_0/A divider_1/and_0/B 0.08fF
C662 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z4 0.12fF
C663 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z2 1.07fF
C664 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z3 0.38fF
C665 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z1 0.09fF
C666 divbuf_19/OUT divbuf_19/OUT4 1.11fF
C667 divider_2/and_0/OUT divider_2/prescaler_0/nand_0/z1 0.01fF
C668 divider_2/nor_0/B divider_2/nor_0/A 1.21fF
C669 divbuf_15/OUT5 divbuf_15/IN 0.00fF
C670 divbuf_25/OUT3 divbuf_25/OUT4 5.16fF
C671 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z2 0.21fF
C672 divider_0/tspc_1/Z3 divider_0/tspc_1/Z4 0.65fF
C673 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Q 0.04fF
C674 divider_0/prescaler_0/Out divider_0/clk 0.51fF
C675 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a4 0.12fF
C676 ro_complete_0/cbank_1/switch_5/vin ro_complete_0/cbank_1/v 1.30fF
C677 ro_complete_1/a0 ro_complete_1/cbank_2/switch_5/vin 0.09fF
C678 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C679 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z4 0.12fF
C680 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C681 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Q 0.20fF
C682 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/D 0.09fF
C683 divider_1/prescaler_0/tspc_0/Z2 divider_1/clk 0.11fF
C684 divbuf_22/OUT4 divbuf_22/OUT5 20.26fF
C685 divbuf_22/OUT3 divbuf_22/OUT 0.26fF
C686 divider_2/tspc_2/Q divider_2/tspc_1/Z3 0.45fF
C687 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z2 0.01fF
C688 divider_2/tspc_0/Z2 divider_2/tspc_0/a_630_n680# 0.01fF
C689 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/z5 0.20fF
C690 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z4 0.20fF
C691 divider_2/and_0/OUT divider_2/clk 0.04fF
C692 ro_complete_0/a4 ro_complete_0/cbank_1/switch_1/vin 0.09fF
C693 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z3 0.05fF
C694 divbuf_14/OUT divbuf_14/OUT5 43.38fF
C695 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/nand_1/z1 0.01fF
C696 divider_0/prescaler_0/tspc_2/Z2 divider_0/clk 0.11fF
C697 divbuf_1/OUT divbuf_1/a_492_n240# 0.00fF
C698 pll_full_0/divbuf_1/OUT4 pll_full_0/divbuf_1/OUT 1.11fF
C699 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C700 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C701 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/Out 0.21fF
C702 divider_1/tspc_0/Z2 divider_1/tspc_0/Z3 0.16fF
C703 divider_1/tspc_0/a_630_n680# divider_1/tspc_1/Q 0.01fF
C704 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z4 0.36fF
C705 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/Out 0.05fF
C706 divbuf_21/a_492_n240# divbuf_21/OUT 0.00fF
C707 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C708 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/clk 0.45fF
C709 divider_2/prescaler_0/Out divider_2/tspc_2/Z2 0.11fF
C710 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/nand_1/z1 0.22fF
C711 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/tspc_0/D 0.04fF
C712 pd_0/R pd_0/tspc_r_1/Z2 0.21fF
C713 divider_2/nor_0/B divider_2/tspc_1/Z1 0.03fF
C714 divider_2/nor_0/A divider_2/and_0/A 0.01fF
C715 divbuf_24/OUT3 divbuf_24/OUT5 0.01fF
C716 divbuf_24/OUT2 divbuf_24/OUT 0.06fF
C717 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C718 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z4 0.36fF
C719 divider_0/tspc_2/Z1 divider_0/tspc_2/Z3 0.06fF
C720 ro_complete_1/a4 ro_complete_1/cbank_1/v 0.05fF
C721 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C722 divbuf_6/a_492_n240# divbuf_6/IN 0.13fF
C723 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/nor_1/B 0.03fF
C724 divider_1/tspc_1/Q divider_1/tspc_1/a_630_n680# 0.04fF
C725 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z3 0.16fF
C726 divbuf_7/OUT4 divbuf_7/OUT 1.11fF
C727 divider_1/nor_0/A divider_1/tspc_2/Z2 0.23fF
C728 divbuf_23/a_492_n240# divbuf_23/OUT5 0.01fF
C729 pd_1/R pd_1/tspc_r_1/Qbar1 0.30fF
C730 pd_1/tspc_r_0/Z1 pd_1/tspc_r_0/Z3 0.09fF
C731 pd_1/DOWN pd_1/tspc_r_0/z5 0.03fF
C732 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z2 0.19fF
C733 divbuf_19/OUT divbuf_19/a_492_n240# 0.00fF
C734 divider_2/prescaler_0/m1_2700_2190# divider_2/nor_0/A 0.01fF
C735 divider_2/tspc_1/Z2 divider_2/tspc_1/Z3 0.16fF
C736 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/D 0.15fF
C737 divider_2/mc2 divider_2/and_0/B 0.20fF
C738 divbuf_15/OUT4 divbuf_15/OUT3 5.16fF
C739 divbuf_15/OUT5 divbuf_15/OUT2 0.02fF
C740 ro_complete_0/a5 ro_complete_0/cbank_2/v 0.08fF
C741 ro_complete_0/a0 ro_complete_0/cbank_1/switch_5/vin 0.09fF
C742 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C743 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z3 0.16fF
C744 divider_0/mc2 divider_0/and_0/B 0.20fF
C745 pll_full_0/pd_0/DIV pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C746 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT3 1.37fF
C747 divbuf_3/OUT3 divbuf_3/OUT5 0.01fF
C748 divbuf_10/OUT2 divbuf_10/OUT3 1.37fF
C749 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C750 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/and_0/OUT 0.14fF
C751 divider_1/tspc_2/Q divider_1/tspc_1/Z4 0.15fF
C752 divider_1/tspc_0/Z4 divider_1/nor_1/B 0.22fF
C753 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z4 0.12fF
C754 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z2 1.07fF
C755 divider_1/and_0/out1 divider_1/and_0/Z1 0.36fF
C756 divbuf_9/OUT4 divbuf_9/OUT5 20.26fF
C757 divbuf_9/OUT3 divbuf_9/OUT 0.26fF
C758 cp_0/a_10_n50# cp_0/vbias 0.19fF
C759 cp_0/a_1710_n2840# cp_0/out 0.61fF
C760 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Qbar1 0.38fF
C761 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C762 divider_2/nor_0/B divider_2/and_0/B 0.31fF
C763 divbuf_0/OUT4 divbuf_0/OUT5 20.26fF
C764 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C765 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/z5 0.11fF
C766 divider_0/nor_1/Z1 divider_0/nor_0/B 0.18fF
C767 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/v 1.30fF
C768 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C769 divbuf_4/IN divbuf_4/OUT5 0.00fF
C770 ro_complete_1/cbank_1/v ro_complete_1/cbank_2/v 1.36fF
C771 divbuf_20/OUT5 divbuf_20/OUT 43.38fF
C772 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C773 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/clk 0.12fF
C774 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/D 0.11fF
C775 divider_1/tspc_2/Q divider_1/tspc_2/Z3 0.05fF
C776 divider_1/prescaler_0/tspc_1/Z2 divider_1/clk 0.11fF
C777 divbuf_8/a_492_n240# divbuf_8/OUT 0.00fF
C778 pd_0/DOWN pd_0/tspc_r_0/Qbar 0.21fF
C779 divider_2/tspc_0/Z2 divider_2/tspc_1/Q 0.14fF
C780 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z3 0.06fF
C781 divider_2/nor_0/A divider_2/tspc_2/Z1 0.03fF
C782 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z3 0.05fF
C783 divbuf_2/OUT2 divbuf_2/OUT3 1.37fF
C784 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z4 0.12fF
C785 divider_0/tspc_1/Q divider_0/tspc_0/Z3 0.45fF
C786 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z4 0.28fF
C787 ro_complete_1/a5 ro_complete_1/cbank_1/switch_0/vin 0.09fF
C788 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/v 1.30fF
C789 divider_0/and_0/OUT divider_0/and_0/B 0.01fF
C790 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C791 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/Z2 0.36fF
C792 divider_1/tspc_0/Z2 divider_1/tspc_0/Z4 0.36fF
C793 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z3 0.11fF
C794 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/a_630_n680# 0.19fF
C795 divbuf_5/IN divbuf_5/OUT5 0.00fF
C796 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divbuf_0/IN 0.04fF
C797 divbuf_7/a_492_n240# divbuf_7/IN 0.13fF
C798 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/clk 0.45fF
C799 divbuf_12/OUT4 divbuf_12/OUT 1.11fF
C800 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/z5 0.11fF
C801 divider_2/tspc_1/Z1 divider_2/tspc_1/Z3 0.06fF
C802 divider_2/and_0/A divider_2/and_0/B 0.18fF
C803 ro_complete_1/a2 ro_complete_1/cbank_0/switch_3/vin 0.09fF
C804 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Q 0.91fF
C805 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C806 ro_complete_1/cbank_1/switch_2/vin ro_complete_1/cbank_1/v 1.30fF
C807 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/v 0.08fF
C808 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C809 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C810 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C811 divbuf_11/OUT2 divbuf_11/OUT3 1.37fF
C812 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z3 0.16fF
C813 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z4 0.21fF
C814 divider_2/prescaler_0/tspc_2/D divider_2/prescaler_0/nand_0/z1 0.24fF
C815 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z3 0.65fF
C816 divbuf_2/OUT5 divbuf_2/a_492_n240# 0.01fF
C817 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/v 1.30fF
C818 ro_complete_0/cbank_0/v ro_complete_0/cbank_2/v 0.04fF
C819 pll_full_0/divbuf_0/OUT4 pll_full_0/divbuf_0/OUT5 20.26fF
C820 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C821 ro_complete_1/a0 ro_complete_1/cbank_2/v 0.05fF
C822 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/IN 0.13fF
C823 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C824 divider_1/tspc_1/Z3 divider_1/tspc_1/Z4 0.65fF
C825 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Q 0.04fF
C826 divider_1/prescaler_0/Out divider_1/clk 0.51fF
C827 divbuf_20/a_492_n240# divbuf_20/OUT2 0.42fF
C828 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C829 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C830 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C831 divider_2/tspc_2/Q divider_2/tspc_1/Z4 0.15fF
C832 divbuf_22/OUT5 divbuf_22/OUT 43.38fF
C833 pll_full_0/divider_0/and_0/B pll_full_0/divider_0/and_0/Z1 0.07fF
C834 divbuf_13/a_492_n240# divbuf_13/OUT 0.00fF
C835 pd_1/DOWN pd_1/UP 0.46fF
C836 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/Qbar 0.21fF
C837 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/z5 0.20fF
C838 divider_2/and_0/OUT divider_2/and_0/out1 0.31fF
C839 divider_2/prescaler_0/tspc_2/D divider_2/clk 0.26fF
C840 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C841 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C842 divbuf_2/OUT3 divbuf_2/OUT 0.26fF
C843 divbuf_14/a_492_n240# divbuf_14/OUT5 0.01fF
C844 divider_0/prescaler_0/tspc_0/D divider_0/prescaler_0/nand_1/z1 0.21fF
C845 divider_1/tspc_0/a_630_n680# divider_1/tspc_0/Z3 0.05fF
C846 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/nor_0/B 0.20fF
C847 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/nand_1/z1 0.01fF
C848 divider_1/prescaler_0/tspc_2/Z2 divider_1/clk 0.11fF
C849 divbuf_21/IN divbuf_21/OUT5 0.00fF
C850 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/clk 0.12fF
C851 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z1 0.71fF
C852 pd_0/REF pd_0/tspc_r_1/Z3 0.65fF
C853 divider_2/tspc_2/Q divider_2/tspc_2/Z3 0.05fF
C854 divider_2/nor_0/B divider_2/tspc_1/Q 0.51fF
C855 divbuf_12/a_492_n240# divbuf_12/IN 0.13fF
C856 divbuf_24/OUT4 divbuf_24/OUT 1.11fF
C857 divider_0/tspc_1/Q divider_0/tspc_0/Z4 0.15fF
C858 divbuf_3/OUT2 divbuf_3/a_492_n240# 0.42fF
C859 divider_0/tspc_2/Z1 divider_0/tspc_2/Z4 0.00fF
C860 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z4 0.36fF
C861 divider_1/tspc_2/Z1 divider_1/tspc_2/Z3 0.06fF
C862 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/clk 0.60fF
C863 divider_2/tspc_1/Z2 divider_2/tspc_1/Z4 0.36fF
C864 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/D 0.05fF
C865 divbuf_23/OUT2 divbuf_23/OUT3 1.37fF
C866 divbuf_15/OUT divbuf_15/OUT3 0.26fF
C867 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z4 0.36fF
C868 divbuf_2/OUT3 divbuf_2/OUT4 5.16fF
C869 ro_complete_0/a0 ro_complete_0/cbank_1/v 0.05fF
C870 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT4 5.16fF
C871 divbuf_3/a_492_n240# divbuf_3/OUT 0.00fF
C872 ro_complete_1/a3 ro_complete_1/cbank_2/v 0.05fF
C873 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_0/B 0.06fF
C874 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/ro_complete_0/cbank_2/v 0.04fF
C875 divbuf_10/OUT3 divbuf_10/OUT4 5.16fF
C876 divbuf_10/OUT2 divbuf_10/OUT5 0.02fF
C877 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C878 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z3 0.16fF
C879 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C880 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C881 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C882 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Q 0.04fF
C883 divbuf_22/a_492_n240# divbuf_22/OUT2 0.42fF
C884 pd_1/DOWN pd_1/and_pd_0/Out1 0.12fF
C885 pd_1/REF pd_1/tspc_r_1/Z1 0.17fF
C886 divider_2/tspc_1/Z4 divider_2/nor_0/A 0.02fF
C887 divbuf_9/OUT5 divbuf_9/OUT 43.38fF
C888 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/Out 0.21fF
C889 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z2 0.01fF
C890 divbuf_0/OUT4 divbuf_0/OUT 1.11fF
C891 ro_complete_1/a4 ro_complete_1/cbank_1/switch_1/vin 0.09fF
C892 ro_complete_0/cbank_2/switch_0/vin ro_complete_0/cbank_2/v 1.45fF
C893 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C894 divbuf_4/OUT3 divbuf_4/OUT5 0.01fF
C895 divbuf_4/OUT2 divbuf_4/OUT 0.06fF
C896 divider_1/nor_1/Z1 divider_1/nor_0/B 0.18fF
C897 divider_2/mc2 divider_2/and_0/OUT 0.05fF
C898 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z4 0.00fF
C899 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/D 0.03fF
C900 divbuf_8/IN divbuf_8/OUT5 0.00fF
C901 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Z1 0.02fF
C902 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z4 0.12fF
C903 divider_2/tspc_2/Z1 divider_2/tspc_2/Z2 1.07fF
C904 divider_2/nor_0/A divider_2/tspc_2/Z3 0.38fF
C905 divbuf_24/a_492_n240# divbuf_24/IN 0.13fF
C906 divider_0/mc2 divider_0/and_0/OUT 0.05fF
C907 divider_0/tspc_0/Z1 divider_0/nor_1/B 0.03fF
C908 divbuf_2/OUT2 divbuf_2/OUT5 0.02fF
C909 divbuf_1/OUT2 divbuf_1/OUT 0.06fF
C910 ro_complete_0/a2 ro_complete_0/cbank_2/switch_2/vin 0.14fF
C911 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/v 1.30fF
C912 ro_complete_1/a3 ro_complete_1/cbank_1/switch_2/vin 0.09fF
C913 divbuf_5/OUT3 divbuf_5/OUT5 0.01fF
C914 divbuf_5/OUT2 divbuf_5/OUT 0.06fF
C915 io_clamp_low[0] io_clamp_high[0] 0.53fF
C916 divider_1/tspc_0/a_630_n680# divider_1/tspc_0/Z4 0.12fF
C917 divider_1/tspc_1/Q divider_1/tspc_0/Z3 0.45fF
C918 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z4 0.28fF
C919 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/clk 0.12fF
C920 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/Z2 1.07fF
C921 divider_1/and_0/OUT divider_1/and_0/B 0.01fF
C922 divider_2/tspc_1/Q divider_2/tspc_1/Z3 0.05fF
C923 divider_2/tspc_1/Z1 divider_2/tspc_1/Z4 0.00fF
C924 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z3 0.06fF
C925 divbuf_15/OUT divbuf_15/a_492_n240# 0.00fF
C926 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/D 0.09fF
C927 ro_complete_1/a2 ro_complete_1/cbank_2/switch_3/vin 0.09fF
C928 divbuf_0/OUT5 divbuf_0/OUT2 0.02fF
C929 ro_complete_0/a3 ro_complete_0/cbank_1/v 0.05fF
C930 divbuf_25/OUT2 divbuf_25/OUT 0.06fF
C931 divbuf_1/OUT4 divbuf_1/OUT3 5.16fF
C932 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/switch_5/vin 0.20fF
C933 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z1 0.08fF
C934 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Q 0.91fF
C935 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/a_630_n680# 0.19fF
C936 divbuf_11/OUT3 divbuf_11/OUT4 5.16fF
C937 divbuf_11/OUT2 divbuf_11/OUT5 0.02fF
C938 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z4 0.36fF
C939 divbuf_19/OUT2 divbuf_19/OUT3 1.37fF
C940 divbuf_18/OUT4 divbuf_18/OUT 1.11fF
C941 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/Q 0.04fF
C942 divider_2/prescaler_0/tspc_1/Z3 divider_2/clk 0.45fF
C943 divbuf_9/a_492_n240# divbuf_9/OUT2 0.42fF
C944 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Qbar1 0.38fF
C945 divider_0/tspc_0/Z1 divider_0/tspc_0/Z2 1.07fF
C946 divbuf_14/IN divbuf_14/OUT5 0.00fF
C947 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a5 0.09fF
C948 pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_0/ro_complete_0/cbank_2/v 1.45fF
C949 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/nor_0/A 0.15fF
C950 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C951 pll_full_0/ro_complete_0/cbank_2/v pll_full_0/divider_0/clk 1.36fF
C952 pd_1/tspc_r_1/Z2 pd_1/tspc_r_1/Z4 0.14fF
C953 divbuf_13/IN divbuf_13/OUT5 0.00fF
C954 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C955 divider_0/prescaler_0/Out divider_0/prescaler_0/m1_2700_2190# 0.11fF
C956 divider_1/mc2 divider_1/nor_1/B 0.15fF
C957 divbuf_2/OUT5 divbuf_2/OUT 43.38fF
C958 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C959 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/v 1.30fF
C960 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C961 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C962 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C963 divbuf_5/a_492_n240# divbuf_5/OUT2 0.42fF
C964 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_1/Q 0.01fF
C965 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C966 divbuf_21/OUT3 divbuf_21/OUT5 0.01fF
C967 divbuf_21/OUT2 divbuf_21/OUT 0.06fF
C968 pd_0/DIV pd_0/tspc_r_0/z5 0.04fF
C969 divider_1/prescaler_0/tspc_0/D divider_1/prescaler_0/nand_1/z1 0.21fF
C970 pd_0/tspc_r_0/Z3 pd_0/R 0.27fF
C971 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Qbar1 0.38fF
C972 io_clamp_high[2] io_analog[6] 0.53fF
C973 divider_2/prescaler_0/m1_2700_2190# divider_2/and_0/OUT 0.14fF
C974 divider_0/nor_0/B divider_0/nor_1/B 0.47fF
C975 divider_0/tspc_0/Z3 divider_0/tspc_0/Z4 0.65fF
C976 divbuf_14/OUT5 divbuf_14/OUT4 20.26fF
C977 divider_0/tspc_2/Z3 divider_0/tspc_2/Z4 0.65fF
C978 ro_complete_1/a5 ro_complete_1/cbank_1/v 0.10fF
C979 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/cbank_0/v 1.30fF
C980 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/OUT2 0.02fF
C981 divider_1/tspc_1/Q divider_1/tspc_0/Z4 0.15fF
C982 divbuf_6/a_492_n240# divbuf_6/OUT5 0.01fF
C983 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divbuf_0/IN 0.05fF
C984 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C985 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/A 0.80fF
C986 pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_0/divider_0/clk 1.46fF
C987 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/Z1 0.04fF
C988 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/clk 0.05fF
C989 divbuf_19/IN divbuf_19/a_492_n240# 0.13fF
C990 divider_1/tspc_2/Z1 divider_1/tspc_2/Z4 0.00fF
C991 divbuf_23/OUT3 divbuf_23/OUT4 5.16fF
C992 divbuf_23/OUT2 divbuf_23/OUT5 0.02fF
C993 pd_1/tspc_r_0/Qbar1 pd_1/tspc_r_0/Z3 0.38fF
C994 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/z5 0.04fF
C995 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Z1 0.02fF
C996 divider_2/prescaler_0/tspc_2/Z4 divider_2/prescaler_0/tspc_2/D 0.11fF
C997 divbuf_2/OUT4 divbuf_2/OUT5 20.26fF
C998 divbuf_14/OUT2 divbuf_14/OUT5 0.02fF
C999 divider_0/nor_0/B divider_0/tspc_2/a_630_n680# 0.01fF
C1000 divider_1/nor_0/Z1 divider_1/nor_0/B 0.06fF
C1001 pd_0/DOWN pd_0/UP 0.46fF
C1002 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z4 0.36fF
C1003 divbuf_10/OUT4 divbuf_10/OUT5 20.26fF
C1004 divbuf_10/OUT3 divbuf_10/OUT 0.26fF
C1005 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C1006 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C1007 pd_0/tspc_r_0/Qbar1 pd_0/DIV 0.12fF
C1008 pd_1/REF pd_1/tspc_r_1/Z2 0.19fF
C1009 divider_2/prescaler_0/tspc_2/Z3 divider_2/clk 0.45fF
C1010 divbuf_0/OUT5 divbuf_0/OUT 43.38fF
C1011 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1012 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/tspc_r_1/Z4 0.14fF
C1013 divider_0/tspc_0/Z2 divider_0/nor_0/B 0.20fF
C1014 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/Out 0.04fF
C1015 ro_complete_1/a2 ro_complete_1/cbank_1/v 0.05fF
C1016 divbuf_4/OUT4 divbuf_4/OUT 1.11fF
C1017 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/Out 0.21fF
C1018 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z2 0.01fF
C1019 pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1020 divider_2/nor_1/Z1 divider_2/nor_1/B 0.06fF
C1021 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C1022 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/clk 0.01fF
C1023 divbuf_8/OUT3 divbuf_8/OUT5 0.01fF
C1024 divbuf_8/OUT2 divbuf_8/OUT 0.06fF
C1025 divbuf_18/OUT3 divbuf_18/OUT4 5.16fF
C1026 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Z4 0.65fF
C1027 pd_1/tspc_r_1/Qbar1 pd_1/UP 0.11fF
C1028 divider_2/tspc_2/Z2 divider_2/tspc_2/Z3 0.16fF
C1029 divider_2/nor_0/A divider_2/tspc_2/Z4 0.21fF
C1030 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_5/vin 0.20fF
C1031 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1032 ro_complete_1/a3 ro_complete_1/cbank_2/switch_1/vin 0.13fF
C1033 pd_0/DOWN pd_0/R 0.36fF
C1034 divbuf_5/OUT4 divbuf_5/OUT 1.11fF
C1035 divider_1/tspc_0/Z1 divider_1/nor_1/B 0.03fF
C1036 divbuf_7/a_492_n240# divbuf_7/OUT5 0.01fF
C1037 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z3 0.25fF
C1038 pd_0/tspc_r_1/Z2 pd_0/tspc_r_1/Z4 0.14fF
C1039 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z4 0.00fF
C1040 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Q 0.21fF
C1041 divbuf_19/OUT3 divbuf_19/OUT4 5.16fF
C1042 divider_2/and_0/B divider_2/and_0/Z1 0.07fF
C1043 ro_complete_1/a2 ro_complete_1/cbank_0/switch_2/vin 0.14fF
C1044 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/a4 0.09fF
C1045 divbuf_0/OUT divbuf_0/OUT2 0.06fF
C1046 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_0/vin 0.19fF
C1047 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/v 1.30fF
C1048 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/v 1.30fF
C1049 pd_0/DOWN pd_0/and_pd_0/Out1 0.12fF
C1050 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z3 0.11fF
C1051 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/D 0.09fF
C1052 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C1053 divbuf_11/OUT4 divbuf_11/OUT5 20.26fF
C1054 divbuf_11/OUT3 divbuf_11/OUT 0.26fF
C1055 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/z5 0.20fF
C1056 divider_2/prescaler_0/tspc_1/Z4 divider_2/clk 0.12fF
C1057 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C1058 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z1 0.17fF
C1059 pd_0/tspc_r_0/Z2 pd_0/R 0.21fF
C1060 divbuf_1/OUT5 divbuf_1/IN 0.00fF
C1061 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1062 divider_0/tspc_2/Q divider_0/tspc_2/a_630_n680# 0.04fF
C1063 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/D 0.03fF
C1064 divbuf_4/a_492_n240# divbuf_4/IN 0.13fF
C1065 ro_complete_1/cbank_2/switch_2/vin ro_complete_1/cbank_2/v 1.30fF
C1066 divider_1/tspc_0/Z1 divider_1/tspc_0/Z2 1.07fF
C1067 divbuf_20/a_492_n240# divbuf_20/OUT 0.00fF
C1068 divbuf_16/OUT2 divbuf_16/OUT 0.06fF
C1069 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z2 0.11fF
C1070 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C1071 divider_2/prescaler_0/tspc_0/Z2 divider_2/and_0/OUT 0.06fF
C1072 divbuf_13/OUT3 divbuf_13/OUT5 0.01fF
C1073 divbuf_13/OUT2 divbuf_13/OUT 0.06fF
C1074 divider_2/prescaler_0/tspc_1/Q divider_2/clk 0.60fF
C1075 divider_0/nor_0/B divider_0/tspc_1/Z1 0.03fF
C1076 divbuf_0/OUT5 divbuf_0/a_492_n240# 0.01fF
C1077 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_4/vin 0.20fF
C1078 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/UP 0.03fF
C1079 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C1080 divider_0/prescaler_0/tspc_1/Q divider_0/nor_0/A 0.03fF
C1081 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z3 0.06fF
C1082 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C1083 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1084 divider_1/prescaler_0/Out divider_1/prescaler_0/m1_2700_2190# 0.11fF
C1085 divbuf_21/OUT4 divbuf_21/OUT 1.11fF
C1086 divider_2/prescaler_0/Out divider_2/clk 0.51fF
C1087 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C1088 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/clk 0.01fF
C1089 pd_0/tspc_r_0/Z4 pd_0/tspc_r_1/Z4 0.02fF
C1090 pd_0/REF pd_0/tspc_r_1/Z1 0.17fF
C1091 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z4 0.20fF
C1092 io_clamp_low[1] io_analog[5] 0.53fF
C1093 divider_2/nor_1/B divider_2/tspc_0/Z1 0.03fF
C1094 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_2/D 0.16fF
C1095 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/clk 0.01fF
C1096 divbuf_12/a_492_n240# divbuf_12/OUT5 0.01fF
C1097 divider_0/nor_0/B divider_0/tspc_1/Z2 0.30fF
C1098 ro_complete_0/a4 ro_complete_0/cbank_1/v 0.05fF
C1099 divbuf_3/IN divbuf_3/OUT5 0.00fF
C1100 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C1101 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1102 divider_1/mc2 divider_1/nor_0/A 0.04fF
C1103 divbuf_14/OUT5 divbuf_14/OUT3 0.01fF
C1104 divbuf_6/OUT2 divbuf_6/OUT3 1.37fF
C1105 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Q 0.22fF
C1106 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/nor_1/B 0.35fF
C1107 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C1108 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C1109 divider_1/nor_0/B divider_1/nor_1/B 0.47fF
C1110 divider_1/tspc_0/Z3 divider_1/tspc_0/Z4 0.65fF
C1111 divider_1/nor_0/Z1 divider_1/and_0/A 0.80fF
C1112 divbuf_16/OUT divbuf_16/OUT5 43.38fF
C1113 divider_1/tspc_2/Z3 divider_1/tspc_2/Z4 0.65fF
C1114 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/nor_0/A 0.35fF
C1115 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/clk 0.29fF
C1116 cp_0/a_1710_0# cp_0/out 0.84fF
C1117 pd_1/R pd_1/tspc_r_1/Qbar 0.03fF
C1118 pd_0/tspc_r_1/Z3 pd_0/UP 0.03fF
C1119 divbuf_18/OUT5 divbuf_18/OUT4 20.26fF
C1120 divbuf_23/OUT4 divbuf_23/OUT5 20.26fF
C1121 divbuf_23/OUT3 divbuf_23/OUT 0.26fF
C1122 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z3 0.29fF
C1123 divbuf_25/OUT4 divbuf_25/OUT5 20.26fF
C1124 divbuf_25/OUT3 divbuf_25/OUT 0.26fF
C1125 divider_0/prescaler_0/Out divider_0/tspc_2/Z3 0.45fF
C1126 divider_0/nor_0/B divider_0/nor_0/A 1.21fF
C1127 divbuf_0/a_492_n240# divbuf_0/OUT2 0.42fF
C1128 divider_2/tspc_0/Z4 divider_2/nor_1/B 0.22fF
C1129 divbuf_3/OUT4 divbuf_3/OUT 1.11fF
C1130 ro_complete_1/a1 ro_complete_1/cbank_2/v 0.05fF
C1131 divbuf_10/OUT5 divbuf_10/OUT 43.38fF
C1132 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_1/B 0.00fF
C1133 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C1134 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1135 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C1136 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C1137 divbuf_16/OUT3 divbuf_16/OUT 0.26fF
C1138 divider_1/nor_0/B divider_1/tspc_2/a_630_n680# 0.01fF
C1139 divbuf_22/a_492_n240# divbuf_22/OUT 0.00fF
C1140 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/A 0.01fF
C1141 divider_2/prescaler_0/tspc_2/Z4 divider_2/clk 0.12fF
C1142 divbuf_0/OUT4 divbuf_0/OUT3 5.16fF
C1143 pd_0/DIV pd_0/tspc_r_0/Z1 0.17fF
C1144 divider_0/tspc_0/Z1 divider_0/tspc_1/Q 0.01fF
C1145 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z3 0.06fF
C1146 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT 0.00fF
C1147 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/a_492_n240# 0.01fF
C1148 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C1149 divider_1/tspc_0/Z2 divider_1/nor_0/B 0.20fF
C1150 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/Out 0.04fF
C1151 divbuf_21/a_492_n240# divbuf_21/IN 0.13fF
C1152 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C1153 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/A 0.26fF
C1154 divbuf_8/OUT4 divbuf_8/OUT 1.11fF
C1155 pd_0/R pd_0/tspc_r_1/Z3 0.29fF
C1156 divider_2/tspc_2/Z2 divider_2/tspc_2/Z4 0.36fF
C1157 divbuf_24/a_492_n240# divbuf_24/OUT5 0.01fF
C1158 ro_complete_0/a5 ro_complete_0/cbank_1/switch_0/vin 0.09fF
C1159 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/v 1.30fF
C1160 divider_0/tspc_1/Z1 divider_0/tspc_2/Q 0.01fF
C1161 divider_0/nor_0/B divider_0/tspc_1/a_630_n680# 0.35fF
C1162 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/IN 5.26fF
C1163 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/clk 0.14fF
C1164 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C1165 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z4 0.00fF
C1166 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/divider_0/clk 1.46fF
C1167 divbuf_7/OUT2 divbuf_7/OUT3 1.37fF
C1168 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/B 0.29fF
C1169 pd_1/R pd_1/tspc_r_0/Z3 0.27fF
C1170 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Z4 0.65fF
C1171 divbuf_15/OUT4 divbuf_15/OUT5 20.26fF
C1172 ro_complete_0/a1 ro_complete_0/cbank_1/v 0.05fF
C1173 divbuf_25/OUT3 divbuf_25/OUT2 1.37fF
C1174 divider_0/nor_0/Z1 divider_0/and_0/B 0.18fF
C1175 divider_0/tspc_2/Q divider_0/tspc_1/Z2 0.14fF
C1176 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z2 0.01fF
C1177 divider_1/mc2 divider_1/and_0/B 0.20fF
C1178 divider_0/and_0/out1 divider_0/and_0/B 0.18fF
C1179 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/cbank_1/v 1.43fF
C1180 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/OUT2 0.42fF
C1181 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z4 0.28fF
C1182 divbuf_10/a_492_n240# divbuf_10/OUT2 0.42fF
C1183 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z2 1.07fF
C1184 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z3 0.38fF
C1185 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_1/B 0.22fF
C1186 divbuf_11/OUT5 divbuf_11/OUT 43.38fF
C1187 divbuf_9/a_492_n240# divbuf_9/OUT 0.00fF
C1188 pd_1/R pd_1/and_pd_0/Z1 0.02fF
C1189 ro_complete_0/a2 ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1190 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/tspc_r_1/z5 0.02fF
C1191 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z2 0.25fF
C1192 pd_0/tspc_r_0/Z2 pd_0/tspc_r_0/Z4 0.14fF
C1193 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C1194 divbuf_14/OUT divbuf_14/a_492_n240# 0.00fF
C1195 divider_0/nor_0/B divider_0/and_0/B 0.31fF
C1196 divider_0/tspc_2/Q divider_0/nor_0/A 0.55fF
C1197 divider_0/and_0/OUT divider_0/prescaler_0/nand_0/z1 0.01fF
C1198 pll_full_0/divbuf_0/OUT4 pll_full_0/divbuf_0/OUT3 5.16fF
C1199 divider_2/tspc_0/Z4 divider_2/tspc_0/Z1 0.00fF
C1200 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/switch_5/vin 0.20fF
C1201 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Q 0.91fF
C1202 divider_1/tspc_2/Q divider_1/tspc_2/a_630_n680# 0.04fF
C1203 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/D 0.03fF
C1204 divbuf_20/IN divbuf_20/OUT5 0.00fF
C1205 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/and_0/OUT 0.05fF
C1206 divbuf_8/a_492_n240# divbuf_8/IN 0.13fF
C1207 divider_2/tspc_0/Z3 divider_2/nor_1/B 0.38fF
C1208 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z3 0.33fF
C1209 divbuf_13/OUT4 divbuf_13/OUT 1.11fF
C1210 divbuf_18/OUT divbuf_18/a_492_n240# 0.00fF
C1211 divider_2/and_0/OUT divider_2/and_0/Z1 0.04fF
C1212 divider_2/prescaler_0/tspc_2/Q divider_2/clk 0.05fF
C1213 divbuf_0/OUT divbuf_0/a_492_n240# 0.00fF
C1214 divider_0/nor_0/B divider_0/tspc_1/Q 0.51fF
C1215 divbuf_1/OUT5 divbuf_1/OUT3 0.01fF
C1216 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z4 0.65fF
C1217 divider_0/and_0/OUT divider_0/clk 0.04fF
C1218 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C1219 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1220 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_0/a_630_n680# 0.04fF
C1221 divider_1/nor_0/B divider_1/tspc_1/Z1 0.03fF
C1222 divbuf_5/a_492_n240# divbuf_5/OUT 0.00fF
C1223 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1224 divider_1/prescaler_0/tspc_1/Q divider_1/nor_0/A 0.03fF
C1225 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_0/A 0.15fF
C1226 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C1227 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C1228 divbuf_12/OUT2 divbuf_12/OUT3 1.37fF
C1229 pd_1/R pd_1/tspc_r_0/Qbar1 0.01fF
C1230 pd_1/tspc_r_0/Qbar pd_1/DOWN 0.21fF
C1231 pd_0/tspc_r_0/z5 pd_0/tspc_r_1/z5 0.02fF
C1232 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z2 0.25fF
C1233 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/nand_0/z1 0.07fF
C1234 ro_complete_0/a3 ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1235 divider_0/tspc_1/Z1 divider_0/tspc_1/Z3 0.06fF
C1236 divider_0/tspc_2/Q divider_0/tspc_1/a_630_n680# 0.01fF
C1237 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C1238 divider_0/nor_0/A divider_0/and_0/A 0.01fF
C1239 divider_1/nor_0/B divider_1/tspc_1/Z2 0.30fF
C1240 divbuf_6/OUT3 divbuf_6/OUT4 5.16fF
C1241 divbuf_6/OUT2 divbuf_6/OUT5 0.02fF
C1242 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C1243 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1244 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/divider_0/clk 1.46fF
C1245 divbuf_17/a_492_n240# divbuf_17/OUT5 0.01fF
C1246 divbuf_16/OUT divbuf_16/OUT4 1.11fF
C1247 divbuf_11/a_492_n240# divbuf_11/OUT2 0.42fF
C1248 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z2 0.01fF
C1249 divbuf_23/OUT5 divbuf_23/OUT 43.38fF
C1250 pd_1/tspc_r_0/Z4 pd_1/DIV 0.02fF
C1251 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Q 0.05fF
C1252 divider_2/prescaler_0/m1_2700_2190# divider_2/clk 0.01fF
C1253 pll_full_0/cp_0/a_1710_0# pll_full_0/cp_0/down 0.32fF
C1254 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C1255 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/v 1.30fF
C1256 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1257 divider_0/prescaler_0/m1_2700_2190# divider_0/nor_0/A 0.01fF
C1258 divider_0/prescaler_0/Out divider_0/tspc_2/Z4 0.12fF
C1259 divider_0/tspc_1/Z2 divider_0/tspc_1/Z3 0.16fF
C1260 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/D 0.15fF
C1261 ro_complete_1/cbank_1/switch_5/vin ro_complete_1/cbank_1/v 1.30fF
C1262 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z4 0.01fF
C1263 divbuf_19/OUT2 divbuf_19/OUT5 0.02fF
C1264 divider_1/prescaler_0/Out divider_1/tspc_2/Z3 0.45fF
C1265 divider_1/nor_0/B divider_1/nor_0/A 1.21fF
C1266 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z3 0.45fF
C1267 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z2 0.01fF
C1268 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1269 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1270 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C1271 divider_2/nor_0/Z1 divider_2/nor_0/B 0.06fF
C1272 divbuf_22/IN divbuf_22/OUT5 0.00fF
C1273 divbuf_13/a_492_n240# divbuf_13/IN 0.13fF
C1274 pd_1/REF pd_1/tspc_r_1/Z4 0.02fF
C1275 divider_0/tspc_0/Z1 divider_0/tspc_0/Z3 0.06fF
C1276 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1277 divbuf_0/OUT5 divbuf_0/OUT3 0.01fF
C1278 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1279 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT5 0.02fF
C1280 divbuf_25/a_492_n240# divbuf_25/OUT5 0.01fF
C1281 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Q 0.15fF
C1282 divider_1/tspc_0/Z1 divider_1/tspc_1/Q 0.01fF
C1283 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z3 0.06fF
C1284 pd_1/tspc_r_0/Z2 pd_1/R 0.21fF
C1285 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z3 0.65fF
C1286 divbuf_17/a_492_n240# divbuf_17/OUT 0.00fF
C1287 divider_2/tspc_2/Q divider_2/tspc_2/a_630_n680# 0.04fF
C1288 divider_2/tspc_0/Z3 divider_2/tspc_0/Z1 0.06fF
C1289 divbuf_24/OUT2 divbuf_24/OUT3 1.37fF
C1290 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/Out 0.21fF
C1291 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z3 0.06fF
C1292 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1293 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/a_630_n680# 0.19fF
C1294 divbuf_25/IN divbuf_25/OUT5 0.00fF
C1295 divider_0/nor_0/A divider_0/tspc_2/Z1 0.03fF
C1296 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z3 0.05fF
C1297 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C1298 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_1/B 0.06fF
C1299 divider_1/tspc_1/Z1 divider_1/tspc_2/Q 0.01fF
C1300 divider_1/nor_0/B divider_1/tspc_1/a_630_n680# 0.35fF
C1301 divbuf_7/OUT3 divbuf_7/OUT4 5.16fF
C1302 divbuf_7/OUT2 divbuf_7/OUT5 0.02fF
C1303 divider_2/mc2 divider_2/and_0/out1 0.06fF
C1304 divider_2/nor_0/Z1 divider_2/and_0/A 0.80fF
C1305 divbuf_23/a_492_n240# divbuf_23/OUT2 0.42fF
C1306 divbuf_15/OUT5 divbuf_15/OUT 43.38fF
C1307 divider_0/mc2 divider_0/and_0/out1 0.06fF
C1308 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z3 0.05fF
C1309 divbuf_0/OUT3 divbuf_0/OUT2 1.37fF
C1310 pll_full_0/pd_0/REF pll_full_0/divbuf_1/OUT5 0.00fF
C1311 divbuf_3/a_492_n240# divbuf_3/OUT5 0.01fF
C1312 ro_complete_1/a0 ro_complete_1/cbank_1/switch_5/vin 0.09fF
C1313 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1314 divider_2/tspc_0/Z4 divider_2/tspc_0/Z3 0.65fF
C1315 divider_0/and_0/A divider_0/and_0/B 0.18fF
C1316 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z4 0.21fF
C1317 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/nor_1/B 0.38fF
C1318 divider_1/tspc_2/Q divider_1/tspc_1/Z2 0.14fF
C1319 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z2 0.01fF
C1320 divider_2/nor_1/Z1 divider_2/and_0/B 0.78fF
C1321 divider_1/and_0/out1 divider_1/and_0/B 0.18fF
C1322 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/B 0.08fF
C1323 pll_full_0/pd_0/DIV pll_full_0/pd_0/R 0.51fF
C1324 divbuf_17/OUT5 divbuf_17/OUT 43.38fF
C1325 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_2/Q 0.19fF
C1326 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/clk 0.01fF
C1327 divider_2/nor_1/B divider_2/and_0/B 0.29fF
C1328 divbuf_9/IN divbuf_9/OUT5 0.00fF
C1329 divider_0/mc2 divider_0/nor_0/B 0.06fF
C1330 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/a4 0.12fF
C1331 ro_complete_0/a2 ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1332 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Qbar 0.01fF
C1333 divider_0/prescaler_0/tspc_2/D divider_0/prescaler_0/nand_0/z1 0.24fF
C1334 ro_complete_1/a2 ro_complete_1/cbank_2/switch_2/vin 0.14fF
C1335 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/OUT3 0.01fF
C1336 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1337 divbuf_4/a_492_n240# divbuf_4/OUT5 0.01fF
C1338 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/v 1.30fF
C1339 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z2 1.07fF
C1340 divbuf_20/OUT3 divbuf_20/OUT5 0.01fF
C1341 divbuf_20/OUT2 divbuf_20/OUT 0.06fF
C1342 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C1343 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C1344 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/clk 0.11fF
C1345 divider_1/nor_0/B divider_1/and_0/B 0.31fF
C1346 divider_1/tspc_2/Q divider_1/nor_0/A 0.55fF
C1347 divider_1/and_0/OUT divider_1/prescaler_0/nand_0/z1 0.01fF
C1348 divider_2/tspc_0/Z2 divider_2/nor_0/B 0.20fF
C1349 divider_2/tspc_0/a_630_n680# divider_2/nor_1/B 0.35fF
C1350 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z4 0.08fF
C1351 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z3 0.05fF
C1352 divider_2/tspc_2/a_630_n680# divider_2/nor_0/A 0.35fF
C1353 divider_2/prescaler_0/tspc_0/D divider_2/clk 0.29fF
C1354 divider_0/tspc_0/Z1 divider_0/tspc_0/Z4 0.00fF
C1355 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1356 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1357 divbuf_17/IN divbuf_17/a_492_n240# 0.13fF
C1358 divider_1/mc2 divider_1/and_0/OUT 0.05fF
C1359 divbuf_14/OUT divbuf_14/OUT4 1.11fF
C1360 divider_0/and_0/OUT divider_0/and_0/out1 0.31fF
C1361 divider_0/prescaler_0/tspc_2/D divider_0/clk 0.26fF
C1362 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/switch_0/vin 0.19fF
C1363 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_1/Q 0.01fF
C1364 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C1365 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/Out 0.05fF
C1366 pll_full_0/ro_complete_0/a2 pll_full_0/divider_0/clk 0.11fF
C1367 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z1 0.06fF
C1368 divider_1/nor_0/B divider_1/tspc_1/Q 0.51fF
C1369 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C1370 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C1371 divider_1/and_0/OUT divider_1/clk 0.04fF
C1372 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/Qbar 0.01fF
C1373 io_clamp_high[0] io_analog[4] 0.53fF
C1374 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Qbar1 0.38fF
C1375 divider_2/prescaler_0/tspc_1/Z2 divider_2/and_0/OUT 0.06fF
C1376 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z3 0.33fF
C1377 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Q 0.38fF
C1378 divider_2/prescaler_0/tspc_0/Z2 divider_2/clk 0.11fF
C1379 divbuf_12/OUT3 divbuf_12/OUT4 5.16fF
C1380 divbuf_12/OUT2 divbuf_12/OUT5 0.02fF
C1381 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT4 1.11fF
C1382 divider_2/and_0/out1 divider_2/and_0/A 0.01fF
C1383 divbuf_14/OUT2 divbuf_14/OUT 0.06fF
C1384 divider_0/tspc_1/Q divider_0/tspc_1/Z3 0.05fF
C1385 divider_0/tspc_1/Z1 divider_0/tspc_1/Z4 0.00fF
C1386 divider_0/Out divider_0/nor_1/B 0.22fF
C1387 ro_complete_0/a5 ro_complete_0/cbank_1/v 0.10fF
C1388 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/a0 0.09fF
C1389 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/Qbar 0.01fF
C1390 divbuf_16/a_492_n240# divbuf_16/OUT 0.00fF
C1391 pd_0/DOWN pd_0/tspc_r_0/Z3 0.03fF
C1392 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT2 1.37fF
C1393 divbuf_6/OUT4 divbuf_6/OUT5 20.26fF
C1394 divbuf_6/OUT3 divbuf_6/OUT 0.26fF
C1395 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.04fF
C1396 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C1397 pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_0/divider_0/clk 1.58fF
C1398 divider_2/prescaler_0/Out divider_2/prescaler_0/m1_2700_2190# 0.11fF
C1399 divider_1/tspc_1/Z1 divider_1/tspc_1/Z3 0.06fF
C1400 divider_1/tspc_2/Q divider_1/tspc_1/a_630_n680# 0.01fF
C1401 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z2 0.23fF
C1402 divider_1/nor_0/A divider_1/and_0/A 0.01fF
C1403 pd_1/tspc_r_0/z5 pd_1/tspc_r_0/Z3 0.11fF
C1404 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/DOWN 0.11fF
C1405 divbuf_19/OUT5 divbuf_19/OUT4 20.26fF
C1406 divbuf_19/OUT divbuf_19/OUT3 0.26fF
C1407 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/clk 0.01fF
C1408 divbuf_0/IN divbuf_0/OUT5 0.00fF
C1409 divbuf_1/OUT5 divbuf_1/a_492_n240# 0.01fF
C1410 divider_0/tspc_1/Z2 divider_0/tspc_1/Z4 0.36fF
C1411 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/D 0.05fF
C1412 divider_0/prescaler_0/tspc_0/Z3 divider_0/clk 0.64fF
C1413 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a4 0.12fF
C1414 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1415 divbuf_17/IN divbuf_17/OUT5 0.00fF
C1416 ro_complete_1/cbank_0/v ro_complete_1/cbank_2/v 0.04fF
C1417 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z4 0.15fF
C1418 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/nor_1/B 0.22fF
C1419 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1420 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1421 divider_1/prescaler_0/m1_2700_2190# divider_1/nor_0/A 0.01fF
C1422 divider_1/prescaler_0/Out divider_1/tspc_2/Z4 0.12fF
C1423 divider_1/tspc_1/Z2 divider_1/tspc_1/Z3 0.16fF
C1424 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/D 0.15fF
C1425 divbuf_22/OUT3 divbuf_22/OUT5 0.01fF
C1426 divbuf_22/OUT2 divbuf_22/OUT 0.06fF
C1427 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/Z1 0.36fF
C1428 divider_2/mc2 divider_2/nor_0/B 0.06fF
C1429 divider_2/tspc_2/Q divider_2/tspc_1/Z2 0.14fF
C1430 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/z5 0.11fF
C1431 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/R 0.01fF
C1432 divbuf_18/OUT5 divbuf_18/a_492_n240# 0.01fF
C1433 divbuf_0/OUT divbuf_0/OUT3 0.26fF
C1434 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a3 0.13fF
C1435 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1436 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z2 0.25fF
C1437 divider_0/tspc_1/Z4 divider_0/nor_0/A 0.02fF
C1438 pll_full_0/divbuf_1/OUT4 pll_full_0/divbuf_1/OUT5 20.26fF
C1439 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT 0.26fF
C1440 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1441 divider_1/tspc_0/Z1 divider_1/tspc_0/Z3 0.06fF
C1442 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z4 0.00fF
C1443 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C1444 divbuf_21/a_492_n240# divbuf_21/OUT5 0.01fF
C1445 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/Z3 0.05fF
C1446 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/clk 0.11fF
C1447 divbuf_18/OUT3 divbuf_18/OUT 0.26fF
C1448 divider_2/tspc_2/Q divider_2/nor_0/A 0.55fF
C1449 divider_2/nor_1/B divider_2/tspc_1/Q 0.22fF
C1450 pd_1/tspc_r_1/Qbar pd_1/UP 0.21fF
C1451 divbuf_24/OUT3 divbuf_24/OUT4 5.16fF
C1452 divbuf_24/OUT2 divbuf_24/OUT5 0.02fF
C1453 divbuf_2/OUT2 divbuf_2/a_492_n240# 0.42fF
C1454 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/v 1.30fF
C1455 divider_0/nor_0/B divider_0/tspc_0/Z4 0.02fF
C1456 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1457 ro_complete_1/a4 ro_complete_1/cbank_2/switch_0/vin 0.12fF
C1458 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z4 0.12fF
C1459 divider_0/tspc_2/Z1 divider_0/tspc_2/Z2 1.07fF
C1460 divider_0/nor_0/A divider_0/tspc_2/Z3 0.38fF
C1461 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/a0 0.09fF
C1462 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z3 0.06fF
C1463 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C1464 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1465 divbuf_7/OUT4 divbuf_7/OUT5 20.26fF
C1466 divbuf_7/OUT3 divbuf_7/OUT 0.26fF
C1467 divider_1/nor_0/A divider_1/tspc_2/Z1 0.03fF
C1468 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z3 0.05fF
C1469 pd_1/R pd_1/tspc_r_1/Z3 0.29fF
C1470 pd_1/tspc_r_0/Qbar1 pd_1/tspc_r_0/z5 0.20fF
C1471 pd_1/tspc_r_0/Z1 pd_1/DIV 0.17fF
C1472 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z1 0.17fF
C1473 divbuf_19/OUT5 divbuf_19/a_492_n240# 0.01fF
C1474 divider_2/mc2 divider_2/and_0/A 0.16fF
C1475 divider_2/prescaler_0/tspc_2/Z2 divider_2/and_0/OUT 0.05fF
C1476 ro_complete_0/a0 ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1477 ro_complete_0/cbank_0/v ro_complete_0/cbank_1/v 1.27fF
C1478 divbuf_14/IN divbuf_14/a_492_n240# 0.13fF
C1479 divider_0/mc2 divider_0/and_0/A 0.16fF
C1480 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z4 0.12fF
C1481 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1482 divbuf_3/OUT3 divbuf_3/OUT4 5.16fF
C1483 ro_complete_1/a0 ro_complete_1/cbank_1/v 0.05fF
C1484 divider_2/tspc_0/Z4 divider_2/tspc_0/a_630_n680# 0.12fF
C1485 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z3 0.05fF
C1486 divbuf_10/a_492_n240# divbuf_10/OUT 0.00fF
C1487 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1488 pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_0/divider_0/clk 1.46fF
C1489 divider_2/tspc_2/Q divider_2/tspc_1/Z1 0.01fF
C1490 divider_2/tspc_1/a_630_n680# divider_2/nor_0/B 0.35fF
C1491 divider_1/and_0/A divider_1/and_0/B 0.18fF
C1492 divbuf_9/OUT3 divbuf_9/OUT5 0.01fF
C1493 divbuf_9/OUT2 divbuf_9/OUT 0.06fF
C1494 cp_0/a_1710_n2840# cp_0/upbar 0.29fF
C1495 pd_1/tspc_r_0/Z4 pd_1/tspc_r_1/Z4 0.02fF
C1496 pd_1/REF pd_1/tspc_r_1/Qbar1 0.12fF
C1497 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z4 0.02fF
C1498 divider_2/tspc_1/Z2 divider_2/nor_0/A 0.15fF
C1499 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_0/D 0.32fF
C1500 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/clk 0.01fF
C1501 divider_2/nor_0/B divider_2/and_0/A 0.26fF
C1502 ro_complete_0/a2 ro_complete_0/cbank_2/switch_3/vin 0.09fF
C1503 pll_full_0/cp_0/upbar pll_full_0/cp_0/down 0.02fF
C1504 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z4 0.20fF
C1505 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C1506 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/pd_0/tspc_r_1/Z2 0.71fF
C1507 divbuf_1/OUT divbuf_1/OUT4 1.11fF
C1508 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_4/vin 0.20fF
C1509 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a3 0.13fF
C1510 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/Q 0.04fF
C1511 divider_0/prescaler_0/tspc_1/Z3 divider_0/clk 0.45fF
C1512 divbuf_4/OUT2 divbuf_4/OUT3 1.37fF
C1513 ro_complete_1/cbank_2/switch_0/vin ro_complete_1/cbank_2/v 1.45fF
C1514 divider_1/prescaler_0/tspc_2/D divider_1/prescaler_0/nand_0/z1 0.24fF
C1515 divbuf_20/OUT4 divbuf_20/OUT 1.11fF
C1516 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Z4 0.65fF
C1517 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1518 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/clk 0.51fF
C1519 divbuf_8/a_492_n240# divbuf_8/OUT5 0.01fF
C1520 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C1521 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z4 0.12fF
C1522 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z2 1.07fF
C1523 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Out1 0.05fF
C1524 pll_full_0/pd_0/DOWN pll_full_0/cp_0/a_1710_0# 0.04fF
C1525 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z2 0.01fF
C1526 ro_complete_1/a2 ro_complete_1/cbank_1/switch_3/vin 0.09fF
C1527 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/UP 0.21fF
C1528 divider_0/nor_1/Z1 divider_0/nor_1/B 0.06fF
C1529 divbuf_2/a_492_n240# divbuf_2/OUT 0.00fF
C1530 divbuf_14/OUT divbuf_14/OUT3 0.26fF
C1531 divbuf_5/OUT2 divbuf_5/OUT3 1.37fF
C1532 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/Z1 0.00fF
C1533 divider_1/tspc_0/Z1 divider_1/tspc_0/Z4 0.00fF
C1534 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z2 0.19fF
C1535 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z3 0.05fF
C1536 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z2 0.01fF
C1537 divider_1/and_0/OUT divider_1/and_0/out1 0.31fF
C1538 divider_1/prescaler_0/tspc_2/D divider_1/clk 0.26fF
C1539 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C1540 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/clk 0.11fF
C1541 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z4 0.20fF
C1542 pd_0/REF pd_0/tspc_r_1/z5 0.04fF
C1543 pd_0/tspc_r_1/Z1 pd_0/tspc_r_1/Z2 0.71fF
C1544 divbuf_12/OUT4 divbuf_12/OUT5 20.26fF
C1545 divbuf_12/OUT3 divbuf_12/OUT 0.26fF
C1546 divider_2/tspc_1/Q divider_2/tspc_0/Z1 0.01fF
C1547 divider_2/tspc_1/Z1 divider_2/tspc_1/Z2 1.07fF
C1548 divider_2/nor_0/B divider_2/tspc_1/Z3 0.38fF
C1549 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z4 0.08fF
C1550 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z3 0.05fF
C1551 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Q 0.04fF
C1552 pd_1/and_pd_0/Z1 pd_1/UP 0.06fF
C1553 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT5 43.38fF
C1554 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_1/Qbar 0.02fF
C1555 divbuf_14/OUT2 divbuf_14/a_492_n240# 0.42fF
C1556 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_1/Q 0.13fF
C1557 divider_0/prescaler_0/m1_2700_2190# divider_0/and_0/OUT 0.14fF
C1558 ro_complete_0/a2 ro_complete_0/cbank_2/v 0.05fF
C1559 divbuf_3/OUT2 divbuf_3/OUT 0.06fF
C1560 ro_complete_1/a3 ro_complete_1/cbank_1/v 0.05fF
C1561 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1562 divbuf_6/OUT5 divbuf_6/OUT 43.38fF
C1563 divider_1/tspc_1/Q divider_1/tspc_1/Z3 0.05fF
C1564 divider_1/tspc_1/Z1 divider_1/tspc_1/Z4 0.00fF
C1565 divider_1/Out divider_1/nor_1/B 0.22fF
C1566 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C1567 divbuf_11/a_492_n240# divbuf_11/OUT 0.00fF
C1568 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z3 0.06fF
C1569 pd_0/tspc_r_1/Qbar pd_0/UP 0.21fF
C1570 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z2 0.25fF
C1571 divbuf_18/OUT5 divbuf_18/OUT 43.38fF
C1572 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/switch_1/vin 0.19fF
C1573 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar 0.03fF
C1574 divider_0/prescaler_0/tspc_2/Z4 divider_0/prescaler_0/tspc_2/D 0.11fF
C1575 divider_0/prescaler_0/tspc_0/Z4 divider_0/clk 0.12fF
C1576 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_4/vin 0.20fF
C1577 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C1578 divider_2/tspc_0/Z4 divider_2/tspc_1/Q 0.15fF
C1579 divbuf_20/a_492_n240# divbuf_20/IN 0.13fF
C1580 divider_1/tspc_1/Z2 divider_1/tspc_1/Z4 0.36fF
C1581 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/D 0.05fF
C1582 divider_1/prescaler_0/tspc_0/Z3 divider_1/clk 0.64fF
C1583 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1584 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1585 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/clk 0.14fF
C1586 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/B 0.78fF
C1587 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z3 0.05fF
C1588 divider_2/tspc_0/Z3 divider_2/tspc_0/a_630_n680# 0.05fF
C1589 divbuf_22/OUT4 divbuf_22/OUT 1.11fF
C1590 divbuf_13/a_492_n240# divbuf_13/OUT5 0.01fF
C1591 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/z5 0.11fF
C1592 divider_0/tspc_0/a_630_n680# divider_0/Out 0.04fF
C1593 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT2 0.06fF
C1594 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Out1 0.05fF
C1595 divider_0/prescaler_0/tspc_2/Z3 divider_0/clk 0.45fF
C1596 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/a1 0.14fF
C1597 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/a3 0.09fF
C1598 ro_complete_1/cbank_2/switch_5/vin ro_complete_1/cbank_2/v 1.30fF
C1599 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1600 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/Z4 0.65fF
C1601 divbuf_21/OUT2 divbuf_21/OUT3 1.37fF
C1602 pd_0/DIV pd_0/R 0.51fF
C1603 divider_2/prescaler_0/Out divider_2/tspc_2/Z3 0.45fF
C1604 divider_1/tspc_1/Z4 divider_1/nor_0/A 0.02fF
C1605 pd_0/R pd_0/tspc_r_1/Qbar 0.03fF
C1606 filter_0/a_4216_n2998# filter_0/v 0.31fF
C1607 pd_1/and_pd_0/Out1 pd_1/and_pd_0/Z1 0.18fF
C1608 divbuf_24/OUT4 divbuf_24/OUT5 20.26fF
C1609 divbuf_24/OUT3 divbuf_24/OUT 0.26fF
C1610 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/R 0.21fF
C1611 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/z5 0.03fF
C1612 divider_2/nor_0/A divider_2/and_0/B 0.08fF
C1613 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1614 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/pd_0/UP 0.06fF
C1615 divider_0/tspc_2/Z2 divider_0/tspc_2/Z3 0.16fF
C1616 divider_0/nor_0/A divider_0/tspc_2/Z4 0.21fF
C1617 divbuf_3/IN divbuf_3/a_492_n240# 0.13fF
C1618 divbuf_1/a_492_n240# divbuf_1/IN 0.13fF
C1619 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/v 1.30fF
C1620 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1621 divbuf_6/a_492_n240# divbuf_6/OUT2 0.42fF
C1622 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z4 0.12fF
C1623 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z3 0.45fF
C1624 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/nor_1/B 0.40fF
C1625 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C1626 divider_1/nor_0/B divider_1/tspc_0/Z4 0.02fF
C1627 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z4 0.00fF
C1628 divbuf_7/OUT5 divbuf_7/OUT 43.38fF
C1629 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z4 0.12fF
C1630 divider_1/tspc_2/Z1 divider_1/tspc_2/Z2 1.07fF
C1631 divider_1/nor_0/A divider_1/tspc_2/Z3 0.38fF
C1632 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/B 0.01fF
C1633 cp_0/a_1710_0# cp_0/a_1710_n2840# 0.83fF
C1634 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Out1 0.05fF
C1635 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Q 0.20fF
C1636 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/D 0.09fF
C1637 divbuf_23/a_492_n240# divbuf_23/OUT 0.00fF
C1638 divbuf_15/OUT5 divbuf_15/OUT3 0.01fF
C1639 divbuf_15/OUT divbuf_15/OUT2 0.06fF
C1640 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Z1 0.07fF
C1641 divider_0/prescaler_0/Out divider_0/tspc_2/a_630_n680# 0.01fF
C1642 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1643 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Q 0.21fF
C1644 divbuf_2/OUT2 divbuf_2/OUT 0.06fF
C1645 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C1646 divbuf_25/OUT5 divbuf_25/OUT 43.38fF
C1647 divider_0/and_0/B divider_0/and_0/Z1 0.07fF
C1648 divbuf_3/OUT4 divbuf_3/OUT5 20.26fF
C1649 divbuf_10/IN divbuf_10/OUT5 0.00fF
C1650 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C1651 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1652 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z4 0.12fF
C1653 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z3 0.06fF
C1654 divbuf_22/a_492_n240# divbuf_22/IN 0.13fF
Xpd_0 vdda1 vssa1 pd_0/REF pd_0/DIV pd_0/UP pd_0/DOWN pd_0/R pd
Xpd_1 vdda1 vssa1 pd_1/REF pd_1/DIV pd_1/UP pd_1/DOWN pd_1/R pd
Xcp_0 cp_0/vbias vdda1 gnd cp_0/out cp_0/down cp_0/upbar cp
Xfilter_0 vssa1 filter_0/v filter
Xro_complete_0 ro_complete_0/a0 ro_complete_0/a1 ro_complete_0/a5 ro_complete_0/a4
+ ro_complete_0/a3 ro_complete_0/a2 ro_complete
Xdivbuf_0 vdda1 divbuf_0/IN divbuf_0/OUT divbuf_0/OUT2 divbuf_0/OUT3 divbuf_0/OUT4
+ divbuf_0/OUT5 gnd divbuf
Xro_complete_1 ro_complete_1/a0 ro_complete_1/a1 ro_complete_1/a5 ro_complete_1/a4
+ ro_complete_1/a3 ro_complete_1/a2 ro_complete
Xdivbuf_1 vdda1 divbuf_1/IN divbuf_1/OUT divbuf_1/OUT2 divbuf_1/OUT3 divbuf_1/OUT4
+ divbuf_1/OUT5 gnd divbuf
Xdivbuf_2 vdda1 divbuf_2/IN divbuf_2/OUT divbuf_2/OUT2 divbuf_2/OUT3 divbuf_2/OUT4
+ divbuf_2/OUT5 gnd divbuf
Xdivbuf_3 vdda1 divbuf_3/IN divbuf_3/OUT divbuf_3/OUT2 divbuf_3/OUT3 divbuf_3/OUT4
+ divbuf_3/OUT5 gnd divbuf
Xdivbuf_4 vdda1 divbuf_4/IN divbuf_4/OUT divbuf_4/OUT2 divbuf_4/OUT3 divbuf_4/OUT4
+ divbuf_4/OUT5 gnd divbuf
Xdivbuf_5 vdda1 divbuf_5/IN divbuf_5/OUT divbuf_5/OUT2 divbuf_5/OUT3 divbuf_5/OUT4
+ divbuf_5/OUT5 gnd divbuf
Xdivbuf_6 vdda1 divbuf_6/IN divbuf_6/OUT divbuf_6/OUT2 divbuf_6/OUT3 divbuf_6/OUT4
+ divbuf_6/OUT5 gnd divbuf
Xdivbuf_10 vdda1 divbuf_10/IN divbuf_10/OUT divbuf_10/OUT2 divbuf_10/OUT3 divbuf_10/OUT4
+ divbuf_10/OUT5 gnd divbuf
Xdivbuf_20 vdda1 divbuf_20/IN divbuf_20/OUT divbuf_20/OUT2 divbuf_20/OUT3 divbuf_20/OUT4
+ divbuf_20/OUT5 vssa1 divbuf
Xdivbuf_21 vdda1 divbuf_21/IN divbuf_21/OUT divbuf_21/OUT2 divbuf_21/OUT3 divbuf_21/OUT4
+ divbuf_21/OUT5 vssa1 divbuf
Xdivbuf_7 vdda1 divbuf_7/IN divbuf_7/OUT divbuf_7/OUT2 divbuf_7/OUT3 divbuf_7/OUT4
+ divbuf_7/OUT5 gnd divbuf
Xdivbuf_11 vdda1 divbuf_11/IN divbuf_11/OUT divbuf_11/OUT2 divbuf_11/OUT3 divbuf_11/OUT4
+ divbuf_11/OUT5 gnd divbuf
Xdivbuf_22 vdda1 divbuf_22/IN divbuf_22/OUT divbuf_22/OUT2 divbuf_22/OUT3 divbuf_22/OUT4
+ divbuf_22/OUT5 vssa1 divbuf
Xdivbuf_8 vdda1 divbuf_8/IN divbuf_8/OUT divbuf_8/OUT2 divbuf_8/OUT3 divbuf_8/OUT4
+ divbuf_8/OUT5 gnd divbuf
Xdivbuf_12 vdda1 divbuf_12/IN divbuf_12/OUT divbuf_12/OUT2 divbuf_12/OUT3 divbuf_12/OUT4
+ divbuf_12/OUT5 gnd divbuf
Xdivbuf_23 vdda1 divbuf_23/IN divbuf_23/OUT divbuf_23/OUT2 divbuf_23/OUT3 divbuf_23/OUT4
+ divbuf_23/OUT5 vssa1 divbuf
Xdivbuf_9 vdda1 divbuf_9/IN divbuf_9/OUT divbuf_9/OUT2 divbuf_9/OUT3 divbuf_9/OUT4
+ divbuf_9/OUT5 gnd divbuf
Xdivbuf_13 vdda1 divbuf_13/IN divbuf_13/OUT divbuf_13/OUT2 divbuf_13/OUT3 divbuf_13/OUT4
+ divbuf_13/OUT5 gnd divbuf
Xdivbuf_24 vdda1 divbuf_24/IN divbuf_24/OUT divbuf_24/OUT2 divbuf_24/OUT3 divbuf_24/OUT4
+ divbuf_24/OUT5 vssa1 divbuf
Xdivider_0 gnd vdd divider_0/Out divider_0/clk divider_0/mc2 divider
Xdivbuf_14 vdda1 divbuf_14/IN divbuf_14/OUT divbuf_14/OUT2 divbuf_14/OUT3 divbuf_14/OUT4
+ divbuf_14/OUT5 gnd divbuf
Xdivbuf_25 vdda1 divbuf_25/IN divbuf_25/OUT divbuf_25/OUT2 divbuf_25/OUT3 divbuf_25/OUT4
+ divbuf_25/OUT5 vssa1 divbuf
Xdivbuf_15 vdda1 divbuf_15/IN divbuf_15/OUT divbuf_15/OUT2 divbuf_15/OUT3 divbuf_15/OUT4
+ divbuf_15/OUT5 gnd divbuf
Xdivider_1 vssa1 vdda1 divider_1/Out divider_1/clk divider_1/mc2 divider
Xdivbuf_16 vdda1 divbuf_16/IN divbuf_16/OUT divbuf_16/OUT2 divbuf_16/OUT3 divbuf_16/OUT4
+ divbuf_16/OUT5 vssa1 divbuf
Xdivider_2 vssa1 vdda1 divider_2/Out divider_2/clk divider_2/mc2 divider
Xdivbuf_17 vdda1 divbuf_17/IN divbuf_17/OUT divbuf_17/OUT2 divbuf_17/OUT3 divbuf_17/OUT4
+ divbuf_17/OUT5 vssa1 divbuf
Xdivbuf_18 vdda1 divbuf_18/IN divbuf_18/OUT divbuf_18/OUT2 divbuf_18/OUT3 divbuf_18/OUT4
+ divbuf_18/OUT5 vssa1 divbuf
Xdivbuf_19 vdda1 divbuf_19/IN divbuf_19/OUT divbuf_19/OUT2 divbuf_19/OUT3 divbuf_19/OUT4
+ divbuf_19/OUT5 vssa1 divbuf
Xpll_full_0 vdda1 pll_full
C1655 io_analog[4] gnd 43.96fF
C1656 io_analog[5] gnd 44.13fF
C1657 io_analog[6] gnd 43.46fF
C1658 io_in_3v3[0] gnd 0.61fF
C1659 io_oeb[26] gnd 0.61fF
C1660 io_in[0] gnd 0.61fF
C1661 io_out[26] gnd 0.61fF
C1662 io_out[0] gnd 0.61fF
C1663 io_in[26] gnd 0.61fF
C1664 io_oeb[0] gnd 0.61fF
C1665 io_in_3v3[26] gnd 0.61fF
C1666 io_in_3v3[1] gnd 0.61fF
C1667 io_oeb[25] gnd 0.61fF
C1668 io_in[1] gnd 0.61fF
C1669 io_out[25] gnd 0.61fF
C1670 io_out[1] gnd 0.61fF
C1671 io_in[25] gnd 0.61fF
C1672 io_oeb[1] gnd 0.61fF
C1673 io_in_3v3[25] gnd 0.61fF
C1674 io_in_3v3[2] gnd 0.61fF
C1675 io_oeb[24] gnd 0.61fF
C1676 io_in[2] gnd 0.61fF
C1677 io_out[24] gnd 0.61fF
C1678 io_out[2] gnd 0.61fF
C1679 io_in[24] gnd 0.61fF
C1680 io_oeb[2] gnd 0.61fF
C1681 io_in_3v3[24] gnd 0.61fF
C1682 io_in_3v3[3] gnd 0.61fF
C1683 gpio_noesd[17] gnd 2.32fF
C1684 io_in[3] gnd 0.61fF
C1685 gpio_analog[17] gnd 2.30fF
C1686 io_out[3] gnd 0.61fF
C1687 io_oeb[3] gnd 0.61fF
C1688 io_in_3v3[4] gnd 0.61fF
C1689 io_in[4] gnd 0.61fF
C1690 io_out[4] gnd 0.61fF
C1691 io_oeb[4] gnd 0.61fF
C1692 io_oeb[23] gnd 0.61fF
C1693 io_out[23] gnd 0.61fF
C1694 io_in[23] gnd 0.61fF
C1695 io_in_3v3[23] gnd 0.61fF
C1696 gpio_noesd[16] gnd 2.30fF
C1697 gpio_analog[16] gnd 2.30fF
C1698 io_in_3v3[5] gnd 0.61fF
C1699 io_in[5] gnd 0.61fF
C1700 io_out[5] gnd 0.61fF
C1701 io_oeb[5] gnd 0.61fF
C1702 io_oeb[22] gnd 0.61fF
C1703 io_out[22] gnd 0.61fF
C1704 io_in[22] gnd 0.61fF
C1705 io_in_3v3[22] gnd 0.61fF
C1706 gpio_noesd[15] gnd 2.31fF
C1707 gpio_analog[15] gnd 2.30fF
C1708 io_in_3v3[6] gnd 0.61fF
C1709 io_in[6] gnd 0.61fF
C1710 io_out[6] gnd 0.61fF
C1711 io_oeb[6] gnd 0.61fF
C1712 io_oeb[21] gnd 0.61fF
C1713 io_out[21] gnd 0.61fF
C1714 io_in[21] gnd 0.61fF
C1715 io_in_3v3[21] gnd 0.61fF
C1716 gpio_noesd[14] gnd 2.30fF
C1717 gpio_analog[14] gnd 2.29fF
C1718 vssd2 gnd 38.54fF
C1719 vssd1 gnd 13.04fF
C1720 vdda2 gnd 38.30fF
C1721 io_oeb[20] gnd 0.61fF
C1722 io_out[20] gnd 0.61fF
C1723 io_in[20] gnd 0.61fF
C1724 io_in_3v3[20] gnd 0.61fF
C1725 gpio_noesd[13] gnd 2.31fF
C1726 gpio_analog[13] gnd 2.30fF
C1727 gpio_analog[0] gnd 0.61fF
C1728 gpio_noesd[0] gnd 0.61fF
C1729 io_in_3v3[7] gnd 0.61fF
C1730 io_in[7] gnd 0.61fF
C1731 io_out[7] gnd 0.61fF
C1732 io_oeb[7] gnd 0.61fF
C1733 io_oeb[19] gnd 0.61fF
C1734 io_out[19] gnd 0.61fF
C1735 io_in[19] gnd 0.61fF
C1736 io_in_3v3[19] gnd 0.61fF
C1737 gpio_noesd[12] gnd 2.32fF
C1738 gpio_analog[12] gnd 2.30fF
C1739 gpio_analog[1] gnd 0.61fF
C1740 gpio_noesd[1] gnd 0.61fF
C1741 io_in_3v3[8] gnd 0.61fF
C1742 io_in[8] gnd 0.61fF
C1743 io_out[8] gnd 0.61fF
C1744 io_oeb[8] gnd 0.61fF
C1745 io_oeb[18] gnd 0.61fF
C1746 io_out[18] gnd 0.61fF
C1747 io_in[18] gnd 0.61fF
C1748 io_in_3v3[18] gnd 0.61fF
C1749 gpio_noesd[11] gnd 2.30fF
C1750 gpio_analog[11] gnd 2.29fF
C1751 gpio_analog[2] gnd 0.61fF
C1752 gpio_noesd[2] gnd 0.61fF
C1753 io_in_3v3[9] gnd 0.61fF
C1754 io_in[9] gnd 0.61fF
C1755 io_out[9] gnd 0.61fF
C1756 io_oeb[9] gnd 0.61fF
C1757 io_oeb[17] gnd 0.61fF
C1758 io_out[17] gnd 0.61fF
C1759 io_in[17] gnd 0.61fF
C1760 io_in_3v3[17] gnd 0.61fF
C1761 gpio_noesd[10] gnd 2.31fF
C1762 gpio_analog[10] gnd 2.29fF
C1763 gpio_analog[3] gnd 0.61fF
C1764 gpio_noesd[3] gnd 0.61fF
C1765 io_in_3v3[10] gnd 0.61fF
C1766 io_in[10] gnd 0.61fF
C1767 io_out[10] gnd 0.61fF
C1768 io_oeb[10] gnd 0.61fF
C1769 io_oeb[16] gnd 0.61fF
C1770 io_out[16] gnd 0.61fF
C1771 io_in[16] gnd 0.61fF
C1772 io_in_3v3[16] gnd 0.61fF
C1773 gpio_noesd[9] gnd 2.28fF
C1774 gpio_analog[9] gnd 2.28fF
C1775 gpio_analog[4] gnd 0.61fF
C1776 gpio_noesd[4] gnd 0.61fF
C1777 io_in_3v3[11] gnd 0.61fF
C1778 io_in[11] gnd 0.61fF
C1779 io_out[11] gnd 0.61fF
C1780 io_oeb[11] gnd 0.61fF
C1781 io_oeb[15] gnd 0.61fF
C1782 io_out[15] gnd 0.61fF
C1783 io_in[15] gnd 0.61fF
C1784 io_in_3v3[15] gnd 0.61fF
C1785 gpio_noesd[8] gnd 2.28fF
C1786 gpio_analog[8] gnd 2.26fF
C1787 gpio_analog[5] gnd 0.61fF
C1788 gpio_noesd[5] gnd 0.61fF
C1789 io_in_3v3[12] gnd 0.61fF
C1790 io_in[12] gnd 0.61fF
C1791 io_out[12] gnd 0.61fF
C1792 io_oeb[12] gnd 0.61fF
C1793 io_oeb[14] gnd 0.61fF
C1794 io_out[14] gnd 0.61fF
C1795 io_in[14] gnd 0.61fF
C1796 io_in_3v3[14] gnd 0.61fF
C1797 gpio_noesd[7] gnd 2.30fF
C1798 gpio_analog[7] gnd 2.28fF
C1799 vssa2 gnd 38.35fF
C1800 gpio_analog[6] gnd 5.71fF
C1801 gpio_noesd[6] gnd 5.70fF
C1802 io_in_3v3[13] gnd 0.61fF
C1803 io_in[13] gnd 0.61fF
C1804 io_out[13] gnd 0.61fF
C1805 io_oeb[13] gnd 0.61fF
C1806 vccd1 gnd 39.84fF
C1807 vccd2 gnd 38.46fF
C1808 io_analog[0] gnd 19.99fF
C1809 io_analog[10] gnd 19.36fF
C1810 io_analog[1] gnd 13.17fF
C1811 io_analog[2] gnd 12.57fF
C1812 io_analog[3] gnd 12.83fF
C1813 io_clamp_high[0] gnd 3.58fF
C1814 io_clamp_low[0] gnd 3.58fF
C1815 io_clamp_high[1] gnd 3.58fF
C1816 io_clamp_low[1] gnd 3.58fF
C1817 io_clamp_high[2] gnd 3.58fF
C1818 io_clamp_low[2] gnd 3.58fF
C1819 io_analog[7] gnd 12.74fF
C1820 io_analog[8] gnd 13.08fF
C1821 io_analog[9] gnd 13.08fF
C1822 user_irq[2] gnd 0.63fF
C1823 user_irq[1] gnd 0.63fF
C1824 user_irq[0] gnd 0.63fF
C1825 user_clock2 gnd 0.63fF
C1826 la_oenb[127] gnd 0.63fF
C1827 la_data_out[127] gnd 0.63fF
C1828 la_data_in[127] gnd 0.63fF
C1829 la_oenb[126] gnd 0.63fF
C1830 la_data_out[126] gnd 0.63fF
C1831 la_data_in[126] gnd 0.63fF
C1832 la_oenb[125] gnd 0.63fF
C1833 la_data_out[125] gnd 0.63fF
C1834 la_data_in[125] gnd 0.63fF
C1835 la_oenb[124] gnd 0.63fF
C1836 la_data_out[124] gnd 0.63fF
C1837 la_data_in[124] gnd 0.63fF
C1838 la_oenb[123] gnd 0.63fF
C1839 la_data_out[123] gnd 0.63fF
C1840 la_data_in[123] gnd 0.63fF
C1841 la_oenb[122] gnd 0.63fF
C1842 la_data_out[122] gnd 0.63fF
C1843 la_data_in[122] gnd 0.63fF
C1844 la_oenb[121] gnd 0.63fF
C1845 la_data_out[121] gnd 0.63fF
C1846 la_data_in[121] gnd 0.63fF
C1847 la_oenb[120] gnd 0.63fF
C1848 la_data_out[120] gnd 0.63fF
C1849 la_data_in[120] gnd 0.63fF
C1850 la_oenb[119] gnd 0.63fF
C1851 la_data_out[119] gnd 0.63fF
C1852 la_data_in[119] gnd 0.63fF
C1853 la_oenb[118] gnd 0.63fF
C1854 la_data_out[118] gnd 0.63fF
C1855 la_data_in[118] gnd 0.63fF
C1856 la_oenb[117] gnd 0.63fF
C1857 la_data_out[117] gnd 0.63fF
C1858 la_data_in[117] gnd 0.63fF
C1859 la_oenb[116] gnd 0.63fF
C1860 la_data_out[116] gnd 0.63fF
C1861 la_data_in[116] gnd 0.63fF
C1862 la_oenb[115] gnd 0.63fF
C1863 la_data_out[115] gnd 0.63fF
C1864 la_data_in[115] gnd 0.63fF
C1865 la_oenb[114] gnd 0.63fF
C1866 la_data_out[114] gnd 0.63fF
C1867 la_data_in[114] gnd 0.63fF
C1868 la_oenb[113] gnd 0.63fF
C1869 la_data_out[113] gnd 0.63fF
C1870 la_data_in[113] gnd 0.63fF
C1871 la_oenb[112] gnd 0.63fF
C1872 la_data_out[112] gnd 0.63fF
C1873 la_data_in[112] gnd 0.63fF
C1874 la_oenb[111] gnd 0.63fF
C1875 la_data_out[111] gnd 0.63fF
C1876 la_data_in[111] gnd 0.63fF
C1877 la_oenb[110] gnd 0.63fF
C1878 la_data_out[110] gnd 0.63fF
C1879 la_data_in[110] gnd 0.63fF
C1880 la_oenb[109] gnd 0.63fF
C1881 la_data_out[109] gnd 0.63fF
C1882 la_data_in[109] gnd 0.63fF
C1883 la_oenb[108] gnd 0.63fF
C1884 la_data_out[108] gnd 0.63fF
C1885 la_data_in[108] gnd 0.63fF
C1886 la_oenb[107] gnd 0.63fF
C1887 la_data_out[107] gnd 0.63fF
C1888 la_data_in[107] gnd 0.63fF
C1889 la_oenb[106] gnd 0.63fF
C1890 la_data_out[106] gnd 0.63fF
C1891 la_data_in[106] gnd 0.63fF
C1892 la_oenb[105] gnd 0.63fF
C1893 la_data_out[105] gnd 0.63fF
C1894 la_data_in[105] gnd 0.63fF
C1895 la_oenb[104] gnd 0.63fF
C1896 la_data_out[104] gnd 0.63fF
C1897 la_data_in[104] gnd 0.63fF
C1898 la_oenb[103] gnd 0.63fF
C1899 la_data_out[103] gnd 0.63fF
C1900 la_data_in[103] gnd 0.63fF
C1901 la_oenb[102] gnd 0.63fF
C1902 la_data_out[102] gnd 0.63fF
C1903 la_data_in[102] gnd 0.63fF
C1904 la_oenb[101] gnd 0.63fF
C1905 la_data_out[101] gnd 0.63fF
C1906 la_data_in[101] gnd 0.63fF
C1907 la_oenb[100] gnd 0.63fF
C1908 la_data_out[100] gnd 0.63fF
C1909 la_data_in[100] gnd 0.63fF
C1910 la_oenb[99] gnd 0.63fF
C1911 la_data_out[99] gnd 0.63fF
C1912 la_data_in[99] gnd 0.63fF
C1913 la_oenb[98] gnd 0.63fF
C1914 la_data_out[98] gnd 0.63fF
C1915 la_data_in[98] gnd 0.63fF
C1916 la_oenb[97] gnd 0.63fF
C1917 la_data_out[97] gnd 0.63fF
C1918 la_data_in[97] gnd 0.63fF
C1919 la_oenb[96] gnd 0.63fF
C1920 la_data_out[96] gnd 0.63fF
C1921 la_data_in[96] gnd 0.63fF
C1922 la_oenb[95] gnd 0.63fF
C1923 la_data_out[95] gnd 0.63fF
C1924 la_data_in[95] gnd 0.63fF
C1925 la_oenb[94] gnd 0.63fF
C1926 la_data_out[94] gnd 0.63fF
C1927 la_data_in[94] gnd 0.63fF
C1928 la_oenb[93] gnd 0.63fF
C1929 la_data_out[93] gnd 0.63fF
C1930 la_data_in[93] gnd 0.63fF
C1931 la_oenb[92] gnd 0.63fF
C1932 la_data_out[92] gnd 0.63fF
C1933 la_data_in[92] gnd 0.63fF
C1934 la_oenb[91] gnd 0.63fF
C1935 la_data_out[91] gnd 0.63fF
C1936 la_data_in[91] gnd 0.63fF
C1937 la_oenb[90] gnd 0.63fF
C1938 la_data_out[90] gnd 0.63fF
C1939 la_data_in[90] gnd 0.63fF
C1940 la_oenb[89] gnd 0.63fF
C1941 la_data_out[89] gnd 0.63fF
C1942 la_data_in[89] gnd 0.63fF
C1943 la_oenb[88] gnd 0.63fF
C1944 la_data_out[88] gnd 0.63fF
C1945 la_data_in[88] gnd 0.63fF
C1946 la_oenb[87] gnd 0.63fF
C1947 la_data_out[87] gnd 0.63fF
C1948 la_data_in[87] gnd 0.63fF
C1949 la_oenb[86] gnd 0.63fF
C1950 la_data_out[86] gnd 0.63fF
C1951 la_data_in[86] gnd 0.63fF
C1952 la_oenb[85] gnd 0.63fF
C1953 la_data_out[85] gnd 0.63fF
C1954 la_data_in[85] gnd 0.63fF
C1955 la_oenb[84] gnd 0.63fF
C1956 la_data_out[84] gnd 0.63fF
C1957 la_data_in[84] gnd 0.63fF
C1958 la_oenb[83] gnd 0.63fF
C1959 la_data_out[83] gnd 0.63fF
C1960 la_data_in[83] gnd 0.63fF
C1961 la_oenb[82] gnd 0.63fF
C1962 la_data_out[82] gnd 0.63fF
C1963 la_data_in[82] gnd 0.63fF
C1964 la_oenb[81] gnd 0.63fF
C1965 la_data_out[81] gnd 0.63fF
C1966 la_data_in[81] gnd 0.63fF
C1967 la_oenb[80] gnd 0.63fF
C1968 la_data_out[80] gnd 0.63fF
C1969 la_data_in[80] gnd 0.63fF
C1970 la_oenb[79] gnd 0.63fF
C1971 la_data_out[79] gnd 0.63fF
C1972 la_data_in[79] gnd 0.63fF
C1973 la_oenb[78] gnd 0.63fF
C1974 la_data_out[78] gnd 0.63fF
C1975 la_data_in[78] gnd 0.63fF
C1976 la_oenb[77] gnd 0.63fF
C1977 la_data_out[77] gnd 0.63fF
C1978 la_data_in[77] gnd 0.63fF
C1979 la_oenb[76] gnd 0.63fF
C1980 la_data_out[76] gnd 0.63fF
C1981 la_data_in[76] gnd 0.63fF
C1982 la_oenb[75] gnd 0.63fF
C1983 la_data_out[75] gnd 0.63fF
C1984 la_data_in[75] gnd 0.63fF
C1985 la_oenb[74] gnd 0.63fF
C1986 la_data_out[74] gnd 0.63fF
C1987 la_data_in[74] gnd 0.63fF
C1988 la_oenb[73] gnd 0.63fF
C1989 la_data_out[73] gnd 0.63fF
C1990 la_data_in[73] gnd 0.63fF
C1991 la_oenb[72] gnd 0.63fF
C1992 la_data_out[72] gnd 0.63fF
C1993 la_data_in[72] gnd 0.63fF
C1994 la_oenb[71] gnd 0.63fF
C1995 la_data_out[71] gnd 0.63fF
C1996 la_data_in[71] gnd 0.63fF
C1997 la_oenb[70] gnd 0.63fF
C1998 la_data_out[70] gnd 0.63fF
C1999 la_data_in[70] gnd 0.63fF
C2000 la_oenb[69] gnd 0.63fF
C2001 la_data_out[69] gnd 0.63fF
C2002 la_data_in[69] gnd 0.63fF
C2003 la_oenb[68] gnd 0.63fF
C2004 la_data_out[68] gnd 0.63fF
C2005 la_data_in[68] gnd 0.63fF
C2006 la_oenb[67] gnd 0.63fF
C2007 la_data_out[67] gnd 0.63fF
C2008 la_data_in[67] gnd 0.63fF
C2009 la_oenb[66] gnd 0.63fF
C2010 la_data_out[66] gnd 0.63fF
C2011 la_data_in[66] gnd 0.63fF
C2012 la_oenb[65] gnd 0.63fF
C2013 la_data_out[65] gnd 0.63fF
C2014 la_data_in[65] gnd 0.63fF
C2015 la_oenb[64] gnd 0.63fF
C2016 la_data_out[64] gnd 0.63fF
C2017 la_data_in[64] gnd 0.63fF
C2018 la_oenb[63] gnd 0.63fF
C2019 la_data_out[63] gnd 0.63fF
C2020 la_data_in[63] gnd 0.63fF
C2021 la_oenb[62] gnd 0.63fF
C2022 la_data_out[62] gnd 0.63fF
C2023 la_data_in[62] gnd 0.63fF
C2024 la_oenb[61] gnd 0.63fF
C2025 la_data_out[61] gnd 0.63fF
C2026 la_data_in[61] gnd 0.63fF
C2027 la_oenb[60] gnd 0.63fF
C2028 la_data_out[60] gnd 0.63fF
C2029 la_data_in[60] gnd 0.63fF
C2030 la_oenb[59] gnd 0.63fF
C2031 la_data_out[59] gnd 0.63fF
C2032 la_data_in[59] gnd 0.63fF
C2033 la_oenb[58] gnd 0.63fF
C2034 la_data_out[58] gnd 0.63fF
C2035 la_data_in[58] gnd 0.63fF
C2036 la_oenb[57] gnd 0.63fF
C2037 la_data_out[57] gnd 0.63fF
C2038 la_data_in[57] gnd 0.63fF
C2039 la_oenb[56] gnd 0.63fF
C2040 la_data_out[56] gnd 0.63fF
C2041 la_data_in[56] gnd 0.63fF
C2042 la_oenb[55] gnd 0.63fF
C2043 la_data_out[55] gnd 0.63fF
C2044 la_data_in[55] gnd 0.63fF
C2045 la_oenb[54] gnd 0.63fF
C2046 la_data_out[54] gnd 0.63fF
C2047 la_data_in[54] gnd 0.63fF
C2048 la_oenb[53] gnd 0.63fF
C2049 la_data_out[53] gnd 0.63fF
C2050 la_data_in[53] gnd 0.63fF
C2051 la_oenb[52] gnd 0.63fF
C2052 la_data_out[52] gnd 0.63fF
C2053 la_data_in[52] gnd 0.63fF
C2054 la_oenb[51] gnd 0.63fF
C2055 la_data_out[51] gnd 0.63fF
C2056 la_data_in[51] gnd 0.63fF
C2057 la_oenb[50] gnd 0.63fF
C2058 la_data_out[50] gnd 0.63fF
C2059 la_data_in[50] gnd 0.63fF
C2060 la_oenb[49] gnd 0.63fF
C2061 la_data_out[49] gnd 0.63fF
C2062 la_data_in[49] gnd 0.63fF
C2063 la_oenb[48] gnd 0.63fF
C2064 la_data_out[48] gnd 0.63fF
C2065 la_data_in[48] gnd 0.63fF
C2066 la_oenb[47] gnd 0.63fF
C2067 la_data_out[47] gnd 0.63fF
C2068 la_data_in[47] gnd 0.63fF
C2069 la_oenb[46] gnd 0.63fF
C2070 la_data_out[46] gnd 0.63fF
C2071 la_data_in[46] gnd 0.63fF
C2072 la_oenb[45] gnd 0.63fF
C2073 la_data_out[45] gnd 0.63fF
C2074 la_data_in[45] gnd 0.63fF
C2075 la_oenb[44] gnd 0.63fF
C2076 la_data_out[44] gnd 0.63fF
C2077 la_data_in[44] gnd 0.63fF
C2078 la_oenb[43] gnd 0.63fF
C2079 la_data_out[43] gnd 0.63fF
C2080 la_data_in[43] gnd 0.63fF
C2081 la_oenb[42] gnd 0.63fF
C2082 la_data_out[42] gnd 0.63fF
C2083 la_data_in[42] gnd 0.63fF
C2084 la_oenb[41] gnd 0.63fF
C2085 la_data_out[41] gnd 0.63fF
C2086 la_data_in[41] gnd 0.63fF
C2087 la_oenb[40] gnd 0.63fF
C2088 la_data_out[40] gnd 0.63fF
C2089 la_data_in[40] gnd 0.63fF
C2090 la_oenb[39] gnd 0.63fF
C2091 la_data_out[39] gnd 0.63fF
C2092 la_data_in[39] gnd 0.63fF
C2093 la_oenb[38] gnd 0.63fF
C2094 la_data_out[38] gnd 0.63fF
C2095 la_data_in[38] gnd 0.63fF
C2096 la_oenb[37] gnd 0.63fF
C2097 la_data_out[37] gnd 0.63fF
C2098 la_data_in[37] gnd 0.63fF
C2099 la_oenb[36] gnd 0.63fF
C2100 la_data_out[36] gnd 0.63fF
C2101 la_data_in[36] gnd 0.63fF
C2102 la_oenb[35] gnd 0.63fF
C2103 la_data_out[35] gnd 0.63fF
C2104 la_data_in[35] gnd 0.63fF
C2105 la_oenb[34] gnd 0.63fF
C2106 la_data_out[34] gnd 0.63fF
C2107 la_data_in[34] gnd 0.63fF
C2108 la_oenb[33] gnd 0.63fF
C2109 la_data_out[33] gnd 0.63fF
C2110 la_data_in[33] gnd 0.63fF
C2111 la_oenb[32] gnd 0.63fF
C2112 la_data_out[32] gnd 0.63fF
C2113 la_data_in[32] gnd 0.63fF
C2114 la_oenb[31] gnd 0.63fF
C2115 la_data_out[31] gnd 0.63fF
C2116 la_data_in[31] gnd 0.63fF
C2117 la_oenb[30] gnd 0.63fF
C2118 la_data_out[30] gnd 0.63fF
C2119 la_data_in[30] gnd 0.63fF
C2120 la_oenb[29] gnd 0.63fF
C2121 la_data_out[29] gnd 0.63fF
C2122 la_data_in[29] gnd 0.63fF
C2123 la_oenb[28] gnd 0.63fF
C2124 la_data_out[28] gnd 0.63fF
C2125 la_data_in[28] gnd 0.63fF
C2126 la_oenb[27] gnd 0.63fF
C2127 la_data_out[27] gnd 0.63fF
C2128 la_data_in[27] gnd 0.63fF
C2129 la_oenb[26] gnd 0.63fF
C2130 la_data_out[26] gnd 0.63fF
C2131 la_data_in[26] gnd 0.63fF
C2132 la_oenb[25] gnd 0.63fF
C2133 la_data_out[25] gnd 0.63fF
C2134 la_data_in[25] gnd 0.63fF
C2135 la_oenb[24] gnd 0.63fF
C2136 la_data_out[24] gnd 0.63fF
C2137 la_data_in[24] gnd 0.63fF
C2138 la_oenb[23] gnd 0.63fF
C2139 la_data_out[23] gnd 0.63fF
C2140 la_data_in[23] gnd 0.63fF
C2141 la_oenb[22] gnd 0.63fF
C2142 la_data_out[22] gnd 0.63fF
C2143 la_data_in[22] gnd 0.63fF
C2144 la_oenb[21] gnd 0.63fF
C2145 la_data_out[21] gnd 0.63fF
C2146 la_data_in[21] gnd 0.63fF
C2147 la_oenb[20] gnd 0.63fF
C2148 la_data_out[20] gnd 0.63fF
C2149 la_data_in[20] gnd 0.63fF
C2150 la_oenb[19] gnd 0.63fF
C2151 la_data_out[19] gnd 0.63fF
C2152 la_data_in[19] gnd 0.63fF
C2153 la_oenb[18] gnd 0.63fF
C2154 la_data_out[18] gnd 0.63fF
C2155 la_data_in[18] gnd 0.63fF
C2156 la_oenb[17] gnd 0.63fF
C2157 la_data_out[17] gnd 0.63fF
C2158 la_data_in[17] gnd 0.63fF
C2159 la_oenb[16] gnd 0.63fF
C2160 la_data_out[16] gnd 0.63fF
C2161 la_data_in[16] gnd 0.63fF
C2162 la_oenb[15] gnd 0.63fF
C2163 la_data_out[15] gnd 0.63fF
C2164 la_data_in[15] gnd 0.63fF
C2165 la_oenb[14] gnd 0.63fF
C2166 la_data_out[14] gnd 0.63fF
C2167 la_data_in[14] gnd 0.63fF
C2168 la_oenb[13] gnd 0.63fF
C2169 la_data_out[13] gnd 0.63fF
C2170 la_data_in[13] gnd 0.63fF
C2171 la_oenb[12] gnd 0.63fF
C2172 la_data_out[12] gnd 0.63fF
C2173 la_data_in[12] gnd 0.63fF
C2174 la_oenb[11] gnd 0.63fF
C2175 la_data_out[11] gnd 0.63fF
C2176 la_data_in[11] gnd 0.63fF
C2177 la_oenb[10] gnd 0.63fF
C2178 la_data_out[10] gnd 0.63fF
C2179 la_data_in[10] gnd 0.63fF
C2180 la_oenb[9] gnd 0.63fF
C2181 la_data_out[9] gnd 0.63fF
C2182 la_data_in[9] gnd 0.63fF
C2183 la_oenb[8] gnd 0.63fF
C2184 la_data_out[8] gnd 0.63fF
C2185 la_data_in[8] gnd 0.63fF
C2186 la_oenb[7] gnd 0.63fF
C2187 la_data_out[7] gnd 0.63fF
C2188 la_data_in[7] gnd 0.63fF
C2189 la_oenb[6] gnd 0.63fF
C2190 la_data_out[6] gnd 0.63fF
C2191 la_data_in[6] gnd 0.63fF
C2192 la_oenb[5] gnd 0.63fF
C2193 la_data_out[5] gnd 0.63fF
C2194 la_data_in[5] gnd 0.63fF
C2195 la_oenb[4] gnd 0.63fF
C2196 la_data_out[4] gnd 0.63fF
C2197 la_data_in[4] gnd 0.63fF
C2198 la_oenb[3] gnd 0.63fF
C2199 la_data_out[3] gnd 0.63fF
C2200 la_data_in[3] gnd 0.63fF
C2201 la_oenb[2] gnd 0.63fF
C2202 la_data_out[2] gnd 0.63fF
C2203 la_data_in[2] gnd 0.63fF
C2204 la_oenb[1] gnd 0.63fF
C2205 la_data_out[1] gnd 0.63fF
C2206 la_data_in[1] gnd 0.63fF
C2207 la_oenb[0] gnd 0.63fF
C2208 la_data_out[0] gnd 0.63fF
C2209 la_data_in[0] gnd 0.63fF
C2210 wbs_dat_o[31] gnd 0.63fF
C2211 wbs_dat_i[31] gnd 0.63fF
C2212 wbs_adr_i[31] gnd 0.63fF
C2213 wbs_dat_o[30] gnd 0.63fF
C2214 wbs_dat_i[30] gnd 0.63fF
C2215 wbs_adr_i[30] gnd 0.63fF
C2216 wbs_dat_o[29] gnd 0.63fF
C2217 wbs_dat_i[29] gnd 0.63fF
C2218 wbs_adr_i[29] gnd 0.63fF
C2219 wbs_dat_o[28] gnd 0.63fF
C2220 wbs_dat_i[28] gnd 0.63fF
C2221 wbs_adr_i[28] gnd 0.63fF
C2222 wbs_dat_o[27] gnd 0.63fF
C2223 wbs_dat_i[27] gnd 0.63fF
C2224 wbs_adr_i[27] gnd 0.63fF
C2225 wbs_dat_o[26] gnd 0.63fF
C2226 wbs_dat_i[26] gnd 0.63fF
C2227 wbs_adr_i[26] gnd 0.63fF
C2228 wbs_dat_o[25] gnd 0.63fF
C2229 wbs_dat_i[25] gnd 0.63fF
C2230 wbs_adr_i[25] gnd 0.63fF
C2231 wbs_dat_o[24] gnd 0.63fF
C2232 wbs_dat_i[24] gnd 0.63fF
C2233 wbs_adr_i[24] gnd 0.63fF
C2234 wbs_dat_o[23] gnd 0.63fF
C2235 wbs_dat_i[23] gnd 0.63fF
C2236 wbs_adr_i[23] gnd 0.63fF
C2237 wbs_dat_o[22] gnd 0.63fF
C2238 wbs_dat_i[22] gnd 0.63fF
C2239 wbs_adr_i[22] gnd 0.63fF
C2240 wbs_dat_o[21] gnd 0.63fF
C2241 wbs_dat_i[21] gnd 0.63fF
C2242 wbs_adr_i[21] gnd 0.63fF
C2243 wbs_dat_o[20] gnd 0.63fF
C2244 wbs_dat_i[20] gnd 0.63fF
C2245 wbs_adr_i[20] gnd 0.63fF
C2246 wbs_dat_o[19] gnd 0.63fF
C2247 wbs_dat_i[19] gnd 0.63fF
C2248 wbs_adr_i[19] gnd 0.63fF
C2249 wbs_dat_o[18] gnd 0.63fF
C2250 wbs_dat_i[18] gnd 0.63fF
C2251 wbs_adr_i[18] gnd 0.63fF
C2252 wbs_dat_o[17] gnd 0.63fF
C2253 wbs_dat_i[17] gnd 0.63fF
C2254 wbs_adr_i[17] gnd 0.63fF
C2255 wbs_dat_o[16] gnd 0.63fF
C2256 wbs_dat_i[16] gnd 0.63fF
C2257 wbs_adr_i[16] gnd 0.63fF
C2258 wbs_dat_o[15] gnd 0.63fF
C2259 wbs_dat_i[15] gnd 0.63fF
C2260 wbs_adr_i[15] gnd 0.63fF
C2261 wbs_dat_o[14] gnd 0.63fF
C2262 wbs_dat_i[14] gnd 0.63fF
C2263 wbs_adr_i[14] gnd 0.63fF
C2264 wbs_dat_o[13] gnd 0.63fF
C2265 wbs_dat_i[13] gnd 0.63fF
C2266 wbs_adr_i[13] gnd 0.63fF
C2267 wbs_dat_o[12] gnd 0.63fF
C2268 wbs_dat_i[12] gnd 0.63fF
C2269 wbs_adr_i[12] gnd 0.63fF
C2270 wbs_dat_o[11] gnd 0.63fF
C2271 wbs_dat_i[11] gnd 0.63fF
C2272 wbs_adr_i[11] gnd 0.63fF
C2273 wbs_dat_o[10] gnd 0.63fF
C2274 wbs_dat_i[10] gnd 0.63fF
C2275 wbs_adr_i[10] gnd 0.63fF
C2276 wbs_dat_o[9] gnd 0.63fF
C2277 wbs_dat_i[9] gnd 0.63fF
C2278 wbs_adr_i[9] gnd 0.63fF
C2279 wbs_dat_o[8] gnd 0.63fF
C2280 wbs_dat_i[8] gnd 0.63fF
C2281 wbs_adr_i[8] gnd 0.63fF
C2282 wbs_dat_o[7] gnd 0.63fF
C2283 wbs_dat_i[7] gnd 0.63fF
C2284 wbs_adr_i[7] gnd 0.63fF
C2285 wbs_dat_o[6] gnd 0.63fF
C2286 wbs_dat_i[6] gnd 0.63fF
C2287 wbs_adr_i[6] gnd 0.63fF
C2288 wbs_dat_o[5] gnd 0.63fF
C2289 wbs_dat_i[5] gnd 0.63fF
C2290 wbs_adr_i[5] gnd 0.63fF
C2291 wbs_dat_o[4] gnd 0.63fF
C2292 wbs_dat_i[4] gnd 0.63fF
C2293 wbs_adr_i[4] gnd 0.63fF
C2294 wbs_sel_i[3] gnd 0.63fF
C2295 wbs_dat_o[3] gnd 0.63fF
C2296 wbs_dat_i[3] gnd 0.63fF
C2297 wbs_adr_i[3] gnd 0.63fF
C2298 wbs_sel_i[2] gnd 0.63fF
C2299 wbs_dat_o[2] gnd 0.63fF
C2300 wbs_dat_i[2] gnd 0.63fF
C2301 wbs_adr_i[2] gnd 0.63fF
C2302 wbs_sel_i[1] gnd 0.63fF
C2303 wbs_dat_o[1] gnd 0.63fF
C2304 wbs_dat_i[1] gnd 0.63fF
C2305 wbs_adr_i[1] gnd 0.63fF
C2306 wbs_sel_i[0] gnd 0.63fF
C2307 wbs_dat_o[0] gnd 0.63fF
C2308 wbs_dat_i[0] gnd 0.63fF
C2309 wbs_adr_i[0] gnd 0.63fF
C2310 wbs_we_i gnd 0.63fF
C2311 wbs_stb_i gnd 0.63fF
C2312 wbs_cyc_i gnd 0.63fF
C2313 wbs_ack_o gnd 0.63fF
C2314 wb_rst_i gnd 0.63fF
C2315 wb_clk_i gnd 0.63fF
C2316 m2_494098_659718# gnd 0.80fF **FLOATING
C2317 pll_full_0/divider_0/and_0/Z1 gnd 0.65fF
C2318 pll_full_0/divider_0/and_0/B gnd 2.45fF
C2319 pll_full_0/divider_0/and_0/A gnd 2.35fF
C2320 pll_full_0/divider_0/and_0/out1 gnd 2.99fF
C2321 pll_full_0/divider_0/tspc_2/Z4 gnd 0.86fF
C2322 pll_full_0/divider_0/tspc_2/Z3 gnd 2.26fF
C2323 pll_full_0/divider_0/tspc_2/Z2 gnd 1.46fF
C2324 pll_full_0/divider_0/tspc_2/Z1 gnd 0.99fF
C2325 pll_full_0/divider_0/nor_0/A gnd 7.08fF
C2326 pll_full_0/divider_0/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2327 pll_full_0/divider_0/tspc_1/Z4 gnd 0.86fF
C2328 pll_full_0/divider_0/tspc_1/Z3 gnd 2.26fF
C2329 pll_full_0/divider_0/tspc_1/Z2 gnd 1.46fF
C2330 pll_full_0/divider_0/tspc_1/Z1 gnd 0.99fF
C2331 pll_full_0/divider_0/nor_0/B gnd 7.12fF
C2332 pll_full_0/divider_0/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2333 pll_full_0/divider_0/tspc_2/Q gnd 3.14fF
C2334 pll_full_0/divider_0/tspc_0/Z4 gnd 0.86fF
C2335 pll_full_0/divbuf_0/IN gnd 9.89fF
C2336 pll_full_0/divider_0/tspc_0/Z3 gnd 2.26fF
C2337 pll_full_0/divider_0/tspc_0/Z2 gnd 1.46fF
C2338 pll_full_0/divider_0/tspc_0/Z1 gnd 0.99fF
C2339 pll_full_0/divider_0/nor_1/B gnd 6.48fF
C2340 pll_full_0/divider_0/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2341 pll_full_0/divider_0/tspc_1/Q gnd 3.12fF
C2342 pll_full_0/divider_0/clk gnd 33.42fF
C2343 pll_full_0/divider_0/prescaler_0/nand_1/z1 gnd 0.36fF
C2344 pll_full_0/divider_0/prescaler_0/tspc_0/D gnd 2.64fF
C2345 pll_full_0/divider_0/prescaler_0/tspc_2/Q gnd 3.72fF
C2346 pll_full_0/divider_0/prescaler_0/tspc_1/Q gnd 3.61fF
C2347 pll_full_0/divider_0/prescaler_0/nand_0/z1 gnd 0.36fF
C2348 pll_full_0/divider_0/prescaler_0/tspc_2/D gnd 3.12fF
C2349 pll_full_0/divider_0/and_0/OUT gnd 5.67fF
C2350 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2351 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2352 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 gnd 1.19fF
C2353 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2354 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# gnd 1.47fF **FLOATING
C2355 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2356 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2357 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2358 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2359 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2360 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2361 pll_full_0/divider_0/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2362 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2363 pll_full_0/divider_0/prescaler_0/Out gnd 4.59fF
C2364 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2365 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2366 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2367 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2368 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2369 pll_full_0/divider_0/nor_1/Z1 gnd 1.34fF
C2370 pll_full_0/divider_0/nor_0/Z1 gnd 1.34fF
C2371 pll_full_0/divbuf_1/OUT gnd 363.82fF
C2372 pll_full_0/divbuf_1/OUT5 gnd 350.37fF
C2373 pll_full_0/divbuf_1/OUT4 gnd 133.72fF
C2374 pll_full_0/divbuf_1/OUT3 gnd 34.03fF
C2375 pll_full_0/divbuf_1/OUT2 gnd 8.71fF
C2376 pll_full_0/divbuf_1/a_492_n240# gnd 2.46fF **FLOATING
C2377 pll_full_0/divbuf_0/OUT5 gnd 350.37fF
C2378 pll_full_0/divbuf_0/OUT4 gnd 133.72fF
C2379 pll_full_0/divbuf_0/OUT3 gnd 34.03fF
C2380 pll_full_0/divbuf_0/OUT2 gnd 8.71fF
C2381 pll_full_0/divbuf_0/a_492_n240# gnd 2.46fF **FLOATING
C2382 pll_full_0/ro_complete_0/cbank_2/v gnd 16.43fF
C2383 pll_full_0/ro_complete_0/cbank_2/switch_5/vin gnd 0.78fF
C2384 pll_full_0/ro_complete_0/cbank_2/switch_4/vin gnd 1.50fF
C2385 pll_full_0/ro_complete_0/cbank_2/switch_2/vin gnd 1.30fF
C2386 pll_full_0/ro_complete_0/cbank_2/switch_3/vin gnd 0.56fF
C2387 pll_full_0/ro_complete_0/cbank_2/switch_1/vin gnd 1.14fF
C2388 pll_full_0/ro_complete_0/cbank_2/switch_0/vin gnd 1.02fF
C2389 pll_full_0/ro_complete_0/cbank_1/switch_5/vin gnd 0.78fF
C2390 pll_full_0/ro_complete_0/a0 gnd 5.35fF
C2391 pll_full_0/ro_complete_0/cbank_1/switch_4/vin gnd 1.50fF
C2392 pll_full_0/ro_complete_0/a1 gnd 6.54fF
C2393 pll_full_0/ro_complete_0/cbank_1/switch_2/vin gnd 1.30fF
C2394 pll_full_0/ro_complete_0/a3 gnd 5.96fF
C2395 pll_full_0/ro_complete_0/cbank_1/switch_3/vin gnd 0.56fF
C2396 pll_full_0/ro_complete_0/a2 gnd 5.21fF
C2397 pll_full_0/ro_complete_0/cbank_1/switch_1/vin gnd 1.14fF
C2398 pll_full_0/ro_complete_0/a4 gnd 5.81fF
C2399 pll_full_0/ro_complete_0/cbank_1/switch_0/vin gnd 1.02fF
C2400 pll_full_0/ro_complete_0/a5 gnd 6.74fF
C2401 pll_full_0/ro_complete_0/cbank_0/v gnd 15.12fF
C2402 pll_full_0/ro_complete_0/cbank_0/switch_5/vin gnd 0.78fF
C2403 pll_full_0/ro_complete_0/cbank_0/switch_4/vin gnd 1.50fF
C2404 pll_full_0/ro_complete_0/cbank_0/switch_2/vin gnd 1.30fF
C2405 pll_full_0/ro_complete_0/cbank_0/switch_3/vin gnd 0.56fF
C2406 pll_full_0/ro_complete_0/cbank_0/switch_1/vin gnd 1.14fF
C2407 pll_full_0/ro_complete_0/cbank_0/switch_0/vin gnd 1.02fF
C2408 pll_full_0/ro_complete_0/ro_var_extend_0/vcont gnd 0.27fF
C2409 pll_full_0/filter_0/a_4216_n5230# gnd 418.90fF **FLOATING
C2410 pll_full_0/filter_0/a_4216_n2998# gnd 1.39fF **FLOATING
C2411 pll_full_0/cp_0/down gnd 1.54fF
C2412 pll_full_0/cp_0/upbar gnd 1.79fF
C2413 pll_full_0/cp_0/a_7110_n2840# gnd 0.17fF **FLOATING
C2414 pll_full_0/cp_0/a_3060_n2840# gnd 1.71fF **FLOATING
C2415 pll_full_0/cp_0/a_7110_0# gnd 0.17fF **FLOATING
C2416 pll_full_0/cp_0/a_6370_0# gnd 0.40fF **FLOATING
C2417 pll_full_0/cp_0/a_3060_0# gnd 2.49fF **FLOATING
C2418 pll_full_0/cp_0/a_1710_0# gnd 7.47fF **FLOATING
C2419 pll_full_0/pd_0/UP gnd 6.41fF
C2420 pll_full_0/pd_0/and_pd_0/Z1 gnd 0.39fF
C2421 pll_full_0/pd_0/and_pd_0/Out1 gnd 2.22fF
C2422 pll_full_0/pd_0/tspc_r_1/z5 gnd 1.10fF
C2423 pll_full_0/pd_0/tspc_r_1/Z4 gnd 1.07fF
C2424 pll_full_0/pd_0/tspc_r_1/Qbar gnd 0.88fF
C2425 pll_full_0/pd_0/tspc_r_1/Z2 gnd 1.22fF
C2426 pll_full_0/pd_0/tspc_r_1/Z1 gnd 0.67fF
C2427 pll_full_0/pd_0/tspc_r_1/Qbar1 gnd 1.34fF
C2428 pll_full_0/pd_0/tspc_r_1/Z3 gnd 2.12fF
C2429 pll_full_0/pd_0/REF gnd 6.48fF
C2430 pll_full_0/pd_0/tspc_r_0/z5 gnd 1.10fF
C2431 pll_full_0/pd_0/tspc_r_0/Z4 gnd 1.07fF
C2432 pll_full_0/pd_0/R gnd 3.05fF
C2433 pll_full_0/pd_0/tspc_r_0/Qbar gnd 0.79fF
C2434 pll_full_0/pd_0/tspc_r_0/Z2 gnd 1.22fF
C2435 pll_full_0/pd_0/tspc_r_0/Z1 gnd 0.67fF
C2436 pll_full_0/pd_0/DOWN gnd 7.34fF
C2437 pll_full_0/pd_0/tspc_r_0/Qbar1 gnd 1.34fF
C2438 pll_full_0/pd_0/tspc_r_0/Z3 gnd 2.12fF
C2439 pll_full_0/pd_0/DIV gnd 372.69fF
C2440 divbuf_19/OUT gnd 363.82fF
C2441 divbuf_19/OUT5 gnd 350.37fF
C2442 divbuf_19/OUT4 gnd 133.72fF
C2443 divbuf_19/OUT3 gnd 34.03fF
C2444 divbuf_19/OUT2 gnd 8.71fF
C2445 divbuf_19/IN gnd 0.89fF
C2446 divbuf_19/a_492_n240# gnd 2.46fF **FLOATING
C2447 divbuf_18/OUT gnd 363.82fF
C2448 divbuf_18/OUT5 gnd 350.37fF
C2449 divbuf_18/OUT4 gnd 133.72fF
C2450 divbuf_18/OUT3 gnd 34.03fF
C2451 divbuf_18/OUT2 gnd 8.71fF
C2452 divbuf_18/IN gnd 0.89fF
C2453 divbuf_18/a_492_n240# gnd 2.46fF **FLOATING
C2454 divbuf_17/OUT gnd 363.82fF
C2455 divbuf_17/OUT5 gnd 350.37fF
C2456 divbuf_17/OUT4 gnd 133.72fF
C2457 divbuf_17/OUT3 gnd 34.03fF
C2458 divbuf_17/OUT2 gnd 8.71fF
C2459 divbuf_17/IN gnd 0.89fF
C2460 divbuf_17/a_492_n240# gnd 2.46fF **FLOATING
C2461 divider_2/and_0/Z1 gnd 0.74fF
C2462 divider_2/and_0/B gnd 2.25fF
C2463 divider_2/and_0/A gnd 2.19fF
C2464 divider_2/and_0/out1 gnd 2.93fF
C2465 divider_2/tspc_2/Z4 gnd 0.86fF
C2466 divider_2/tspc_2/Z3 gnd 2.26fF
C2467 divider_2/tspc_2/Z2 gnd 1.46fF
C2468 divider_2/tspc_2/Z1 gnd 0.99fF
C2469 divider_2/nor_0/A gnd 7.04fF
C2470 divider_2/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2471 divider_2/tspc_1/Z4 gnd 0.86fF
C2472 divider_2/tspc_1/Z3 gnd 2.26fF
C2473 divider_2/tspc_1/Z2 gnd 1.46fF
C2474 divider_2/tspc_1/Z1 gnd 0.99fF
C2475 divider_2/nor_0/B gnd 7.05fF
C2476 divider_2/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2477 divider_2/tspc_2/Q gnd 3.14fF
C2478 divider_2/tspc_0/Z4 gnd 0.86fF
C2479 divider_2/Out gnd 1.60fF
C2480 divider_2/tspc_0/Z3 gnd 2.26fF
C2481 divider_2/tspc_0/Z2 gnd 1.46fF
C2482 divider_2/tspc_0/Z1 gnd 0.99fF
C2483 divider_2/nor_1/B gnd 6.44fF
C2484 divider_2/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2485 divider_2/tspc_1/Q gnd 3.12fF
C2486 divider_2/clk gnd 5.63fF
C2487 divider_2/prescaler_0/nand_1/z1 gnd 0.36fF
C2488 divider_2/prescaler_0/tspc_0/D gnd 2.64fF
C2489 divider_2/prescaler_0/tspc_2/Q gnd 3.74fF
C2490 divider_2/prescaler_0/tspc_1/Q gnd 3.61fF
C2491 divider_2/prescaler_0/nand_0/z1 gnd 0.36fF
C2492 divider_2/prescaler_0/tspc_2/D gnd 3.12fF
C2493 divider_2/and_0/OUT gnd 5.62fF
C2494 divider_2/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2495 divider_2/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2496 divider_2/prescaler_0/tspc_2/Z2 gnd 1.46fF
C2497 divider_2/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2498 divider_2/prescaler_0/tspc_2/a_630_n680# gnd 1.14fF **FLOATING
C2499 divider_2/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2500 divider_2/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2501 divider_2/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2502 divider_2/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2503 divider_2/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2504 divider_2/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2505 divider_2/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2506 divider_2/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2507 divider_2/prescaler_0/Out gnd 4.59fF
C2508 divider_2/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2509 divider_2/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2510 divider_2/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2511 divider_2/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2512 divider_2/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2513 divider_2/nor_1/Z1 gnd 1.34fF
C2514 divider_2/mc2 gnd 5.29fF
C2515 divider_2/nor_0/Z1 gnd 1.34fF
C2516 divbuf_16/OUT gnd 363.82fF
C2517 divbuf_16/OUT5 gnd 350.37fF
C2518 divbuf_16/OUT4 gnd 133.72fF
C2519 divbuf_16/OUT3 gnd 34.03fF
C2520 divbuf_16/OUT2 gnd 8.71fF
C2521 divbuf_16/IN gnd 0.89fF
C2522 divbuf_16/a_492_n240# gnd 2.46fF **FLOATING
C2523 divider_1/and_0/Z1 gnd 0.74fF
C2524 divider_1/and_0/B gnd 2.25fF
C2525 divider_1/and_0/A gnd 2.19fF
C2526 divider_1/and_0/out1 gnd 2.93fF
C2527 divider_1/tspc_2/Z4 gnd 0.86fF
C2528 divider_1/tspc_2/Z3 gnd 2.26fF
C2529 divider_1/tspc_2/Z2 gnd 1.46fF
C2530 divider_1/tspc_2/Z1 gnd 0.99fF
C2531 divider_1/nor_0/A gnd 7.04fF
C2532 divider_1/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2533 divider_1/tspc_1/Z4 gnd 0.86fF
C2534 divider_1/tspc_1/Z3 gnd 2.26fF
C2535 divider_1/tspc_1/Z2 gnd 1.46fF
C2536 divider_1/tspc_1/Z1 gnd 0.99fF
C2537 divider_1/nor_0/B gnd 7.05fF
C2538 divider_1/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2539 divider_1/tspc_2/Q gnd 3.14fF
C2540 divider_1/tspc_0/Z4 gnd 0.86fF
C2541 divider_1/Out gnd 1.60fF
C2542 divider_1/tspc_0/Z3 gnd 2.26fF
C2543 divider_1/tspc_0/Z2 gnd 1.46fF
C2544 divider_1/tspc_0/Z1 gnd 0.99fF
C2545 divider_1/nor_1/B gnd 6.33fF
C2546 divider_1/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2547 divider_1/tspc_1/Q gnd 3.12fF
C2548 divider_1/clk gnd 5.63fF
C2549 divider_1/prescaler_0/nand_1/z1 gnd 0.36fF
C2550 divider_1/prescaler_0/tspc_0/D gnd 2.64fF
C2551 divider_1/prescaler_0/tspc_2/Q gnd 3.74fF
C2552 divider_1/prescaler_0/tspc_1/Q gnd 3.61fF
C2553 divider_1/prescaler_0/nand_0/z1 gnd 0.36fF
C2554 divider_1/prescaler_0/tspc_2/D gnd 3.12fF
C2555 divider_1/and_0/OUT gnd 5.62fF
C2556 divider_1/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2557 divider_1/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2558 divider_1/prescaler_0/tspc_2/Z2 gnd 1.46fF
C2559 divider_1/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2560 divider_1/prescaler_0/tspc_2/a_630_n680# gnd 1.14fF **FLOATING
C2561 divider_1/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2562 divider_1/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2563 divider_1/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2564 divider_1/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2565 divider_1/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2566 divider_1/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2567 divider_1/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2568 divider_1/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2569 divider_1/prescaler_0/Out gnd 4.59fF
C2570 divider_1/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2571 divider_1/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2572 divider_1/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2573 divider_1/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2574 divider_1/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2575 divider_1/nor_1/Z1 gnd 1.34fF
C2576 divider_1/mc2 gnd 5.29fF
C2577 divider_1/nor_0/Z1 gnd 1.34fF
C2578 divbuf_15/OUT gnd 363.82fF
C2579 divbuf_15/OUT5 gnd 350.37fF
C2580 divbuf_15/OUT4 gnd 133.72fF
C2581 divbuf_15/OUT3 gnd 34.03fF
C2582 divbuf_15/OUT2 gnd 8.71fF
C2583 divbuf_15/IN gnd 0.89fF
C2584 divbuf_15/a_492_n240# gnd 2.46fF **FLOATING
C2585 divbuf_25/OUT gnd 363.82fF
C2586 divbuf_25/OUT5 gnd 350.37fF
C2587 divbuf_25/OUT4 gnd 133.72fF
C2588 divbuf_25/OUT3 gnd 34.03fF
C2589 divbuf_25/OUT2 gnd 8.71fF
C2590 divbuf_25/IN gnd 0.89fF
C2591 divbuf_25/a_492_n240# gnd 2.46fF **FLOATING
C2592 divbuf_14/OUT gnd 363.82fF
C2593 divbuf_14/OUT5 gnd 350.37fF
C2594 divbuf_14/OUT4 gnd 133.72fF
C2595 divbuf_14/OUT3 gnd 34.03fF
C2596 divbuf_14/OUT2 gnd 8.71fF
C2597 divbuf_14/IN gnd 0.89fF
C2598 divbuf_14/a_492_n240# gnd 2.46fF **FLOATING
C2599 divider_0/and_0/Z1 gnd 0.74fF
C2600 divider_0/and_0/B gnd 2.25fF
C2601 divider_0/and_0/A gnd 2.19fF
C2602 divider_0/and_0/out1 gnd 2.93fF
C2603 divider_0/tspc_2/Z4 gnd 0.86fF
C2604 divider_0/tspc_2/Z3 gnd 2.26fF
C2605 divider_0/tspc_2/Z2 gnd 1.46fF
C2606 divider_0/tspc_2/Z1 gnd 0.99fF
C2607 divider_0/nor_0/A gnd 7.04fF
C2608 divider_0/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2609 divider_0/tspc_1/Z4 gnd 0.86fF
C2610 divider_0/tspc_1/Z3 gnd 2.26fF
C2611 divider_0/tspc_1/Z2 gnd 1.46fF
C2612 divider_0/tspc_1/Z1 gnd 0.99fF
C2613 divider_0/nor_0/B gnd 7.05fF
C2614 divider_0/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2615 divider_0/tspc_2/Q gnd 3.14fF
C2616 divider_0/tspc_0/Z4 gnd 0.86fF
C2617 divider_0/Out gnd 1.60fF
C2618 divider_0/tspc_0/Z3 gnd 2.26fF
C2619 divider_0/tspc_0/Z2 gnd 1.46fF
C2620 divider_0/tspc_0/Z1 gnd 0.99fF
C2621 divider_0/nor_1/B gnd 6.33fF
C2622 divider_0/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2623 divider_0/tspc_1/Q gnd 3.12fF
C2624 divider_0/clk gnd 5.63fF
C2625 divider_0/prescaler_0/nand_1/z1 gnd 0.36fF
C2626 divider_0/prescaler_0/tspc_0/D gnd 2.64fF
C2627 divider_0/prescaler_0/tspc_2/Q gnd 3.64fF
C2628 divider_0/prescaler_0/tspc_1/Q gnd 3.61fF
C2629 divider_0/prescaler_0/nand_0/z1 gnd 0.36fF
C2630 divider_0/prescaler_0/tspc_2/D gnd 3.12fF
C2631 divider_0/and_0/OUT gnd 5.62fF
C2632 divider_0/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2633 divider_0/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2634 divider_0/prescaler_0/tspc_2/Z2 gnd 1.46fF
C2635 divider_0/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2636 divider_0/prescaler_0/tspc_2/a_630_n680# gnd 1.14fF **FLOATING
C2637 divider_0/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2638 divider_0/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2639 divider_0/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2640 divider_0/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2641 divider_0/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2642 divider_0/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2643 divider_0/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2644 divider_0/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2645 divider_0/prescaler_0/Out gnd 4.59fF
C2646 divider_0/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2647 divider_0/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2648 divider_0/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2649 divider_0/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2650 divider_0/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2651 divider_0/nor_1/Z1 gnd 1.34fF
C2652 divider_0/mc2 gnd 5.29fF
C2653 divider_0/nor_0/Z1 gnd 1.34fF
C2654 divbuf_24/OUT gnd 363.82fF
C2655 divbuf_24/OUT5 gnd 350.37fF
C2656 divbuf_24/OUT4 gnd 133.72fF
C2657 divbuf_24/OUT3 gnd 34.03fF
C2658 divbuf_24/OUT2 gnd 8.71fF
C2659 divbuf_24/IN gnd 0.89fF
C2660 divbuf_24/a_492_n240# gnd 2.46fF **FLOATING
C2661 divbuf_13/OUT gnd 363.82fF
C2662 divbuf_13/OUT5 gnd 350.37fF
C2663 divbuf_13/OUT4 gnd 133.72fF
C2664 divbuf_13/OUT3 gnd 34.03fF
C2665 divbuf_13/OUT2 gnd 8.71fF
C2666 divbuf_13/IN gnd 0.89fF
C2667 divbuf_13/a_492_n240# gnd 2.46fF **FLOATING
C2668 divbuf_9/OUT gnd 363.82fF
C2669 divbuf_9/OUT5 gnd 350.37fF
C2670 divbuf_9/OUT4 gnd 133.72fF
C2671 divbuf_9/OUT3 gnd 34.03fF
C2672 divbuf_9/OUT2 gnd 8.71fF
C2673 divbuf_9/IN gnd 0.89fF
C2674 divbuf_9/a_492_n240# gnd 2.46fF **FLOATING
C2675 divbuf_23/OUT gnd 363.82fF
C2676 divbuf_23/OUT5 gnd 350.37fF
C2677 divbuf_23/OUT4 gnd 133.72fF
C2678 divbuf_23/OUT3 gnd 34.03fF
C2679 divbuf_23/OUT2 gnd 8.71fF
C2680 divbuf_23/IN gnd 0.89fF
C2681 divbuf_23/a_492_n240# gnd 2.46fF **FLOATING
C2682 divbuf_12/OUT gnd 363.82fF
C2683 divbuf_12/OUT5 gnd 350.37fF
C2684 divbuf_12/OUT4 gnd 133.72fF
C2685 divbuf_12/OUT3 gnd 34.03fF
C2686 divbuf_12/OUT2 gnd 8.71fF
C2687 divbuf_12/IN gnd 0.89fF
C2688 divbuf_12/a_492_n240# gnd 2.46fF **FLOATING
C2689 divbuf_8/OUT gnd 363.82fF
C2690 divbuf_8/OUT5 gnd 350.37fF
C2691 divbuf_8/OUT4 gnd 133.72fF
C2692 divbuf_8/OUT3 gnd 34.03fF
C2693 divbuf_8/OUT2 gnd 8.71fF
C2694 divbuf_8/IN gnd 0.89fF
C2695 divbuf_8/a_492_n240# gnd 2.46fF **FLOATING
C2696 divbuf_22/OUT gnd 363.82fF
C2697 divbuf_22/OUT5 gnd 350.37fF
C2698 divbuf_22/OUT4 gnd 133.72fF
C2699 divbuf_22/OUT3 gnd 34.03fF
C2700 divbuf_22/OUT2 gnd 8.71fF
C2701 divbuf_22/IN gnd 0.89fF
C2702 divbuf_22/a_492_n240# gnd 2.46fF **FLOATING
C2703 divbuf_11/OUT gnd 363.82fF
C2704 divbuf_11/OUT5 gnd 350.37fF
C2705 divbuf_11/OUT4 gnd 133.72fF
C2706 divbuf_11/OUT3 gnd 34.03fF
C2707 divbuf_11/OUT2 gnd 8.71fF
C2708 divbuf_11/IN gnd 0.89fF
C2709 divbuf_11/a_492_n240# gnd 2.46fF **FLOATING
C2710 divbuf_7/OUT gnd 363.82fF
C2711 divbuf_7/OUT5 gnd 350.37fF
C2712 divbuf_7/OUT4 gnd 133.72fF
C2713 divbuf_7/OUT3 gnd 34.03fF
C2714 divbuf_7/OUT2 gnd 8.71fF
C2715 divbuf_7/IN gnd 0.89fF
C2716 divbuf_7/a_492_n240# gnd 2.46fF **FLOATING
C2717 divbuf_21/OUT gnd 363.82fF
C2718 divbuf_21/OUT5 gnd 350.37fF
C2719 divbuf_21/OUT4 gnd 133.72fF
C2720 divbuf_21/OUT3 gnd 34.03fF
C2721 divbuf_21/OUT2 gnd 8.71fF
C2722 divbuf_21/IN gnd 0.89fF
C2723 divbuf_21/a_492_n240# gnd 2.46fF **FLOATING
C2724 divbuf_20/OUT gnd 363.82fF
C2725 divbuf_20/OUT5 gnd 350.37fF
C2726 divbuf_20/OUT4 gnd 133.72fF
C2727 divbuf_20/OUT3 gnd 34.03fF
C2728 divbuf_20/OUT2 gnd 8.71fF
C2729 divbuf_20/IN gnd 0.89fF
C2730 divbuf_20/a_492_n240# gnd 2.46fF **FLOATING
C2731 divbuf_10/OUT gnd 363.82fF
C2732 divbuf_10/OUT5 gnd 350.37fF
C2733 divbuf_10/OUT4 gnd 133.72fF
C2734 divbuf_10/OUT3 gnd 34.03fF
C2735 divbuf_10/OUT2 gnd 8.71fF
C2736 divbuf_10/IN gnd 0.89fF
C2737 divbuf_10/a_492_n240# gnd 2.46fF **FLOATING
C2738 divbuf_6/OUT gnd 363.82fF
C2739 divbuf_6/OUT5 gnd 350.37fF
C2740 divbuf_6/OUT4 gnd 133.72fF
C2741 divbuf_6/OUT3 gnd 34.03fF
C2742 divbuf_6/OUT2 gnd 8.71fF
C2743 divbuf_6/IN gnd 0.89fF
C2744 divbuf_6/a_492_n240# gnd 2.46fF **FLOATING
C2745 divbuf_5/OUT gnd 363.82fF
C2746 divbuf_5/OUT5 gnd 350.37fF
C2747 divbuf_5/OUT4 gnd 133.72fF
C2748 divbuf_5/OUT3 gnd 34.03fF
C2749 divbuf_5/OUT2 gnd 8.71fF
C2750 divbuf_5/IN gnd 0.89fF
C2751 divbuf_5/a_492_n240# gnd 2.46fF **FLOATING
C2752 divbuf_4/OUT gnd 363.82fF
C2753 divbuf_4/OUT5 gnd 350.37fF
C2754 divbuf_4/OUT4 gnd 133.72fF
C2755 divbuf_4/OUT3 gnd 34.03fF
C2756 divbuf_4/OUT2 gnd 8.71fF
C2757 divbuf_4/IN gnd 0.89fF
C2758 divbuf_4/a_492_n240# gnd 2.46fF **FLOATING
C2759 divbuf_3/OUT gnd 363.82fF
C2760 divbuf_3/OUT5 gnd 350.37fF
C2761 divbuf_3/OUT4 gnd 133.72fF
C2762 divbuf_3/OUT3 gnd 34.03fF
C2763 divbuf_3/OUT2 gnd 8.71fF
C2764 divbuf_3/IN gnd 0.89fF
C2765 divbuf_3/a_492_n240# gnd 2.46fF **FLOATING
C2766 divbuf_2/OUT gnd 363.82fF
C2767 divbuf_2/OUT5 gnd 350.37fF
C2768 divbuf_2/OUT4 gnd 133.72fF
C2769 divbuf_2/OUT3 gnd 34.03fF
C2770 divbuf_2/OUT2 gnd 8.71fF
C2771 divbuf_2/IN gnd 0.89fF
C2772 divbuf_2/a_492_n240# gnd 2.46fF **FLOATING
C2773 divbuf_1/OUT gnd 363.82fF
C2774 divbuf_1/OUT5 gnd 350.37fF
C2775 divbuf_1/OUT4 gnd 133.72fF
C2776 divbuf_1/OUT3 gnd 34.03fF
C2777 divbuf_1/OUT2 gnd 8.71fF
C2778 divbuf_1/IN gnd 0.89fF
C2779 divbuf_1/a_492_n240# gnd 2.46fF **FLOATING
C2780 ro_complete_1/cbank_2/v gnd 16.43fF
C2781 ro_complete_1/cbank_2/switch_5/vin gnd 0.78fF
C2782 ro_complete_1/cbank_2/switch_4/vin gnd 1.50fF
C2783 ro_complete_1/cbank_2/switch_2/vin gnd 1.30fF
C2784 ro_complete_1/cbank_2/switch_3/vin gnd 0.56fF
C2785 ro_complete_1/cbank_2/switch_1/vin gnd 1.14fF
C2786 ro_complete_1/cbank_2/switch_0/vin gnd 1.02fF
C2787 ro_complete_1/cbank_1/v gnd 16.43fF
C2788 ro_complete_1/cbank_1/switch_5/vin gnd 0.78fF
C2789 ro_complete_1/a0 gnd 5.35fF
C2790 ro_complete_1/cbank_1/switch_4/vin gnd 1.50fF
C2791 ro_complete_1/a1 gnd 6.54fF
C2792 ro_complete_1/cbank_1/switch_2/vin gnd 1.30fF
C2793 ro_complete_1/a3 gnd 5.96fF
C2794 ro_complete_1/cbank_1/switch_3/vin gnd 0.56fF
C2795 ro_complete_1/a2 gnd 5.21fF
C2796 ro_complete_1/cbank_1/switch_1/vin gnd 1.14fF
C2797 ro_complete_1/a4 gnd 5.81fF
C2798 ro_complete_1/cbank_1/switch_0/vin gnd 1.02fF
C2799 ro_complete_1/a5 gnd 6.74fF
C2800 ro_complete_1/cbank_0/v gnd 15.12fF
C2801 ro_complete_1/cbank_0/switch_5/vin gnd 0.78fF
C2802 ro_complete_1/cbank_0/switch_4/vin gnd 1.50fF
C2803 ro_complete_1/cbank_0/switch_2/vin gnd 1.30fF
C2804 ro_complete_1/cbank_0/switch_3/vin gnd 0.56fF
C2805 ro_complete_1/cbank_0/switch_1/vin gnd 1.14fF
C2806 ro_complete_1/cbank_0/switch_0/vin gnd 1.02fF
C2807 ro_complete_1/ro_var_extend_0/vcont gnd 0.27fF
C2808 divbuf_0/OUT gnd 363.82fF
C2809 divbuf_0/OUT5 gnd 350.37fF
C2810 divbuf_0/OUT4 gnd 133.72fF
C2811 divbuf_0/OUT3 gnd 34.03fF
C2812 divbuf_0/OUT2 gnd 8.71fF
C2813 divbuf_0/IN gnd 0.89fF
C2814 divbuf_0/a_492_n240# gnd 2.46fF **FLOATING
C2815 ro_complete_0/cbank_2/v gnd 16.43fF
C2816 ro_complete_0/cbank_2/switch_5/vin gnd 0.78fF
C2817 ro_complete_0/cbank_2/switch_4/vin gnd 1.50fF
C2818 ro_complete_0/cbank_2/switch_2/vin gnd 1.30fF
C2819 ro_complete_0/cbank_2/switch_3/vin gnd 0.56fF
C2820 ro_complete_0/cbank_2/switch_1/vin gnd 1.14fF
C2821 ro_complete_0/cbank_2/switch_0/vin gnd 1.02fF
C2822 ro_complete_0/cbank_1/v gnd 16.46fF
C2823 ro_complete_0/cbank_1/switch_5/vin gnd 0.78fF
C2824 ro_complete_0/a0 gnd 5.35fF
C2825 ro_complete_0/cbank_1/switch_4/vin gnd 1.50fF
C2826 ro_complete_0/a1 gnd 6.54fF
C2827 ro_complete_0/cbank_1/switch_2/vin gnd 1.30fF
C2828 ro_complete_0/a3 gnd 5.96fF
C2829 ro_complete_0/cbank_1/switch_3/vin gnd 0.56fF
C2830 ro_complete_0/a2 gnd 5.21fF
C2831 ro_complete_0/cbank_1/switch_1/vin gnd 1.14fF
C2832 ro_complete_0/a4 gnd 5.81fF
C2833 ro_complete_0/cbank_1/switch_0/vin gnd 1.02fF
C2834 ro_complete_0/a5 gnd 6.74fF
C2835 ro_complete_0/cbank_0/v gnd 15.12fF
C2836 ro_complete_0/cbank_0/switch_5/vin gnd 0.78fF
C2837 ro_complete_0/cbank_0/switch_4/vin gnd 1.50fF
C2838 ro_complete_0/cbank_0/switch_2/vin gnd 1.30fF
C2839 ro_complete_0/cbank_0/switch_3/vin gnd 0.56fF
C2840 ro_complete_0/cbank_0/switch_1/vin gnd 1.14fF
C2841 ro_complete_0/cbank_0/switch_0/vin gnd 1.02fF
C2842 ro_complete_0/ro_var_extend_0/vcont gnd 0.27fF
C2843 filter_0/v gnd 85.69fF
C2844 filter_0/a_4216_n5230# gnd 418.47fF **FLOATING
C2845 filter_0/a_4216_n2998# gnd 1.03fF **FLOATING
C2846 cp_0/down gnd 1.54fF
C2847 cp_0/vbias gnd 2.41fF
C2848 cp_0/out gnd 5.34fF
C2849 cp_0/upbar gnd 1.50fF
C2850 cp_0/a_7110_n2840# gnd 0.17fF **FLOATING
C2851 cp_0/a_3060_n2840# gnd 1.71fF **FLOATING
C2852 cp_0/a_7110_0# gnd 0.17fF **FLOATING
C2853 cp_0/a_6370_0# gnd 0.40fF **FLOATING
C2854 cp_0/a_3060_0# gnd 1.66fF **FLOATING
C2855 cp_0/a_1710_0# gnd 5.89fF **FLOATING
C2856 cp_0/a_1710_n2840# gnd 4.91fF **FLOATING
C2857 cp_0/a_10_n50# gnd 2.96fF **FLOATING
C2858 pd_1/UP gnd 2.21fF
C2859 pd_1/and_pd_0/Z1 gnd 0.39fF
C2860 pd_1/and_pd_0/Out1 gnd 2.22fF
C2861 pd_1/tspc_r_1/z5 gnd 1.10fF
C2862 pd_1/tspc_r_1/Z4 gnd 1.07fF
C2863 pd_1/tspc_r_1/Qbar gnd 0.88fF
C2864 pd_1/tspc_r_1/Z2 gnd 1.22fF
C2865 pd_1/tspc_r_1/Z1 gnd 0.67fF
C2866 pd_1/tspc_r_1/Qbar1 gnd 1.34fF
C2867 pd_1/tspc_r_1/Z3 gnd 2.12fF
C2868 pd_1/REF gnd 1.80fF
C2869 pd_1/tspc_r_0/z5 gnd 1.10fF
C2870 pd_1/tspc_r_0/Z4 gnd 1.07fF
C2871 pd_1/R gnd 3.05fF
C2872 pd_1/tspc_r_0/Qbar gnd 0.79fF
C2873 pd_1/tspc_r_0/Z2 gnd 1.22fF
C2874 pd_1/tspc_r_0/Z1 gnd 0.67fF
C2875 pd_1/DOWN gnd 3.08fF
C2876 pd_1/tspc_r_0/Qbar1 gnd 1.34fF
C2877 pd_1/tspc_r_0/Z3 gnd 2.12fF
C2878 pd_1/DIV gnd 1.82fF
C2879 pd_0/UP gnd 2.21fF
C2880 pd_0/and_pd_0/Z1 gnd 0.39fF
C2881 pd_0/and_pd_0/Out1 gnd 2.22fF
C2882 pd_0/tspc_r_1/z5 gnd 1.10fF
C2883 pd_0/tspc_r_1/Z4 gnd 1.07fF
C2884 pd_0/tspc_r_1/Qbar gnd 0.88fF
C2885 pd_0/tspc_r_1/Z2 gnd 1.22fF
C2886 pd_0/tspc_r_1/Z1 gnd 0.67fF
C2887 pd_0/tspc_r_1/Qbar1 gnd 1.34fF
C2888 pd_0/tspc_r_1/Z3 gnd 2.12fF
C2889 pd_0/REF gnd 1.80fF
C2890 pd_0/tspc_r_0/z5 gnd 1.10fF
C2891 pd_0/tspc_r_0/Z4 gnd 1.07fF
C2892 pd_0/R gnd 3.05fF
C2893 pd_0/tspc_r_0/Qbar gnd 0.79fF
C2894 pd_0/tspc_r_0/Z2 gnd 1.22fF
C2895 pd_0/tspc_r_0/Z1 gnd 0.67fF
C2896 pd_0/DOWN gnd 3.08fF
C2897 pd_0/tspc_r_0/Qbar1 gnd 1.34fF
C2898 pd_0/tspc_r_0/Z3 gnd 2.12fF
C2899 pd_0/DIV gnd 1.82fF
.ends
