* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[5] io_analog[6] io_analog[7]
+ io_analog[8] io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
C0 divider_0/tspc_1/Z1 divider_0/tspc_2/Q 0.01fF
C1 divider_0/nor_0/B divider_0/tspc_1/a_630_n680# 0.35fF
C2 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a4 0.12fF
C3 divbuf_2/OUT ro_complete_0/cbank_1/switch_0/vin 0.09fF
C4 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/v 1.30fF
C5 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/and_0/OUT 0.05fF
C6 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/IN 5.26fF
C7 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z4 0.00fF
C8 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/divider_0/clk 1.46fF
C9 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/clk 0.14fF
C10 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C11 divbuf_7/OUT2 divbuf_7/OUT3 1.37fF
C12 pll_full_1/pd_0/R pll_full_1/pd_0/tspc_r_1/Z3 0.29fF
C13 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/B 0.29fF
C14 pd_1/tspc_r_0/Qbar pd_1/tspc_r_0/Qbar1 0.01fF
C15 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Z4 0.65fF
C16 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C17 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C18 divbuf_15/OUT4 divbuf_15/OUT5 20.26fF
C19 io_clamp_low[2] io_clamp_high[2] 0.53fF
C20 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C21 divbuf_25/OUT3 divbuf_25/OUT2 1.37fF
C22 divider_0/nor_0/Z1 divider_0/and_0/B 0.18fF
C23 divider_0/tspc_2/Q divider_0/tspc_1/Z2 0.14fF
C24 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z2 0.01fF
C25 divbuf_6/OUT ro_complete_0/cbank_1/v 0.05fF
C26 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/nor_0/A 0.15fF
C27 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/tspc_0/D 0.32fF
C28 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C29 divider_1/mc2 divider_1/and_0/B 0.20fF
C30 divider_0/and_0/out1 divider_0/and_0/B 0.18fF
C31 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/cbank_1/v 1.43fF
C32 io_clamp_high[1] io_analog[5] 0.53fF
C33 divbuf_10/a_492_n240# divbuf_10/OUT2 0.42fF
C34 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/R 0.27fF
C35 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z2 1.07fF
C36 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z3 0.38fF
C37 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_1/B 0.22fF
C38 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z4 0.28fF
C39 divbuf_11/OUT5 divbuf_11/OUT 43.38fF
C40 pd_1/R pd_1/tspc_r_1/Qbar 0.03fF
C41 divbuf_9/a_492_n240# divbuf_9/OUT 0.00fF
C42 divbuf_5/OUT ro_complete_0/cbank_1/switch_3/vin 0.09fF
C43 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/tspc_r_1/z5 0.02fF
C44 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z2 0.25fF
C45 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C46 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C47 pll_full_1/ro_complete_0/cbank_1/switch_4/vin pll_full_1/divider_0/clk 1.46fF
C48 divbuf_14/OUT divbuf_14/a_492_n240# 0.00fF
C49 divider_0/nor_0/B divider_0/and_0/B 0.31fF
C50 divider_0/tspc_2/Q divider_0/nor_0/A 0.55fF
C51 divider_0/and_0/OUT divider_0/prescaler_0/nand_0/z1 0.01fF
C52 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C53 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z2 0.01fF
C54 pll_full_1/pd_0/UP pll_full_1/pd_0/and_pd_0/Out1 0.33fF
C55 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT2 1.37fF
C56 divider_2/tspc_0/Z4 divider_2/tspc_0/Z1 0.00fF
C57 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/switch_5/vin 0.20fF
C58 divbuf_20/IN divbuf_20/OUT5 0.00fF
C59 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/and_0/OUT 0.05fF
C60 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Q 0.91fF
C61 divider_1/tspc_2/Q divider_1/tspc_2/a_630_n680# 0.04fF
C62 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/D 0.03fF
C63 divbuf_8/a_492_n240# divbuf_8/IN 0.13fF
C64 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/z5 0.20fF
C65 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C66 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C67 divider_2/tspc_0/Z3 divider_2/nor_1/B 0.38fF
C68 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z3 0.33fF
C69 pd_1/UP pd_1/and_pd_0/Out1 0.33fF
C70 divbuf_18/OUT divbuf_18/a_492_n240# 0.00fF
C71 divider_2/and_0/OUT divider_2/and_0/Z1 0.04fF
C72 divider_2/prescaler_0/tspc_2/Q divider_2/clk 0.05fF
C73 divbuf_13/OUT4 divbuf_13/OUT 1.11fF
C74 divbuf_4/OUT divbuf_3/OUT 2.71fF
C75 divbuf_0/OUT5 divbuf_0/a_492_n240# 0.01fF
C76 pll_full_1/pd_0/UP pll_full_1/pd_0/and_pd_0/Z1 0.06fF
C77 divider_0/nor_0/B divider_0/tspc_1/Q 0.51fF
C78 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_1/Z2 0.01fF
C79 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z3 0.45fF
C80 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C81 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C82 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.04fF
C83 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z4 0.65fF
C84 divider_0/and_0/OUT divider_0/clk 0.04fF
C85 divbuf_1/OUT5 divbuf_1/OUT3 0.01fF
C86 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C87 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C88 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_0/a_630_n680# 0.04fF
C89 divider_1/nor_0/B divider_1/tspc_1/Z1 0.03fF
C90 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_1/z5 0.02fF
C91 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C92 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_0/A 0.15fF
C93 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C94 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C95 divider_1/prescaler_0/tspc_1/Q divider_1/nor_0/A 0.03fF
C96 divbuf_12/OUT2 divbuf_12/OUT3 1.37fF
C97 pd_1/tspc_r_0/Qbar pd_1/DOWN 0.21fF
C98 pd_0/tspc_r_0/z5 pd_0/tspc_r_1/z5 0.02fF
C99 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z2 0.25fF
C100 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/nand_0/z1 0.07fF
C101 pll_full_0/pd_0/DOWN pll_full_0/pd_0/UP 4.58fF
C102 divbuf_6/OUT divbuf_7/OUT 2.98fF
C103 divbuf_3/OUT ro_complete_0/cbank_2/switch_2/vin 0.09fF
C104 divider_0/tspc_2/Q divider_0/tspc_1/a_630_n680# 0.01fF
C105 divider_0/tspc_1/Z1 divider_0/tspc_1/Z3 0.06fF
C106 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C107 divider_0/nor_0/A divider_0/and_0/A 0.01fF
C108 divider_1/nor_0/B divider_1/tspc_1/Z2 0.30fF
C109 divbuf_6/OUT2 divbuf_6/OUT5 0.02fF
C110 divbuf_6/OUT3 divbuf_6/OUT4 5.16fF
C111 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/R 0.30fF
C112 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Z2 0.25fF
C113 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C114 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C115 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/divider_0/clk 1.46fF
C116 divbuf_11/a_492_n240# divbuf_11/OUT2 0.42fF
C117 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z2 0.01fF
C118 divbuf_17/a_492_n240# divbuf_17/OUT5 0.01fF
C119 divbuf_16/OUT divbuf_16/OUT4 1.11fF
C120 divbuf_23/OUT5 divbuf_23/OUT 43.38fF
C121 pd_1/R pd_1/tspc_r_0/Qbar1 0.01fF
C122 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C123 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Q 0.05fF
C124 divider_2/prescaler_0/m1_2700_2190# divider_2/clk 0.01fF
C125 pll_full_0/pd_0/R pll_full_0/pd_0/UP 0.46fF
C126 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C127 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/nor_1/B 0.06fF
C128 divbuf_3/OUT divbuf_3/OUT2 0.06fF
C129 divbuf_2/OUT2 divbuf_2/a_492_n240# 0.42fF
C130 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C131 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/v 1.30fF
C132 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C133 divider_0/prescaler_0/m1_2700_2190# divider_0/nor_0/A 0.01fF
C134 divider_0/prescaler_0/Out divider_0/tspc_2/Z4 0.12fF
C135 divider_0/tspc_1/Z2 divider_0/tspc_1/Z3 0.16fF
C136 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/D 0.15fF
C137 ro_complete_1/cbank_1/switch_5/vin ro_complete_1/cbank_1/v 1.30fF
C138 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z4 0.01fF
C139 divbuf_19/OUT2 divbuf_19/OUT5 0.02fF
C140 divider_1/prescaler_0/Out divider_1/tspc_2/Z3 0.45fF
C141 divider_1/nor_0/B divider_1/nor_0/A 1.21fF
C142 pll_full_1/pd_0/DOWN pll_full_1/pd_0/R 0.36fF
C143 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z2 0.01fF
C144 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z3 0.45fF
C145 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C146 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C147 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C148 pd_0/DIV pd_0/tspc_r_0/Qbar1 0.12fF
C149 divbuf_22/IN divbuf_22/OUT5 0.00fF
C150 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/z5 0.11fF
C151 divider_2/nor_0/Z1 divider_2/nor_0/B 0.06fF
C152 divbuf_13/a_492_n240# divbuf_13/IN 0.13fF
C153 pd_1/R pd_1/and_pd_0/Z1 0.02fF
C154 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/Qbar 0.01fF
C155 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C156 divbuf_1/OUT2 divbuf_1/OUT5 0.02fF
C157 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_4/vin 0.20fF
C158 pll_full_0/pd_0/UP pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C159 divider_0/tspc_0/Z1 divider_0/tspc_0/Z3 0.06fF
C160 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z4 0.00fF
C161 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Z4 0.21fF
C162 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/nor_1/B 0.38fF
C163 divbuf_5/OUT divbuf_5/OUT2 0.06fF
C164 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/a_492_n240# 0.01fF
C165 divbuf_25/a_492_n240# divbuf_25/OUT5 0.01fF
C166 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/and_0/B 0.08fF
C167 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Q 0.15fF
C168 divider_1/tspc_0/Z1 divider_1/tspc_1/Q 0.01fF
C169 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z3 0.06fF
C170 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_0/Z4 0.04fF
C171 pd_0/R pd_0/UP 0.45fF
C172 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/OUT3 0.01fF
C173 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C174 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z3 0.65fF
C175 divbuf_17/a_492_n240# divbuf_17/OUT 0.00fF
C176 divider_2/tspc_2/Q divider_2/tspc_2/a_630_n680# 0.04fF
C177 divider_2/tspc_0/Z3 divider_2/tspc_0/Z1 0.06fF
C178 divbuf_24/OUT2 divbuf_24/OUT3 1.37fF
C179 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_0/Z2 1.07fF
C180 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/Out 0.21fF
C181 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z3 0.06fF
C182 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.20fF
C183 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.09fF
C184 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/clk 0.11fF
C185 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/R 0.21fF
C186 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C187 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/a_630_n680# 0.19fF
C188 divbuf_25/IN divbuf_25/OUT5 0.00fF
C189 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z3 0.05fF
C190 divider_0/nor_0/A divider_0/tspc_2/Z1 0.03fF
C191 divider_1/tspc_1/Z1 divider_1/tspc_2/Q 0.01fF
C192 divider_1/nor_0/B divider_1/tspc_1/a_630_n680# 0.35fF
C193 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C194 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_1/B 0.06fF
C195 divbuf_7/OUT2 divbuf_7/OUT5 0.02fF
C196 divbuf_7/OUT3 divbuf_7/OUT4 5.16fF
C197 pll_full_1/divbuf_1/OUT2 pll_full_1/divbuf_1/OUT3 1.37fF
C198 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT4 1.11fF
C199 pd_1/DOWN pd_1/R 0.36fF
C200 pd_0/UP pd_0/and_pd_0/Out1 0.33fF
C201 divbuf_23/a_492_n240# divbuf_23/OUT2 0.42fF
C202 divider_2/mc2 divider_2/and_0/out1 0.06fF
C203 divider_2/nor_0/Z1 divider_2/and_0/A 0.80fF
C204 divbuf_15/OUT5 divbuf_15/OUT 43.38fF
C205 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_1/Q 0.01fF
C206 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C207 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/Out 0.05fF
C208 pll_full_1/ro_complete_0/a2 pll_full_1/divider_0/clk 0.11fF
C209 divider_0/mc2 divider_0/and_0/out1 0.06fF
C210 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z3 0.05fF
C211 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/nand_1/z1 0.22fF
C212 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/prescaler_0/tspc_0/D 0.04fF
C213 divbuf_3/a_492_n240# divbuf_3/OUT5 0.01fF
C214 ro_complete_1/a0 ro_complete_1/cbank_1/switch_5/vin 0.09fF
C215 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C216 divider_2/tspc_0/Z4 divider_2/tspc_0/Z3 0.65fF
C217 divider_0/and_0/A divider_0/and_0/B 0.18fF
C218 io_clamp_low[0] io_analog[4] 0.53fF
C219 divider_1/tspc_2/Q divider_1/tspc_1/Z2 0.14fF
C220 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z2 0.01fF
C221 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z4 0.21fF
C222 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/nor_1/B 0.38fF
C223 divider_2/nor_1/Z1 divider_2/and_0/B 0.78fF
C224 divider_1/and_0/out1 divider_1/and_0/B 0.18fF
C225 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/B 0.08fF
C226 divbuf_9/IN divbuf_9/OUT5 0.00fF
C227 pll_full_1/divbuf_0/OUT3 pll_full_1/divbuf_0/OUT2 1.37fF
C228 pll_full_0/pd_0/DIV pll_full_0/pd_0/R 0.51fF
C229 divbuf_17/OUT5 divbuf_17/OUT 43.38fF
C230 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_2/Q 0.19fF
C231 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/clk 0.01fF
C232 divider_2/nor_1/B divider_2/and_0/B 0.29fF
C233 divider_0/mc2 divider_0/nor_0/B 0.06fF
C234 divbuf_0/OUT divbuf_0/OUT2 0.06fF
C235 ro_complete_0/cbank_0/switch_0/vin divbuf_4/OUT 0.12fF
C236 divbuf_5/OUT ro_complete_0/cbank_0/switch_3/vin 0.09fF
C237 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_1/a_630_n680# 0.04fF
C238 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C239 pll_full_1/ro_complete_0/cbank_1/switch_0/vin pll_full_1/divider_0/clk 1.58fF
C240 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Qbar 0.01fF
C241 ro_complete_1/a2 ro_complete_1/cbank_2/switch_2/vin 0.14fF
C242 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C243 divider_0/prescaler_0/tspc_2/D divider_0/prescaler_0/nand_0/z1 0.24fF
C244 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z2 0.23fF
C245 divbuf_4/a_492_n240# divbuf_4/OUT5 0.01fF
C246 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/v 1.30fF
C247 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z2 1.07fF
C248 divbuf_20/OUT2 divbuf_20/OUT 0.06fF
C249 divbuf_20/OUT3 divbuf_20/OUT5 0.01fF
C250 divider_1/nor_0/B divider_1/and_0/B 0.31fF
C251 divider_1/tspc_2/Q divider_1/nor_0/A 0.55fF
C252 divider_1/and_0/OUT divider_1/prescaler_0/nand_0/z1 0.01fF
C253 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/tspc_r_1/z5 0.20fF
C254 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Z4 0.20fF
C255 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C256 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C257 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/clk 0.11fF
C258 divider_2/tspc_0/Z2 divider_2/nor_0/B 0.20fF
C259 divider_2/tspc_0/a_630_n680# divider_2/nor_1/B 0.35fF
C260 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z3 0.05fF
C261 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z4 0.08fF
C262 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C263 divider_2/tspc_2/a_630_n680# divider_2/nor_0/A 0.35fF
C264 divider_2/prescaler_0/tspc_0/D divider_2/clk 0.29fF
C265 divider_0/tspc_0/Z1 divider_0/tspc_0/Z4 0.00fF
C266 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z2 0.19fF
C267 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C268 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z4 0.15fF
C269 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/nor_1/B 0.22fF
C270 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C271 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C272 pll_full_0/pd_0/REF pll_full_0/divbuf_1/a_492_n240# 0.13fF
C273 divbuf_17/IN divbuf_17/a_492_n240# 0.13fF
C274 divider_1/mc2 divider_1/and_0/OUT 0.05fF
C275 divbuf_14/OUT divbuf_14/OUT4 1.11fF
C276 divider_0/and_0/OUT divider_0/and_0/out1 0.31fF
C277 divider_0/prescaler_0/tspc_2/D divider_0/clk 0.26fF
C278 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/switch_0/vin 0.19fF
C279 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/Z1 0.36fF
C280 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_1/Q 0.01fF
C281 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C282 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/Out 0.05fF
C283 pll_full_0/ro_complete_0/a2 pll_full_0/divider_0/clk 0.11fF
C284 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z1 0.06fF
C285 divider_1/nor_0/B divider_1/tspc_1/Q 0.51fF
C286 divider_1/and_0/OUT divider_1/clk 0.04fF
C287 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C288 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C289 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/Qbar 0.01fF
C290 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Qbar1 0.38fF
C291 divider_2/prescaler_0/tspc_1/Z2 divider_2/and_0/OUT 0.06fF
C292 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z3 0.33fF
C293 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Q 0.38fF
C294 divider_2/prescaler_0/tspc_0/Z2 divider_2/clk 0.11fF
C295 divbuf_12/OUT2 divbuf_12/OUT5 0.02fF
C296 divbuf_12/OUT3 divbuf_12/OUT4 5.16fF
C297 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C298 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C299 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT3 0.26fF
C300 divider_2/and_0/out1 divider_2/and_0/A 0.01fF
C301 divbuf_14/OUT2 divbuf_14/OUT 0.06fF
C302 divider_0/tspc_1/Q divider_0/tspc_1/Z3 0.05fF
C303 divider_0/tspc_1/Z1 divider_0/tspc_1/Z4 0.00fF
C304 divider_0/Out divider_0/nor_1/B 0.22fF
C305 divbuf_2/OUT ro_complete_0/cbank_1/v 0.10fF
C306 ro_complete_0/cbank_0/switch_5/vin divbuf_7/OUT 0.09fF
C307 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_2/Z3 0.05fF
C308 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/clk 0.11fF
C309 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT 43.38fF
C310 divbuf_16/a_492_n240# divbuf_16/OUT 0.00fF
C311 divbuf_6/OUT4 divbuf_6/OUT5 20.26fF
C312 pll_full_1/divbuf_1/a_492_n240# pll_full_1/divbuf_1/OUT5 0.01fF
C313 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.04fF
C314 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C315 pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_0/divider_0/clk 1.58fF
C316 divider_2/prescaler_0/Out divider_2/prescaler_0/m1_2700_2190# 0.11fF
C317 divider_1/tspc_2/Q divider_1/tspc_1/a_630_n680# 0.01fF
C318 divider_1/tspc_1/Z1 divider_1/tspc_1/Z3 0.06fF
C319 divider_1/nor_0/A divider_1/and_0/A 0.01fF
C320 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z2 0.23fF
C321 pd_1/tspc_r_0/z5 pd_1/tspc_r_0/Z3 0.11fF
C322 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/DOWN 0.11fF
C323 divbuf_19/OUT divbuf_19/OUT3 0.26fF
C324 divbuf_19/OUT5 divbuf_19/OUT4 20.26fF
C325 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/clk 0.01fF
C326 pll_full_1/ro_complete_0/cbank_0/switch_5/vin pll_full_1/ro_complete_0/a0 0.09fF
C327 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C328 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C329 divider_0/tspc_1/Z2 divider_0/tspc_1/Z4 0.36fF
C330 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/D 0.05fF
C331 divider_0/prescaler_0/tspc_0/Z3 divider_0/clk 0.64fF
C332 divbuf_1/OUT5 divbuf_1/a_492_n240# 0.01fF
C333 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a4 0.12fF
C334 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C335 divbuf_17/IN divbuf_17/OUT5 0.00fF
C336 ro_complete_1/cbank_0/v ro_complete_1/cbank_2/v 0.04fF
C337 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z4 0.15fF
C338 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/nor_1/B 0.22fF
C339 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C340 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C341 divider_1/prescaler_0/m1_2700_2190# divider_1/nor_0/A 0.01fF
C342 divider_1/prescaler_0/Out divider_1/tspc_2/Z4 0.12fF
C343 divider_1/tspc_1/Z2 divider_1/tspc_1/Z3 0.16fF
C344 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/D 0.15fF
C345 divbuf_22/OUT2 divbuf_22/OUT 0.06fF
C346 divbuf_22/OUT3 divbuf_22/OUT5 0.01fF
C347 pd_0/tspc_r_0/Z3 pd_0/DOWN 0.03fF
C348 divider_2/mc2 divider_2/nor_0/B 0.06fF
C349 divider_2/tspc_2/Q divider_2/tspc_1/Z2 0.14fF
C350 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/Z1 0.36fF
C351 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z4 0.20fF
C352 pd_1/REF pd_1/tspc_r_1/z5 0.04fF
C353 pd_1/tspc_r_1/Z1 pd_1/tspc_r_1/Z2 0.71fF
C354 pll_full_0/pd_0/DOWN pll_full_0/cp_0/a_1710_0# 0.04fF
C355 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/R 0.01fF
C356 divbuf_18/OUT5 divbuf_18/a_492_n240# 0.01fF
C357 divbuf_0/OUT5 divbuf_0/OUT2 0.02fF
C358 ro_complete_0/cbank_0/switch_1/vin divbuf_3/OUT 0.13fF
C359 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/Z4 0.65fF
C360 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.06fF
C361 pll_full_1/ro_complete_0/cbank_1/switch_5/vin pll_full_1/divider_0/clk 1.46fF
C362 divider_0/tspc_1/Z4 divider_0/nor_0/A 0.02fF
C363 divbuf_5/OUT divbuf_5/OUT4 1.11fF
C364 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C365 divider_1/tspc_0/Z1 divider_1/tspc_0/Z3 0.06fF
C366 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z4 0.00fF
C367 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C368 divbuf_21/a_492_n240# divbuf_21/OUT5 0.01fF
C369 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/Z3 0.05fF
C370 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/clk 0.11fF
C371 pd_1/DIV pd_1/tspc_r_0/z5 0.04fF
C372 divbuf_18/OUT3 divbuf_18/OUT 0.26fF
C373 divider_2/tspc_2/Q divider_2/nor_0/A 0.55fF
C374 divider_2/nor_1/B divider_2/tspc_1/Q 0.22fF
C375 divbuf_24/OUT2 divbuf_24/OUT5 0.02fF
C376 divbuf_24/OUT3 divbuf_24/OUT4 5.16fF
C377 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a5 0.09fF
C378 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/v 1.30fF
C379 divider_0/nor_0/B divider_0/tspc_0/Z4 0.02fF
C380 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z4 0.00fF
C381 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_1/Z4 0.65fF
C382 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.04fF
C383 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/clk 0.51fF
C384 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z4 0.12fF
C385 divider_0/tspc_2/Z1 divider_0/tspc_2/Z2 1.07fF
C386 divider_0/nor_0/A divider_0/tspc_2/Z3 0.38fF
C387 divbuf_6/OUT divbuf_6/a_492_n240# 0.00fF
C388 ro_complete_1/a4 ro_complete_1/cbank_2/switch_0/vin 0.12fF
C389 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/a0 0.09fF
C390 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z3 0.06fF
C391 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C392 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C393 divbuf_7/OUT4 divbuf_7/OUT5 20.26fF
C394 pll_full_1/divbuf_1/OUT3 pll_full_1/divbuf_1/OUT4 5.16fF
C395 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT5 43.38fF
C396 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z3 0.05fF
C397 divider_1/nor_0/A divider_1/tspc_2/Z1 0.03fF
C398 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z1 0.17fF
C399 divbuf_19/OUT5 divbuf_19/a_492_n240# 0.01fF
C400 divider_2/mc2 divider_2/and_0/A 0.16fF
C401 divider_2/prescaler_0/tspc_2/Z2 divider_2/and_0/OUT 0.05fF
C402 io_clamp_low[1] io_clamp_high[1] 0.53fF
C403 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Z3 0.05fF
C404 divbuf_2/IN divbuf_2/OUT5 0.00fF
C405 divbuf_7/OUT ro_complete_0/cbank_2/switch_4/vin 0.13fF
C406 ro_complete_0/cbank_0/v ro_complete_0/cbank_1/v 1.27fF
C407 divbuf_14/IN divbuf_14/a_492_n240# 0.13fF
C408 divider_0/mc2 divider_0/and_0/A 0.16fF
C409 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z4 0.12fF
C410 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z3 0.06fF
C411 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/prescaler_0/nand_1/z1 0.01fF
C412 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/clk 0.11fF
C413 divider_2/tspc_0/Z4 divider_2/tspc_0/a_630_n680# 0.12fF
C414 divbuf_3/OUT3 divbuf_3/OUT4 5.16fF
C415 ro_complete_1/a0 ro_complete_1/cbank_1/v 0.05fF
C416 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z3 0.05fF
C417 divbuf_10/a_492_n240# divbuf_10/OUT 0.00fF
C418 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C419 pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_0/divider_0/clk 1.46fF
C420 divider_2/tspc_2/Q divider_2/tspc_1/Z1 0.01fF
C421 divider_2/tspc_1/a_630_n680# divider_2/nor_0/B 0.35fF
C422 divider_1/and_0/A divider_1/and_0/B 0.18fF
C423 divbuf_9/OUT2 divbuf_9/OUT 0.06fF
C424 divbuf_9/OUT3 divbuf_9/OUT5 0.01fF
C425 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z4 0.02fF
C426 divider_2/tspc_1/Z2 divider_2/nor_0/A 0.15fF
C427 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_0/D 0.32fF
C428 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/clk 0.01fF
C429 divider_2/nor_0/B divider_2/and_0/A 0.26fF
C430 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C431 divbuf_5/OUT ro_complete_0/cbank_2/switch_3/vin 0.09fF
C432 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z4 0.20fF
C433 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C434 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/pd_0/tspc_r_1/Z2 0.71fF
C435 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C436 divbuf_1/OUT divbuf_1/OUT4 1.11fF
C437 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_4/vin 0.20fF
C438 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/and_pd_0/Out1 0.05fF
C439 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/OUT2 0.02fF
C440 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a3 0.13fF
C441 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/Q 0.04fF
C442 divider_0/prescaler_0/tspc_1/Z3 divider_0/clk 0.45fF
C443 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z3 0.06fF
C444 divbuf_7/OUT divbuf_7/OUT3 0.26fF
C445 divbuf_4/OUT2 divbuf_4/OUT3 1.37fF
C446 ro_complete_1/cbank_2/switch_0/vin ro_complete_1/cbank_2/v 1.45fF
C447 divider_1/prescaler_0/tspc_2/D divider_1/prescaler_0/nand_0/z1 0.24fF
C448 divbuf_20/OUT4 divbuf_20/OUT 1.11fF
C449 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Z4 0.65fF
C450 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C451 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/clk 0.51fF
C452 divbuf_8/a_492_n240# divbuf_8/OUT5 0.01fF
C453 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT2 0.06fF
C454 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C455 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C456 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C457 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z4 0.12fF
C458 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z2 1.07fF
C459 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Out1 0.05fF
C460 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z2 0.01fF
C461 ro_complete_1/a2 ro_complete_1/cbank_1/switch_3/vin 0.09fF
C462 divbuf_0/OUT2 divbuf_0/a_492_n240# 0.42fF
C463 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/and_pd_0/Z1 0.02fF
C464 divider_0/nor_1/Z1 divider_0/nor_1/B 0.06fF
C465 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.06fF
C466 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C467 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/clk 0.14fF
C468 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/and_0/B 0.78fF
C469 divbuf_14/OUT divbuf_14/OUT3 0.26fF
C470 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/Z1 0.00fF
C471 divider_1/tspc_0/Z1 divider_1/tspc_0/Z4 0.00fF
C472 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z2 0.19fF
C473 divbuf_5/OUT2 divbuf_5/OUT3 1.37fF
C474 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z3 0.05fF
C475 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z2 0.01fF
C476 divider_1/and_0/OUT divider_1/and_0/out1 0.31fF
C477 divider_1/prescaler_0/tspc_2/D divider_1/clk 0.26fF
C478 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C479 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/clk 0.11fF
C480 divbuf_12/OUT3 divbuf_12/OUT 0.26fF
C481 divbuf_12/OUT4 divbuf_12/OUT5 20.26fF
C482 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z4 0.20fF
C483 pd_0/REF pd_0/tspc_r_1/z5 0.04fF
C484 pd_0/tspc_r_1/Z1 pd_0/tspc_r_1/Z2 0.71fF
C485 divider_2/tspc_1/Q divider_2/tspc_0/Z1 0.01fF
C486 divider_2/tspc_1/Z1 divider_2/tspc_1/Z2 1.07fF
C487 divider_2/nor_0/B divider_2/tspc_1/Z3 0.38fF
C488 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z3 0.05fF
C489 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z4 0.08fF
C490 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Q 0.04fF
C491 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT4 1.11fF
C492 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_1/Qbar 0.02fF
C493 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C494 divbuf_5/OUT ro_complete_0/cbank_2/v 0.05fF
C495 divbuf_14/OUT2 divbuf_14/a_492_n240# 0.42fF
C496 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_1/Q 0.13fF
C497 divider_0/prescaler_0/m1_2700_2190# divider_0/and_0/OUT 0.14fF
C498 ro_complete_1/a3 ro_complete_1/cbank_1/v 0.05fF
C499 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C500 divider_1/tspc_1/Q divider_1/tspc_1/Z3 0.05fF
C501 divider_1/tspc_1/Z1 divider_1/tspc_1/Z4 0.00fF
C502 divider_1/Out divider_1/nor_1/B 0.22fF
C503 filter_0/v divbuf_25/OUT4 1.11fF
C504 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C505 divbuf_11/a_492_n240# divbuf_11/OUT 0.00fF
C506 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z3 0.06fF
C507 cp_0/a_1710_n2840# cp_0/upbar 0.29fF
C508 pd_1/R pd_1/REF 0.61fF
C509 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C510 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z2 0.25fF
C511 divbuf_18/OUT5 divbuf_18/OUT 43.38fF
C512 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/switch_1/vin 0.19fF
C513 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar 0.03fF
C514 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Z4 0.12fF
C515 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/Z3 0.45fF
C516 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/nor_1/B 0.40fF
C517 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C518 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_4/vin 0.20fF
C519 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C520 divider_0/prescaler_0/tspc_2/Z4 divider_0/prescaler_0/tspc_2/D 0.11fF
C521 divider_0/prescaler_0/tspc_0/Z4 divider_0/clk 0.12fF
C522 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/B 0.01fF
C523 divider_2/tspc_0/Z4 divider_2/tspc_1/Q 0.15fF
C524 divider_1/tspc_1/Z2 divider_1/tspc_1/Z4 0.36fF
C525 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/D 0.05fF
C526 divider_1/prescaler_0/tspc_0/Z3 divider_1/clk 0.64fF
C527 divbuf_20/a_492_n240# divbuf_20/IN 0.13fF
C528 pll_full_1/cp_0/down pll_full_1/cp_0/a_1710_0# 0.32fF
C529 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/R 0.21fF
C530 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C531 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C532 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/clk 0.14fF
C533 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/B 0.78fF
C534 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z1 0.09fF
C535 pd_0/DIV pd_0/tspc_r_0/Z2 0.19fF
C536 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z3 0.05fF
C537 divider_2/tspc_0/Z3 divider_2/tspc_0/a_630_n680# 0.05fF
C538 divbuf_22/OUT4 divbuf_22/OUT 1.11fF
C539 divbuf_13/a_492_n240# divbuf_13/OUT5 0.01fF
C540 cp_0/upbar cp_0/down 0.02fF
C541 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/z5 0.20fF
C542 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/z5 0.11fF
C543 divbuf_5/OUT ro_complete_0/cbank_1/switch_2/vin 0.14fF
C544 divider_0/tspc_0/a_630_n680# divider_0/Out 0.04fF
C545 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Out1 0.05fF
C546 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.91fF
C547 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C548 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/a1 0.14fF
C549 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/a3 0.09fF
C550 pll_full_0/divbuf_0/OUT2 pll_full_0/divbuf_0/a_492_n240# 0.42fF
C551 divider_0/prescaler_0/tspc_2/Z3 divider_0/clk 0.45fF
C552 ro_complete_1/cbank_2/switch_5/vin ro_complete_1/cbank_2/v 1.30fF
C553 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C554 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/Z4 0.65fF
C555 divider_2/prescaler_0/Out divider_2/tspc_2/Z3 0.45fF
C556 divider_1/tspc_1/Z4 divider_1/nor_0/A 0.02fF
C557 divbuf_21/OUT2 divbuf_21/OUT3 1.37fF
C558 pll_full_1/pd_0/DIV pll_full_1/pd_0/tspc_r_0/Qbar1 0.12fF
C559 pd_0/R pd_0/tspc_r_1/Qbar 0.03fF
C560 divbuf_24/OUT3 divbuf_24/OUT 0.26fF
C561 divbuf_24/OUT4 divbuf_24/OUT5 20.26fF
C562 pd_1/and_pd_0/Out1 pd_1/and_pd_0/Z1 0.18fF
C563 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/z5 0.03fF
C564 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/R 0.21fF
C565 divider_2/nor_0/A divider_2/and_0/B 0.08fF
C566 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Z4 0.65fF
C567 divbuf_2/OUT divbuf_2/OUT2 0.06fF
C568 divbuf_3/IN divbuf_3/a_492_n240# 0.13fF
C569 divbuf_1/a_492_n240# divbuf_1/IN 0.13fF
C570 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/v 1.30fF
C571 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C572 divider_0/tspc_2/Z2 divider_0/tspc_2/Z3 0.16fF
C573 divider_0/nor_0/A divider_0/tspc_2/Z4 0.21fF
C574 divbuf_6/a_492_n240# divbuf_6/OUT2 0.42fF
C575 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z4 0.12fF
C576 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z3 0.45fF
C577 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/nor_1/B 0.40fF
C578 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C579 divider_1/nor_0/B divider_1/tspc_0/Z4 0.02fF
C580 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z4 0.00fF
C581 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z4 0.12fF
C582 divider_1/tspc_2/Z1 divider_1/tspc_2/Z2 1.07fF
C583 divider_1/nor_0/A divider_1/tspc_2/Z3 0.38fF
C584 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/B 0.01fF
C585 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Out1 0.05fF
C586 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Q 0.20fF
C587 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/D 0.09fF
C588 divbuf_23/a_492_n240# divbuf_23/OUT 0.00fF
C589 divbuf_15/OUT divbuf_15/OUT2 0.06fF
C590 divbuf_15/OUT5 divbuf_15/OUT3 0.01fF
C591 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C592 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Z1 0.07fF
C593 divider_0/prescaler_0/Out divider_0/tspc_2/a_630_n680# 0.01fF
C594 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z4 0.00fF
C595 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Q 0.21fF
C596 pll_full_1/divider_0/prescaler_0/tspc_0/D pll_full_1/divider_0/prescaler_0/nand_1/z1 0.21fF
C597 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C598 divbuf_3/OUT4 divbuf_3/OUT5 20.26fF
C599 pll_full_1/pd_0/UP pll_full_1/pd_0/tspc_r_1/Z3 0.03fF
C600 divider_0/and_0/B divider_0/and_0/Z1 0.07fF
C601 divbuf_10/IN divbuf_10/OUT5 0.00fF
C602 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C603 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C604 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z4 0.12fF
C605 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z3 0.06fF
C606 divbuf_22/a_492_n240# divbuf_22/IN 0.13fF
C607 cp_0/a_1710_n2840# cp_0/out 0.61fF
C608 pd_1/DOWN pd_1/and_pd_0/Out1 0.12fF
C609 pd_1/REF pd_1/tspc_r_1/Qbar1 0.12fF
C610 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/nand_1/z1 0.22fF
C611 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/tspc_0/D 0.04fF
C612 divbuf_9/OUT4 divbuf_9/OUT 1.11fF
C613 divbuf_5/OUT ro_complete_0/cbank_0/switch_2/vin 0.14fF
C614 ro_complete_0/cbank_0/switch_1/vin divbuf_4/OUT 0.09fF
C615 ro_complete_0/cbank_0/switch_0/vin divbuf_2/OUT 0.09fF
C616 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z3 0.33fF
C617 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/Z4 0.15fF
C618 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.15fF
C619 pll_full_1/ro_complete_0/a0 pll_full_1/divider_0/clk 0.11fF
C620 pll_full_0/cp_0/upbar pll_full_0/cp_0/down 0.02fF
C621 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C622 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/z5 0.20fF
C623 divider_0/prescaler_0/tspc_1/Z4 divider_0/clk 0.12fF
C624 divbuf_5/OUT divbuf_5/a_492_n240# 0.00fF
C625 divbuf_3/OUT divbuf_3/OUT3 0.26fF
C626 divbuf_1/OUT2 divbuf_1/OUT3 1.37fF
C627 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z4 0.00fF
C628 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT2 0.02fF
C629 divbuf_7/OUT divbuf_7/OUT5 43.38fF
C630 divbuf_4/OUT2 divbuf_4/OUT5 0.02fF
C631 divbuf_4/OUT3 divbuf_4/OUT4 5.16fF
C632 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Z4 0.02fF
C633 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/Q 0.04fF
C634 divider_1/prescaler_0/tspc_1/Z3 divider_1/clk 0.45fF
C635 divbuf_18/OUT3 divbuf_18/OUT5 0.01fF
C636 divider_2/tspc_0/Z3 divider_2/tspc_1/Q 0.45fF
C637 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z3 0.16fF
C638 divbuf_8/OUT2 divbuf_8/OUT3 1.37fF
C639 pll_full_1/divbuf_1/OUT2 pll_full_1/divbuf_1/OUT 0.06fF
C640 pll_full_1/divbuf_1/OUT3 pll_full_1/divbuf_1/OUT5 0.01fF
C641 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C642 divider_2/nor_0/A divider_2/tspc_2/Z2 0.23fF
C643 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C644 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/and_pd_0/Z1 0.18fF
C645 divider_0/prescaler_0/tspc_1/Q divider_0/clk 0.60fF
C646 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C647 divbuf_5/OUT2 divbuf_5/OUT5 0.02fF
C648 divbuf_5/OUT3 divbuf_5/OUT4 5.16fF
C649 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C650 divider_1/nor_1/Z1 divider_1/nor_1/B 0.06fF
C651 divbuf_7/a_492_n240# divbuf_7/OUT2 0.42fF
C652 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C653 divbuf_17/OUT4 divbuf_17/OUT5 20.26fF
C654 pd_0/R pd_0/and_pd_0/Z1 0.02fF
C655 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/z5 0.20fF
C656 divider_2/nor_0/B divider_2/tspc_1/Z4 0.21fF
C657 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z4 0.12fF
C658 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z2 1.07fF
C659 divbuf_12/OUT5 divbuf_12/OUT 43.38fF
C660 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT5 43.38fF
C661 divider_2/and_0/out1 divider_2/and_0/Z1 0.36fF
C662 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C663 divbuf_2/OUT divbuf_2/a_492_n240# 0.00fF
C664 divbuf_15/OUT5 divbuf_15/a_492_n240# 0.01fF
C665 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_1/Q 0.21fF
C666 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_2/D 0.16fF
C667 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/D 0.03fF
C668 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/a_492_n240# 0.01fF
C669 divbuf_25/OUT2 divbuf_25/OUT5 0.02fF
C670 ro_complete_1/a4 ro_complete_1/cbank_2/v 0.05fF
C671 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_0/vin 0.19fF
C672 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z4 0.15fF
C673 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C674 pll_full_0/ro_complete_0/a0 pll_full_0/divider_0/clk 0.11fF
C675 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_1/Q 0.13fF
C676 divider_1/prescaler_0/m1_2700_2190# divider_1/and_0/OUT 0.14fF
C677 divbuf_11/IN divbuf_11/OUT5 0.00fF
C678 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/a_492_n240# 0.00fF
C679 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z4 0.00fF
C680 divbuf_17/OUT3 divbuf_17/OUT5 0.01fF
C681 pd_1/R pd_1/tspc_r_1/Qbar1 0.30fF
C682 pd_1/tspc_r_0/Z3 pd_1/tspc_r_0/Qbar1 0.38fF
C683 pd_0/and_pd_0/Out1 pd_0/and_pd_0/Z1 0.18fF
C684 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/Qbar 0.01fF
C685 divider_2/prescaler_0/tspc_1/Z2 divider_2/clk 0.11fF
C686 divbuf_9/a_492_n240# divbuf_9/IN 0.13fF
C687 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Qbar1 0.12fF
C688 pll_full_1/ro_complete_0/a3 pll_full_1/divider_0/clk 0.11fF
C689 divbuf_7/OUT ro_complete_0/cbank_2/switch_5/vin 0.09fF
C690 pll_full_1/pd_0/UP pll_full_1/pd_0/tspc_r_1/Qbar1 0.11fF
C691 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C692 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a4 0.09fF
C693 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a5 0.09fF
C694 filter_0/v divbuf_25/a_492_n240# 0.00fF
C695 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C696 divider_1/prescaler_0/tspc_2/Z4 divider_1/prescaler_0/tspc_2/D 0.11fF
C697 divider_1/prescaler_0/tspc_0/Z4 divider_1/clk 0.12fF
C698 pd_0/DIV pd_0/R 0.51fF
C699 divbuf_17/OUT4 divbuf_17/OUT 1.11fF
C700 divider_2/mc2 divider_2/prescaler_0/tspc_2/a_630_n680# 0.33fF
C701 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z4 0.12fF
C702 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/a_630_n680# 0.19fF
C703 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/tspc_r_0/Z2 0.71fF
C704 divbuf_13/OUT2 divbuf_13/OUT3 1.37fF
C705 divbuf_4/OUT divbuf_2/OUT 1.95fF
C706 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C707 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/v 1.30fF
C708 divider_0/mc2 divider_0/prescaler_0/tspc_2/a_630_n680# 0.33fF
C709 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.09fF
C710 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/a1 0.14fF
C711 divider_0/prescaler_0/tspc_2/Z4 divider_0/clk 0.12fF
C712 pll_full_1/pd_0/UP pll_full_1/pd_0/DOWN 4.58fF
C713 divider_1/tspc_0/a_630_n680# divider_1/Out 0.04fF
C714 divbuf_5/a_492_n240# divbuf_5/IN 0.13fF
C715 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C716 divbuf_21/OUT2 divbuf_21/OUT5 0.02fF
C717 divbuf_21/OUT3 divbuf_21/OUT4 5.16fF
C718 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/tspc_r_0/Z4 0.14fF
C719 divider_2/prescaler_0/Out divider_2/tspc_2/Z4 0.12fF
C720 divider_1/prescaler_0/tspc_2/Z3 divider_1/clk 0.45fF
C721 divbuf_12/a_492_n240# divbuf_12/OUT2 0.42fF
C722 pd_1/DIV pd_1/tspc_r_0/Qbar1 0.12fF
C723 pd_0/REF pd_0/tspc_r_1/Qbar1 0.12fF
C724 divbuf_17/OUT3 divbuf_17/OUT 0.26fF
C725 filter_0/a_4216_n2998# filter_0/v 0.36fF
C726 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z4 0.14fF
C727 divbuf_24/OUT5 divbuf_24/OUT 43.38fF
C728 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/tspc_0/a_630_n680# 0.01fF
C729 divbuf_6/OUT divbuf_6/OUT2 0.06fF
C730 ro_complete_1/a5 ro_complete_1/cbank_2/switch_0/vin 0.09fF
C731 divider_0/tspc_2/Z2 divider_0/tspc_2/Z4 0.36fF
C732 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/and_pd_0/Out1 0.18fF
C733 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Z4 0.65fF
C734 pll_full_0/ro_complete_0/a3 pll_full_0/divider_0/clk 0.11fF
C735 divider_1/tspc_2/Z2 divider_1/tspc_2/Z3 0.16fF
C736 divider_1/nor_0/A divider_1/tspc_2/Z4 0.21fF
C737 divbuf_23/IN divbuf_23/OUT5 0.00fF
C738 pd_1/DOWN pd_1/tspc_r_0/Z3 0.03fF
C739 divider_2/tspc_1/Z3 divider_2/tspc_1/Z4 0.65fF
C740 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Q 0.04fF
C741 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_492_n240# 0.00fF
C742 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C743 io_clamp_low[0] io_clamp_high[0] 0.53fF
C744 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C745 divbuf_2/OUT3 divbuf_2/OUT5 0.01fF
C746 divider_0/prescaler_0/Out divider_0/nor_0/A 0.15fF
C747 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Z4 0.65fF
C748 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/clk 0.14fF
C749 divider_0/nor_1/Z1 divider_0/and_0/B 0.78fF
C750 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C751 divider_1/prescaler_0/Out divider_1/tspc_2/a_630_n680# 0.01fF
C752 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z4 0.00fF
C753 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Q 0.21fF
C754 divbuf_10/OUT2 divbuf_10/OUT 0.06fF
C755 divbuf_10/OUT3 divbuf_10/OUT5 0.01fF
C756 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C757 divbuf_19/OUT5 divbuf_19/OUT 43.38fF
C758 divider_1/and_0/B divider_1/and_0/Z1 0.07fF
C759 pd_1/tspc_r_1/Z3 pd_1/UP 0.03fF
C760 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/nand_1/z1 0.01fF
C761 divider_2/prescaler_0/tspc_2/Z2 divider_2/clk 0.11fF
C762 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z3 0.05fF
C763 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z4 0.08fF
C764 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/nor_1/B 0.47fF
C765 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_0/Z4 0.65fF
C766 divbuf_3/OUT divbuf_3/OUT5 43.38fF
C767 ro_complete_0/cbank_1/v ro_complete_0/cbank_2/v 1.36fF
C768 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT3 0.26fF
C769 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT4 20.26fF
C770 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C771 pll_full_1/divider_0/tspc_2/Z3 pll_full_1/divider_0/tspc_2/Z4 0.65fF
C772 divbuf_4/OUT4 divbuf_4/OUT5 20.26fF
C773 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z3 0.33fF
C774 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_0/Qbar1 0.20fF
C775 pll_full_0/filter_0/a_4216_n5230# pll_full_0/divider_0/clk 1.58fF
C776 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C777 divbuf_16/OUT2 divbuf_16/OUT5 0.02fF
C778 divider_1/prescaler_0/tspc_1/Z4 divider_1/clk 0.12fF
C779 pd_0/DOWN pd_0/UP 0.46fF
C780 pd_0/tspc_r_0/Z4 pd_0/tspc_r_0/z5 0.04fF
C781 divbuf_8/OUT2 divbuf_8/OUT5 0.02fF
C782 divbuf_8/OUT3 divbuf_8/OUT4 5.16fF
C783 pll_full_1/divbuf_1/OUT4 pll_full_1/divbuf_1/OUT 1.11fF
C784 divbuf_18/IN divbuf_18/a_492_n240# 0.13fF
C785 divider_2/tspc_0/a_630_n680# divider_2/tspc_1/Q 0.01fF
C786 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z4 0.36fF
C787 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_0/D 0.09fF
C788 divbuf_24/a_492_n240# divbuf_24/OUT2 0.42fF
C789 divider_2/tspc_2/Z1 divider_2/tspc_2/Z3 0.06fF
C790 divider_0/tspc_0/Z3 divider_0/Out 0.05fF
C791 divider_0/tspc_0/Z2 divider_0/nor_1/B 0.40fF
C792 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z3 0.33fF
C793 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_0/vin 0.19fF
C794 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_2/a_630_n680# 0.01fF
C795 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/a0 0.13fF
C796 divider_0/and_0/OUT divider_0/and_0/Z1 0.04fF
C797 divider_0/prescaler_0/tspc_2/Q divider_0/clk 0.05fF
C798 divbuf_5/OUT4 divbuf_5/OUT5 20.26fF
C799 divbuf_16/OUT3 divbuf_16/OUT2 1.37fF
C800 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C801 divbuf_16/IN divbuf_16/OUT5 0.00fF
C802 divider_1/prescaler_0/tspc_1/Q divider_1/clk 0.60fF
C803 pd_1/tspc_r_0/Z1 pd_1/tspc_r_0/Z3 0.09fF
C804 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C805 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C806 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z3 0.16fF
C807 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/tspc_1/Q 0.14fF
C808 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/Out 0.04fF
C809 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/nand_0/z1 0.07fF
C810 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/D 0.05fF
C811 divbuf_1/OUT2 divbuf_1/a_492_n240# 0.42fF
C812 divbuf_1/OUT5 divbuf_1/OUT 43.38fF
C813 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C814 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/v 1.30fF
C815 ro_complete_1/a1 ro_complete_1/cbank_1/v 0.05fF
C816 divider_1/mc2 divider_1/and_0/out1 0.06fF
C817 divbuf_14/OUT4 divbuf_14/OUT3 5.16fF
C818 io_clamp_high[2] io_analog[6] 0.53fF
C819 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z2 0.19fF
C820 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_1/Q 0.21fF
C821 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_2/D 0.16fF
C822 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/D 0.03fF
C823 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_1/B 0.47fF
C824 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/Z4 0.65fF
C825 divbuf_11/OUT2 divbuf_11/OUT 0.06fF
C826 divbuf_11/OUT3 divbuf_11/OUT5 0.01fF
C827 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divider_0/tspc_2/Z4 0.65fF
C828 divider_0/nor_0/Z1 divider_0/nor_0/B 0.06fF
C829 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/and_0/B 0.18fF
C830 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C831 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/UP 0.03fF
C832 divider_1/mc2 divider_1/nor_0/B 0.06fF
C833 divbuf_14/OUT2 divbuf_14/OUT3 1.37fF
C834 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Q 0.05fF
C835 divider_0/prescaler_0/m1_2700_2190# divider_0/clk 0.01fF
C836 divbuf_7/OUT ro_complete_0/cbank_2/v 0.05fF
C837 divbuf_20/a_492_n240# divbuf_20/OUT5 0.01fF
C838 divbuf_16/OUT3 divbuf_16/OUT5 0.01fF
C839 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Qbar1 0.38fF
C840 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C841 pd_1/DIV pd_1/tspc_r_0/Z1 0.17fF
C842 pd_0/tspc_r_0/Qbar1 pd_0/R 0.01fF
C843 pd_0/DIV pd_0/tspc_r_0/Z4 0.02fF
C844 pd_0/DOWN pd_0/tspc_r_0/Qbar 0.21fF
C845 divbuf_18/OUT2 divbuf_18/a_492_n240# 0.42fF
C846 divbuf_13/OUT2 divbuf_13/OUT5 0.02fF
C847 divbuf_13/OUT3 divbuf_13/OUT4 5.16fF
C848 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C849 divider_2/and_0/OUT divider_2/and_0/B 0.01fF
C850 ro_complete_0/cbank_1/switch_3/vin divbuf_6/OUT 0.14fF
C851 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z4 0.01fF
C852 pll_full_0/pd_0/REF pll_full_0/divbuf_1/OUT5 0.00fF
C853 ro_complete_1/a4 ro_complete_1/cbank_2/switch_1/vin 0.09fF
C854 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/v 1.30fF
C855 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C856 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_1/Q 0.14fF
C857 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/Out 0.04fF
C858 divbuf_21/OUT3 divbuf_21/OUT 0.26fF
C859 divbuf_21/OUT4 divbuf_21/OUT5 20.26fF
C860 divider_2/prescaler_0/tspc_0/Z3 divider_2/clk 0.64fF
C861 divider_1/prescaler_0/tspc_2/Z4 divider_1/clk 0.12fF
C862 pd_0/tspc_r_1/Z3 pd_0/UP 0.03fF
C863 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/a_630_n680# 0.19fF
C864 pll_full_0/pd_0/DOWN pll_full_0/pd_0/REF 1.48fF
C865 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C866 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Q 0.15fF
C867 divider_0/prescaler_0/tspc_0/Z2 divider_0/and_0/OUT 0.06fF
C868 divbuf_2/OUT divbuf_2/OUT4 1.11fF
C869 divbuf_4/OUT ro_complete_0/cbank_2/switch_0/vin 0.12fF
C870 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_2/a_630_n680# 0.04fF
C871 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/tspc_2/D 0.03fF
C872 divbuf_6/OUT divbuf_6/OUT4 1.11fF
C873 divbuf_3/OUT2 divbuf_3/OUT3 1.37fF
C874 ro_complete_1/a3 ro_complete_1/cbank_2/switch_2/vin 0.09fF
C875 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/B 0.18fF
C876 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C877 divbuf_17/OUT2 divbuf_17/a_492_n240# 0.42fF
C878 divbuf_19/OUT2 divbuf_19/a_492_n240# 0.42fF
C879 divider_1/tspc_2/Z2 divider_1/tspc_2/Z4 0.36fF
C880 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT3 0.26fF
C881 divbuf_23/OUT2 divbuf_23/OUT 0.06fF
C882 divbuf_23/OUT3 divbuf_23/OUT5 0.01fF
C883 pll_full_1/pd_0/DIV pll_full_1/divider_0/and_0/OUT 0.01fF
C884 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C885 pll_full_0/pd_0/R pll_full_0/pd_0/REF 0.61fF
C886 divbuf_15/OUT2 divbuf_15/OUT3 1.37fF
C887 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Z1 0.03fF
C888 pll_full_1/ro_complete_0/a4 pll_full_1/divider_0/clk 0.01fF
C889 divbuf_15/IN divbuf_15/a_492_n240# 0.13fF
C890 divbuf_25/a_492_n240# divbuf_25/IN 0.13fF
C891 divbuf_25/OUT3 divbuf_25/OUT5 0.01fF
C892 divider_0/prescaler_0/Out divider_0/tspc_2/Z2 0.11fF
C893 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/clk 0.01fF
C894 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/a3 0.13fF
C895 divbuf_3/OUT ro_complete_0/cbank_2/v 0.05fF
C896 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/nor_0/A 0.03fF
C897 divider_2/Out divider_2/nor_1/B 0.22fF
C898 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z2 0.01fF
C899 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/v 1.30fF
C900 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C901 divbuf_10/OUT4 divbuf_10/OUT 1.11fF
C902 divider_1/prescaler_0/Out divider_1/nor_0/A 0.15fF
C903 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Z4 0.65fF
C904 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/clk 0.14fF
C905 divider_1/nor_1/Z1 divider_1/and_0/B 0.78fF
C906 divbuf_22/a_492_n240# divbuf_22/OUT5 0.01fF
C907 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C908 cp_0/a_10_n50# cp_0/vbias 0.19fF
C909 pd_1/R pd_1/and_pd_0/Out1 0.33fF
C910 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z1 0.09fF
C911 pd_1/REF pd_1/tspc_r_1/Z2 0.19fF
C912 divider_2/prescaler_0/tspc_0/D divider_2/prescaler_0/nand_1/z1 0.21fF
C913 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C914 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z4 0.12fF
C915 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z2 1.07fF
C916 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Z2 0.30fF
C917 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_2/Q 0.19fF
C918 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/clk 0.01fF
C919 divbuf_4/OUT divbuf_4/OUT3 0.26fF
C920 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/v 1.30fF
C921 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z3 0.05fF
C922 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z4 0.08fF
C923 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C924 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_0/Qbar1 0.11fF
C925 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/a_630_n680# 0.04fF
C926 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C927 divbuf_17/OUT2 divbuf_17/OUT5 0.02fF
C928 divbuf_8/OUT3 divbuf_8/OUT 0.26fF
C929 divbuf_8/OUT4 divbuf_8/OUT5 20.26fF
C930 pd_0/R pd_0/REF 0.61fF
C931 divider_2/tspc_2/Z1 divider_2/tspc_2/Z4 0.00fF
C932 divbuf_3/OUT ro_complete_0/cbank_1/switch_2/vin 0.09fF
C933 divider_0/nor_0/B divider_0/tspc_2/Q 0.22fF
C934 divider_0/tspc_0/a_630_n680# divider_0/nor_1/B 0.35fF
C935 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z3 0.05fF
C936 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z4 0.08fF
C937 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/Z3 0.45fF
C938 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/nor_0/A 1.21fF
C939 divider_0/tspc_2/a_630_n680# divider_0/nor_0/A 0.35fF
C940 divider_0/prescaler_0/tspc_0/D divider_0/clk 0.29fF
C941 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_4/vin 0.20fF
C942 pll_full_1/pd_0/UP pll_full_1/pd_0/R 0.46fF
C943 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C944 divider_1/tspc_0/Z3 divider_1/Out 0.05fF
C945 divider_1/tspc_0/Z2 divider_1/nor_1/B 0.40fF
C946 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z3 0.33fF
C947 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z1 0.03fF
C948 pll_full_0/ro_complete_0/a4 pll_full_0/divider_0/clk 0.01fF
C949 pll_full_1/pd_0/tspc_r_0/Qbar pll_full_1/pd_0/tspc_r_0/Qbar1 0.01fF
C950 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/nor_0/A 0.03fF
C951 divider_1/and_0/OUT divider_1/and_0/Z1 0.04fF
C952 divider_1/prescaler_0/tspc_2/Q divider_1/clk 0.05fF
C953 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z4 0.36fF
C954 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C955 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT2 0.06fF
C956 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/tspc_0/Z3 0.16fF
C957 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C958 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_5/vin 0.20fF
C959 pll_full_0/pd_0/DIV pll_full_0/divider_0/and_0/OUT 0.01fF
C960 divbuf_15/OUT2 divbuf_15/a_492_n240# 0.42fF
C961 divider_0/tspc_1/a_630_n680# divider_0/nor_1/B 0.00fF
C962 divider_0/prescaler_0/tspc_1/Z2 divider_0/and_0/OUT 0.06fF
C963 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z3 0.33fF
C964 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Q 0.38fF
C965 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_0/D 0.11fF
C966 divider_0/nor_0/Z1 divider_0/and_0/A 0.80fF
C967 divider_1/mc2 divider_1/and_0/A 0.16fF
C968 divider_0/and_0/out1 divider_0/and_0/A 0.01fF
C969 ro_complete_1/a5 ro_complete_1/cbank_2/v 0.08fF
C970 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Z1 0.17fF
C971 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C972 io_clamp_low[1] io_analog[5] 0.53fF
C973 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/nand_0/z1 0.07fF
C974 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/D 0.05fF
C975 divbuf_10/a_492_n240# divbuf_10/IN 0.13fF
C976 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z2 0.30fF
C977 divbuf_11/OUT4 divbuf_11/OUT 1.11fF
C978 divbuf_18/OUT2 divbuf_18/OUT 0.06fF
C979 divbuf_17/OUT2 divbuf_17/OUT 0.06fF
C980 divbuf_16/OUT5 divbuf_16/OUT4 20.26fF
C981 divbuf_9/a_492_n240# divbuf_9/OUT5 0.01fF
C982 pd_1/R pd_1/tspc_r_1/Z2 0.21fF
C983 pll_full_1/divbuf_1/OUT5 pll_full_1/divbuf_1/OUT 43.38fF
C984 pll_full_1/ro_complete_0/cbank_1/switch_4/vin pll_full_1/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C985 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z1 0.09fF
C986 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z2 0.19fF
C987 divider_0/tspc_0/Z2 divider_0/tspc_0/a_630_n680# 0.01fF
C988 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_2/Q 0.01fF
C989 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/a_630_n680# 0.35fF
C990 pll_full_1/ro_complete_0/a1 pll_full_1/divider_0/clk 0.11fF
C991 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/tspc_r_1/Qbar1 0.01fF
C992 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/clk 0.01fF
C993 divider_0/nor_0/B divider_0/and_0/A 0.26fF
C994 divbuf_7/OUT divbuf_7/a_492_n240# 0.00fF
C995 divbuf_4/a_492_n240# divbuf_4/OUT2 0.42fF
C996 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_1/Q 0.13fF
C997 divbuf_16/OUT3 divbuf_16/OUT4 5.16fF
C998 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Q 0.05fF
C999 divider_1/prescaler_0/m1_2700_2190# divider_1/clk 0.01fF
C1000 divbuf_20/OUT2 divbuf_20/OUT3 1.37fF
C1001 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z3 0.45fF
C1002 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_0/A 1.21fF
C1003 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/z5 0.11fF
C1004 divider_2/tspc_0/Z2 divider_2/nor_1/B 0.40fF
C1005 divbuf_13/OUT3 divbuf_13/OUT 0.26fF
C1006 divbuf_13/OUT4 divbuf_13/OUT5 20.26fF
C1007 ro_complete_0/cbank_0/switch_3/vin divbuf_6/OUT 0.14fF
C1008 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/v 1.30fF
C1009 ro_complete_0/cbank_0/switch_2/vin divbuf_3/OUT 0.09fF
C1010 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z2 0.14fF
C1011 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C1012 ro_complete_1/a2 ro_complete_1/cbank_2/v 0.05fF
C1013 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/DOWN 0.02fF
C1014 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C1015 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/Out 0.05fF
C1016 divider_0/nor_1/B divider_0/and_0/B 0.29fF
C1017 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/B 0.18fF
C1018 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/a_630_n680# 0.05fF
C1019 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z4 0.01fF
C1020 divbuf_5/a_492_n240# divbuf_5/OUT5 0.01fF
C1021 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z3 0.16fF
C1022 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C1023 divider_2/prescaler_0/tspc_0/Z4 divider_2/clk 0.12fF
C1024 divbuf_21/OUT5 divbuf_21/OUT 43.38fF
C1025 divbuf_12/a_492_n240# divbuf_12/OUT 0.00fF
C1026 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z1 0.09fF
C1027 pd_0/REF pd_0/tspc_r_1/Z2 0.19fF
C1028 pll_full_1/filter_0/a_4216_n5230# pll_full_1/divider_0/clk 1.58fF
C1029 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/a1 0.14fF
C1030 pll_full_1/ro_complete_0/cbank_0/switch_2/vin pll_full_1/ro_complete_0/a3 0.09fF
C1031 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/v 1.30fF
C1032 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/cbank_0/v 1.30fF
C1033 divider_0/tspc_1/Z1 divider_0/tspc_1/Z2 1.07fF
C1034 divider_0/nor_0/B divider_0/tspc_1/Z3 0.38fF
C1035 divider_0/tspc_1/Q divider_0/nor_1/B 0.22fF
C1036 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/and_0/B 0.31fF
C1037 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/nor_0/A 0.55fF
C1038 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/nand_0/z1 0.01fF
C1039 divbuf_3/OUT2 divbuf_3/OUT5 0.02fF
C1040 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/a0 0.09fF
C1041 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT3 1.37fF
C1042 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C1043 divider_1/nor_0/Z1 divider_1/and_0/B 0.18fF
C1044 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Q 0.15fF
C1045 divider_1/prescaler_0/tspc_0/Z2 divider_1/and_0/OUT 0.06fF
C1046 divbuf_6/IN divbuf_6/OUT5 0.00fF
C1047 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_2/Q 0.01fF
C1048 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/a_630_n680# 0.35fF
C1049 pll_full_0/ro_complete_0/a1 pll_full_0/divider_0/clk 0.11fF
C1050 divbuf_11/a_492_n240# divbuf_11/IN 0.13fF
C1051 pd_1/R pd_1/tspc_r_0/Z3 0.27fF
C1052 divbuf_23/OUT4 divbuf_23/OUT 1.11fF
C1053 pll_full_1/ro_complete_0/cbank_0/switch_5/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1054 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Q 0.51fF
C1055 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/tspc_0/Z4 0.36fF
C1056 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar1 0.30fF
C1057 divbuf_2/IN divbuf_2/a_492_n240# 0.13fF
C1058 divider_0/prescaler_0/tspc_2/Z2 divider_0/and_0/OUT 0.05fF
C1059 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/clk 0.06fF
C1060 pll_full_1/pd_0/UP pll_full_1/pd_0/tspc_r_1/z5 0.03fF
C1061 divbuf_19/IN divbuf_19/OUT5 0.00fF
C1062 divbuf_17/OUT4 divbuf_17/OUT3 5.16fF
C1063 divider_1/prescaler_0/Out divider_1/tspc_2/Z2 0.11fF
C1064 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/clk 0.01fF
C1065 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z2 0.14fF
C1066 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C1067 pd_0/DIV pd_0/tspc_r_0/Z3 0.65fF
C1068 divider_2/mc2 divider_2/nor_1/B 0.15fF
C1069 divbuf_22/OUT2 divbuf_22/OUT3 1.37fF
C1070 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/Z4 0.20fF
C1071 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/B 0.18fF
C1072 divider_0/tspc_0/Z2 divider_0/tspc_1/Q 0.14fF
C1073 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1074 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/a_630_n680# 0.01fF
C1075 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z3 0.06fF
C1076 divbuf_4/OUT divbuf_4/OUT5 43.38fF
C1077 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C1078 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1079 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/a3 0.09fF
C1080 divbuf_16/a_492_n240# divbuf_16/OUT2 0.42fF
C1081 divider_0/tspc_1/Z2 divider_0/nor_0/A 0.15fF
C1082 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_0/D 0.32fF
C1083 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/clk 0.01fF
C1084 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/and_0/A 0.01fF
C1085 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z4 0.12fF
C1086 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z2 1.07fF
C1087 divbuf_18/OUT2 divbuf_18/OUT3 1.37fF
C1088 divider_2/nor_1/Z1 divider_2/nor_0/B 0.18fF
C1089 divider_2/prescaler_0/Out divider_2/tspc_2/a_630_n680# 0.01fF
C1090 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_2/Q 0.19fF
C1091 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/clk 0.01fF
C1092 divbuf_21/a_492_n240# divbuf_21/OUT2 0.42fF
C1093 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/B 0.31fF
C1094 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/nor_0/A 0.55fF
C1095 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C1096 pd_1/DIV pd_1/R 0.51fF
C1097 pd_1/tspc_r_0/Z1 pd_1/tspc_r_0/Z2 0.71fF
C1098 pd_0/DOWN pd_0/tspc_r_1/Qbar 0.02fF
C1099 pd_0/R pd_0/tspc_r_1/Qbar1 0.30fF
C1100 divider_2/nor_1/B divider_2/nor_0/B 0.47fF
C1101 divider_2/tspc_0/Z2 divider_2/tspc_0/Z1 1.07fF
C1102 divbuf_8/OUT5 divbuf_8/OUT 43.38fF
C1103 divbuf_24/a_492_n240# divbuf_24/OUT 0.00fF
C1104 divider_2/tspc_2/Z3 divider_2/tspc_2/Z4 0.65fF
C1105 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z3 0.33fF
C1106 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z4 0.12fF
C1107 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1108 divbuf_3/OUT ro_complete_0/cbank_2/switch_1/vin 0.13fF
C1109 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1110 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/nor_0/A 0.01fF
C1111 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/Z4 0.12fF
C1112 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/Z3 0.16fF
C1113 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.15fF
C1114 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1115 divbuf_16/a_492_n240# divbuf_16/IN 0.13fF
C1116 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z2 0.01fF
C1117 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Q 0.51fF
C1118 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z4 0.36fF
C1119 divider_1/nor_0/B divider_1/tspc_2/Q 0.22fF
C1120 divider_1/tspc_0/a_630_n680# divider_1/nor_1/B 0.35fF
C1121 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z3 0.05fF
C1122 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z4 0.08fF
C1123 divider_1/tspc_2/a_630_n680# divider_1/nor_0/A 0.35fF
C1124 divider_1/prescaler_0/tspc_0/D divider_1/clk 0.29fF
C1125 filter_0/v divbuf_25/OUT2 0.06fF
C1126 divbuf_7/IN divbuf_7/OUT5 0.00fF
C1127 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/clk 0.06fF
C1128 divbuf_23/a_492_n240# divbuf_23/IN 0.13fF
C1129 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C1130 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1131 divbuf_15/OUT4 divbuf_15/OUT 1.11fF
C1132 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1133 pll_full_0/cp_0/a_1710_0# pll_full_0/cp_0/down 0.32fF
C1134 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z2 0.01fF
C1135 divider_0/tspc_2/Q divider_0/tspc_1/Z3 0.45fF
C1136 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1137 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1138 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Q 0.04fF
C1139 divbuf_4/OUT ro_complete_0/cbank_2/v 0.05fF
C1140 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/v 1.30fF
C1141 ro_complete_1/a0 ro_complete_1/cbank_2/switch_4/vin 0.13fF
C1142 ro_complete_1/cbank_0/v ro_complete_1/cbank_1/v 1.27fF
C1143 divider_2/tspc_0/Z4 divider_2/tspc_0/Z2 0.36fF
C1144 divider_2/Out divider_2/tspc_0/Z3 0.05fF
C1145 divbuf_16/a_492_n240# divbuf_16/OUT5 0.01fF
C1146 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C1147 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z3 0.06fF
C1148 divider_1/tspc_1/a_630_n680# divider_1/nor_1/B 0.00fF
C1149 divider_1/prescaler_0/tspc_1/Z2 divider_1/and_0/OUT 0.06fF
C1150 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z3 0.33fF
C1151 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Q 0.38fF
C1152 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/D 0.11fF
C1153 divbuf_18/IN divbuf_18/OUT5 0.00fF
C1154 divider_2/tspc_1/a_630_n680# divider_2/nor_1/B 0.00fF
C1155 divider_1/and_0/out1 divider_1/and_0/A 0.01fF
C1156 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/A 0.01fF
C1157 cp_0/a_10_n50# cp_0/a_1710_0# 0.04fF
C1158 divbuf_9/OUT2 divbuf_9/OUT3 1.37fF
C1159 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1160 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C1161 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C1162 ro_complete_0/cbank_2/switch_2/vin ro_complete_0/cbank_2/v 1.30fF
C1163 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z3 0.05fF
C1164 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z1 0.03fF
C1165 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Z3 0.65fF
C1166 divider_1/tspc_0/Z2 divider_1/tspc_0/a_630_n680# 0.01fF
C1167 divbuf_20/OUT2 divbuf_20/OUT5 0.02fF
C1168 divbuf_20/OUT3 divbuf_20/OUT4 5.16fF
C1169 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/nor_0/A 0.01fF
C1170 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z4 0.12fF
C1171 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z3 0.16fF
C1172 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C1173 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_1/Q 0.21fF
C1174 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/clk 0.01fF
C1175 divider_1/nor_0/B divider_1/and_0/A 0.26fF
C1176 pd_0/DOWN pd_0/tspc_r_0/z5 0.03fF
C1177 pd_0/tspc_r_0/Z2 pd_0/R 0.21fF
C1178 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z2 0.01fF
C1179 divbuf_8/a_492_n240# divbuf_8/OUT2 0.42fF
C1180 pd_1/tspc_r_1/Z4 pd_1/tspc_r_1/z5 0.04fF
C1181 divbuf_13/OUT5 divbuf_13/OUT 43.38fF
C1182 ro_complete_0/cbank_1/switch_1/vin divbuf_3/OUT 0.14fF
C1183 pll_full_1/ro_complete_0/cbank_2/switch_2/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C1184 ro_complete_0/cbank_2/switch_3/vin divbuf_6/OUT 0.14fF
C1185 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z1 0.08fF
C1186 divider_0/mc2 divider_0/nor_1/B 0.15fF
C1187 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_1/Z3 0.05fF
C1188 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/cbank_0/v 1.30fF
C1189 pll_full_1/divider_0/and_0/A pll_full_1/divider_0/and_0/B 0.18fF
C1190 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C1191 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1192 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1193 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/a_630_n680# 0.12fF
C1194 pll_full_1/pd_0/R pll_full_1/pd_0/tspc_r_0/Qbar1 0.01fF
C1195 divider_1/nor_1/B divider_1/and_0/B 0.29fF
C1196 divbuf_12/IN divbuf_12/OUT5 0.00fF
C1197 pd_0/DOWN pd_0/and_pd_0/Z1 0.07fF
C1198 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/a1 0.14fF
C1199 filter_0/a_4216_n5230# filter_0/v 0.91fF
C1200 ro_complete_0/cbank_1/switch_4/vin divbuf_7/OUT 0.13fF
C1201 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/nor_0/B 0.18fF
C1202 divbuf_2/OUT ro_complete_0/cbank_2/switch_0/vin 0.09fF
C1203 divider_0/nor_0/B divider_0/tspc_1/Z4 0.21fF
C1204 divider_0/tspc_0/Z3 divider_0/nor_1/B 0.38fF
C1205 pll_full_1/divider_0/prescaler_0/tspc_2/D pll_full_1/divider_0/prescaler_0/nand_0/z1 0.24fF
C1206 divider_0/nor_0/A divider_0/and_0/B 0.08fF
C1207 divbuf_1/OUT divbuf_1/OUT3 0.26fF
C1208 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT4 5.16fF
C1209 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1210 divbuf_6/OUT3 divbuf_6/OUT5 0.01fF
C1211 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C1212 divider_1/tspc_1/Z1 divider_1/tspc_1/Z2 1.07fF
C1213 divider_1/nor_0/B divider_1/tspc_1/Z3 0.38fF
C1214 divider_1/tspc_1/Q divider_1/nor_1/B 0.22fF
C1215 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z3 0.05fF
C1216 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z1 0.03fF
C1217 divbuf_18/OUT2 divbuf_18/OUT5 0.02fF
C1218 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/Z3 0.20fF
C1219 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/DOWN 0.03fF
C1220 divbuf_19/OUT5 divbuf_19/OUT3 0.01fF
C1221 divider_2/nor_0/B divider_2/tspc_2/a_630_n680# 0.01fF
C1222 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/D 0.03fF
C1223 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C1224 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1225 pll_full_1/ro_complete_0/a5 pll_full_1/divider_0/clk 0.15fF
C1226 divbuf_6/OUT ro_complete_0/cbank_2/v 0.05fF
C1227 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Q 0.20fF
C1228 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/D 0.09fF
C1229 divider_0/prescaler_0/tspc_0/Z2 divider_0/clk 0.11fF
C1230 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/out1 0.31fF
C1231 pll_full_1/divider_0/prescaler_0/tspc_2/D pll_full_1/divider_0/clk 0.26fF
C1232 divider_2/tspc_0/Z4 divider_2/nor_0/B 0.02fF
C1233 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/tspc_r_1/Z4 0.14fF
C1234 pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1235 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z3 0.05fF
C1236 divbuf_19/OUT2 divbuf_19/OUT 0.06fF
C1237 divider_1/prescaler_0/tspc_2/Z2 divider_1/and_0/OUT 0.05fF
C1238 divbuf_22/OUT2 divbuf_22/OUT5 0.02fF
C1239 divbuf_22/OUT3 divbuf_22/OUT4 5.16fF
C1240 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Qbar1 0.38fF
C1241 pll_full_0/divider_0/and_0/A pll_full_0/divider_0/and_0/B 0.18fF
C1242 divider_2/tspc_0/Z2 divider_2/tspc_0/Z3 0.16fF
C1243 divbuf_13/a_492_n240# divbuf_13/OUT2 0.42fF
C1244 pd_1/REF pd_1/tspc_r_1/Z4 0.02fF
C1245 pd_1/UP pd_1/tspc_r_1/Qbar 0.21fF
C1246 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/R 0.27fF
C1247 divider_2/prescaler_0/tspc_1/Q divider_2/nor_0/A 0.03fF
C1248 pll_full_1/pd_0/DIV pll_full_1/divider_0/clk 2.26fF
C1249 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/IN 0.00fF
C1250 pll_full_1/ro_complete_0/a1 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1251 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C1252 divider_0/tspc_0/a_630_n680# divider_0/tspc_1/Q 0.01fF
C1253 divider_0/tspc_0/Z2 divider_0/tspc_0/Z3 0.16fF
C1254 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z4 0.36fF
C1255 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/Out 0.05fF
C1256 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_1/Z3 0.05fF
C1257 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z4 0.00fF
C1258 pll_full_1/divbuf_0/IN pll_full_1/divider_0/nor_1/B 0.27fF
C1259 divbuf_5/OUT divbuf_5/OUT3 0.26fF
C1260 divider_1/mc2 divider_1/prescaler_0/tspc_2/a_630_n680# 0.33fF
C1261 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/nand_1/z1 0.22fF
C1262 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/tspc_0/D 0.04fF
C1263 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Qbar1 0.12fF
C1264 pll_full_1/pd_0/tspc_r_0/Z1 pll_full_1/pd_0/DIV 0.17fF
C1265 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C1266 divider_1/tspc_0/Z2 divider_1/tspc_1/Q 0.14fF
C1267 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z3 0.16fF
C1268 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_0/B 0.18fF
C1269 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C1270 divider_2/prescaler_0/Out divider_2/nor_0/A 0.15fF
C1271 divider_1/tspc_1/Z2 divider_1/nor_0/A 0.15fF
C1272 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_0/D 0.32fF
C1273 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/clk 0.01fF
C1274 pd_1/DIV pd_1/tspc_r_0/Z4 0.02fF
C1275 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Qbar1 0.12fF
C1276 divbuf_24/IN divbuf_24/OUT5 0.00fF
C1277 pll_full_0/pd_0/DOWN pll_full_0/pd_0/R 0.36fF
C1278 divbuf_1/OUT2 divbuf_1/OUT 0.06fF
C1279 divbuf_5/OUT ro_complete_0/cbank_1/v 0.05fF
C1280 ro_complete_0/cbank_0/switch_4/vin divbuf_7/OUT 0.13fF
C1281 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z4 0.08fF
C1282 divider_0/tspc_1/Q divider_0/tspc_1/a_630_n680# 0.04fF
C1283 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z3 0.16fF
C1284 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/Z4 0.36fF
C1285 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.05fF
C1286 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/clk 0.64fF
C1287 divider_0/nor_0/A divider_0/tspc_2/Z2 0.23fF
C1288 pll_full_1/pd_0/REF pll_full_1/pd_0/DOWN 1.48fF
C1289 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/R 0.03fF
C1290 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C1291 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z4 0.12fF
C1292 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z2 1.07fF
C1293 pll_full_1/pd_0/REF pll_full_1/divbuf_1/OUT5 0.00fF
C1294 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/DOWN 0.12fF
C1295 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1296 pll_full_0/ro_complete_0/a5 pll_full_0/divider_0/clk 0.15fF
C1297 divbuf_7/OUT3 divbuf_7/OUT5 0.01fF
C1298 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C1299 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/out1 0.31fF
C1300 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/clk 0.26fF
C1301 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z2 0.01fF
C1302 pd_0/tspc_r_1/Z4 pd_0/tspc_r_1/z5 0.04fF
C1303 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/a0 0.13fF
C1304 divider_2/nor_0/Z1 divider_2/and_0/B 0.18fF
C1305 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Out1 0.12fF
C1306 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1307 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1308 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/divider_0/clk 1.46fF
C1309 divbuf_2/OUT2 divbuf_2/OUT3 1.37fF
C1310 divbuf_1/OUT5 divbuf_1/OUT4 20.26fF
C1311 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/v 1.43fF
C1312 divider_0/tspc_2/Q divider_0/tspc_1/Z4 0.15fF
C1313 divider_0/tspc_0/Z4 divider_0/nor_1/B 0.22fF
C1314 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1315 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1316 pll_full_1/divider_0/tspc_1/Z4 pll_full_1/divider_0/nor_0/A 0.02fF
C1317 divider_2/Out divider_2/tspc_0/a_630_n680# 0.04fF
C1318 divider_0/and_0/out1 divider_0/and_0/Z1 0.36fF
C1319 io_clamp_high[0] io_analog[4] 0.53fF
C1320 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/DOWN 0.07fF
C1321 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/DIV 0.04fF
C1322 pll_full_0/ro_complete_0/a1 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1323 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z2 0.01fF
C1324 divider_1/tspc_2/Q divider_1/tspc_1/Z3 0.45fF
C1325 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z3 0.05fF
C1326 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z4 0.08fF
C1327 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Q 0.04fF
C1328 divbuf_10/a_492_n240# divbuf_10/OUT5 0.01fF
C1329 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_1/Z3 0.05fF
C1330 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z4 0.00fF
C1331 pll_full_0/divbuf_0/IN pll_full_0/divider_0/nor_1/B 0.27fF
C1332 divider_2/tspc_2/Q divider_2/nor_0/B 0.22fF
C1333 divbuf_9/OUT2 divbuf_9/OUT5 0.02fF
C1334 divbuf_9/OUT3 divbuf_9/OUT4 5.16fF
C1335 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/cbank_0/switch_1/vin 0.19fF
C1336 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/REF 0.19fF
C1337 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C1338 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C1339 pll_full_0/pd_0/UP pll_full_0/pd_0/tspc_r_1/Qbar 0.21fF
C1340 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_0/Z4 0.02fF
C1341 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1342 pll_full_1/ro_complete_0/cbank_0/v pll_full_1/divider_0/clk 1.27fF
C1343 divbuf_3/OUT divbuf_3/a_492_n240# 0.00fF
C1344 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/switch_5/vin 0.20fF
C1345 pll_full_0/pd_0/DIV pll_full_0/divider_0/clk 2.26fF
C1346 divbuf_25/a_492_n240# divbuf_25/OUT2 0.42fF
C1347 divider_0/tspc_2/Q divider_0/tspc_2/Z3 0.05fF
C1348 divider_0/prescaler_0/tspc_1/Z2 divider_0/clk 0.11fF
C1349 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z4 0.12fF
C1350 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z2 1.07fF
C1351 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z3 0.38fF
C1352 divbuf_7/OUT divbuf_7/OUT2 0.06fF
C1353 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/a_630_n680# 0.19fF
C1354 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/D 0.05fF
C1355 divbuf_20/OUT3 divbuf_20/OUT 0.26fF
C1356 divbuf_20/OUT4 divbuf_20/OUT5 20.26fF
C1357 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z4 0.36fF
C1358 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C1359 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/clk 0.64fF
C1360 pd_0/tspc_r_0/Z2 pd_0/tspc_r_0/Z4 0.14fF
C1361 pd_1/UP pd_1/and_pd_0/Z1 0.06fF
C1362 pll_full_1/ro_complete_0/cbank_2/switch_4/vin pll_full_1/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C1363 divider_0/tspc_0/Z2 divider_0/tspc_0/Z4 0.36fF
C1364 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1365 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z3 0.11fF
C1366 divbuf_4/OUT ro_complete_0/cbank_2/switch_1/vin 0.09fF
C1367 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/v 1.30fF
C1368 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_1/Z4 0.12fF
C1369 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1370 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/switch_5/vin 0.20fF
C1371 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/a0 0.13fF
C1372 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z2 0.16fF
C1373 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z1 0.08fF
C1374 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1375 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1376 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/divider_0/clk 1.46fF
C1377 divider_2/tspc_2/Q divider_2/tspc_1/a_630_n680# 0.01fF
C1378 pll_full_0/divider_0/tspc_1/Z4 pll_full_0/divider_0/nor_0/A 0.02fF
C1379 pd_1/tspc_r_0/Z2 pd_1/R 0.21fF
C1380 pd_0/R pd_0/and_pd_0/Out1 0.33fF
C1381 pd_0/REF pd_0/tspc_r_1/Z4 0.02fF
C1382 pd_0/UP pd_0/tspc_r_1/Qbar 0.21fF
C1383 divider_2/mc2 divider_2/nor_0/A 0.04fF
C1384 divider_2/nor_0/B divider_2/tspc_1/Z2 0.30fF
C1385 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z2 0.01fF
C1386 divbuf_12/OUT2 divbuf_12/OUT 0.06fF
C1387 divbuf_12/OUT3 divbuf_12/OUT5 0.01fF
C1388 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C1389 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1390 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/Out 0.21fF
C1391 divider_2/and_0/out1 divider_2/and_0/B 0.18fF
C1392 divider_0/mc2 divider_0/nor_0/A 0.04fF
C1393 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C1394 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1395 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1396 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/clk 0.45fF
C1397 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/v 1.30fF
C1398 filter_0/v divbuf_25/OUT3 0.26fF
C1399 divbuf_17/OUT2 divbuf_17/OUT3 1.37fF
C1400 divider_1/nor_0/B divider_1/tspc_1/Z4 0.21fF
C1401 divider_1/tspc_0/Z3 divider_1/nor_1/B 0.38fF
C1402 pll_full_1/divbuf_1/a_492_n240# pll_full_1/divbuf_1/OUT 0.00fF
C1403 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/DIV 0.65fF
C1404 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_0/Z4 0.02fF
C1405 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1406 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/divider_0/clk 1.27fF
C1407 divider_1/nor_0/A divider_1/and_0/B 0.08fF
C1408 divbuf_11/a_492_n240# divbuf_11/OUT5 0.01fF
C1409 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z4 0.12fF
C1410 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z2 1.07fF
C1411 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z3 0.38fF
C1412 pd_1/DOWN pd_1/UP 0.46fF
C1413 pd_1/tspc_r_0/z5 pd_1/tspc_r_0/Qbar1 0.20fF
C1414 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z1 0.09fF
C1415 divbuf_19/OUT divbuf_19/OUT4 1.11fF
C1416 divider_2/and_0/OUT divider_2/prescaler_0/nand_0/z1 0.01fF
C1417 divider_2/nor_0/B divider_2/nor_0/A 1.21fF
C1418 pll_full_1/pd_0/DIV pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.03fF
C1419 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1420 divbuf_15/OUT5 divbuf_15/IN 0.00fF
C1421 divbuf_25/OUT3 divbuf_25/OUT4 5.16fF
C1422 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/nor_1/B 0.03fF
C1423 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z2 0.21fF
C1424 divider_0/tspc_1/Z3 divider_0/tspc_1/Z4 0.65fF
C1425 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Q 0.04fF
C1426 divider_0/prescaler_0/Out divider_0/clk 0.51fF
C1427 ro_complete_0/cbank_1/switch_5/vin ro_complete_0/cbank_1/v 1.30fF
C1428 ro_complete_1/a0 ro_complete_1/cbank_2/switch_5/vin 0.09fF
C1429 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C1430 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Q 0.20fF
C1431 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/D 0.09fF
C1432 divider_1/prescaler_0/tspc_0/Z2 divider_1/clk 0.11fF
C1433 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z4 0.12fF
C1434 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1435 pd_0/DIV pd_0/tspc_r_0/Z1 0.17fF
C1436 pd_0/tspc_r_0/Qbar1 pd_0/DOWN 0.11fF
C1437 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z2 0.01fF
C1438 divider_2/tspc_2/Q divider_2/tspc_1/Z3 0.45fF
C1439 divider_2/tspc_0/Z2 divider_2/tspc_0/a_630_n680# 0.01fF
C1440 divbuf_22/OUT3 divbuf_22/OUT 0.26fF
C1441 divbuf_22/OUT4 divbuf_22/OUT5 20.26fF
C1442 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/z5 0.11fF
C1443 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z4 0.20fF
C1444 divider_2/and_0/OUT divider_2/clk 0.04fF
C1445 divbuf_5/OUT divbuf_3/OUT 3.09fF
C1446 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z3 0.05fF
C1447 divbuf_4/OUT ro_complete_0/cbank_1/switch_1/vin 0.09fF
C1448 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.13fF
C1449 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/and_0/OUT 0.14fF
C1450 pll_full_0/pd_0/UP pll_full_0/pd_0/and_pd_0/Z1 0.06fF
C1451 divbuf_14/OUT divbuf_14/OUT5 43.38fF
C1452 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/nand_1/z1 0.01fF
C1453 divider_0/prescaler_0/tspc_2/Z2 divider_0/clk 0.11fF
C1454 divbuf_5/OUT divbuf_5/OUT5 43.38fF
C1455 divbuf_1/OUT divbuf_1/a_492_n240# 0.00fF
C1456 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C1457 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1458 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/Out 0.21fF
C1459 divider_1/tspc_0/a_630_n680# divider_1/tspc_1/Q 0.01fF
C1460 divider_1/tspc_0/Z2 divider_1/tspc_0/Z3 0.16fF
C1461 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z4 0.36fF
C1462 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/Out 0.05fF
C1463 divbuf_21/a_492_n240# divbuf_21/OUT 0.00fF
C1464 divider_2/prescaler_0/Out divider_2/tspc_2/Z2 0.11fF
C1465 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/nand_1/z1 0.22fF
C1466 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/tspc_0/D 0.04fF
C1467 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1468 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/clk 0.45fF
C1469 pd_0/R pd_0/tspc_r_1/Z2 0.21fF
C1470 divider_2/nor_0/B divider_2/tspc_1/Z1 0.03fF
C1471 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C1472 divider_2/nor_0/A divider_2/and_0/A 0.01fF
C1473 divbuf_24/OUT2 divbuf_24/OUT 0.06fF
C1474 divbuf_24/OUT3 divbuf_24/OUT5 0.01fF
C1475 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z4 0.36fF
C1476 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C1477 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.11fF
C1478 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/clk 0.12fF
C1479 divider_0/tspc_2/Z1 divider_0/tspc_2/Z3 0.06fF
C1480 ro_complete_1/a4 ro_complete_1/cbank_1/v 0.05fF
C1481 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1482 divbuf_6/a_492_n240# divbuf_6/IN 0.13fF
C1483 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/nor_1/B 0.03fF
C1484 divider_1/tspc_1/Q divider_1/tspc_1/a_630_n680# 0.04fF
C1485 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z3 0.16fF
C1486 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/pd_0/tspc_r_1/Z3 0.09fF
C1487 divider_1/nor_0/A divider_1/tspc_2/Z2 0.23fF
C1488 pd_1/DOWN pd_1/tspc_r_0/z5 0.03fF
C1489 pd_0/UP pd_0/and_pd_0/Z1 0.06fF
C1490 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z2 0.19fF
C1491 divbuf_19/OUT divbuf_19/a_492_n240# 0.00fF
C1492 divider_2/prescaler_0/m1_2700_2190# divider_2/nor_0/A 0.01fF
C1493 divider_2/tspc_1/Z2 divider_2/tspc_1/Z3 0.16fF
C1494 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/D 0.15fF
C1495 divider_2/mc2 divider_2/and_0/B 0.20fF
C1496 divbuf_23/a_492_n240# divbuf_23/OUT5 0.01fF
C1497 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C1498 divbuf_15/OUT5 divbuf_15/OUT2 0.02fF
C1499 divbuf_15/OUT4 divbuf_15/OUT3 5.16fF
C1500 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divbuf_0/IN 0.04fF
C1501 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C1502 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1503 divider_0/mc2 divider_0/and_0/B 0.20fF
C1504 divbuf_2/OUT2 divbuf_2/OUT5 0.02fF
C1505 divbuf_2/OUT ro_complete_0/cbank_2/v 0.08fF
C1506 divbuf_7/OUT ro_complete_0/cbank_1/switch_5/vin 0.09fF
C1507 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/clk 0.45fF
C1508 pll_full_0/pd_0/DIV pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C1509 divbuf_3/OUT3 divbuf_3/OUT5 0.01fF
C1510 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/IN 0.00fF
C1511 divbuf_10/OUT2 divbuf_10/OUT3 1.37fF
C1512 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C1513 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/and_0/OUT 0.14fF
C1514 divider_1/tspc_2/Q divider_1/tspc_1/Z4 0.15fF
C1515 divider_1/tspc_0/Z4 divider_1/nor_1/B 0.22fF
C1516 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z4 0.12fF
C1517 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z2 1.07fF
C1518 divider_1/and_0/out1 divider_1/and_0/Z1 0.36fF
C1519 pd_1/tspc_r_0/Z4 pd_1/tspc_r_1/Z4 0.02fF
C1520 pd_1/REF pd_1/tspc_r_1/Z3 0.65fF
C1521 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C1522 divider_2/nor_0/B divider_2/and_0/B 0.31fF
C1523 divbuf_9/OUT3 divbuf_9/OUT 0.26fF
C1524 divbuf_9/OUT4 divbuf_9/OUT5 20.26fF
C1525 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_2/v 0.08fF
C1526 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C1527 divbuf_0/OUT3 divbuf_0/OUT4 5.16fF
C1528 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1529 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/z5 0.11fF
C1530 divider_0/nor_1/Z1 divider_0/nor_0/B 0.18fF
C1531 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1532 divbuf_4/OUT divbuf_4/a_492_n240# 0.00fF
C1533 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/v 1.30fF
C1534 pll_full_1/divider_0/tspc_2/Z2 pll_full_1/divider_0/tspc_2/Z3 0.16fF
C1535 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z4 0.21fF
C1536 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C1537 divbuf_7/OUT divbuf_7/OUT4 1.11fF
C1538 divbuf_4/IN divbuf_4/OUT5 0.00fF
C1539 ro_complete_1/cbank_1/v ro_complete_1/cbank_2/v 1.36fF
C1540 divbuf_20/OUT5 divbuf_20/OUT 43.38fF
C1541 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C1542 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/clk 0.12fF
C1543 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/D 0.11fF
C1544 divider_1/tspc_2/Q divider_1/tspc_2/Z3 0.05fF
C1545 divider_1/prescaler_0/tspc_1/Z2 divider_1/clk 0.11fF
C1546 divbuf_8/a_492_n240# divbuf_8/OUT 0.00fF
C1547 pll_full_1/divbuf_1/OUT2 pll_full_1/divbuf_1/OUT5 0.02fF
C1548 pll_full_1/divbuf_0/OUT4 pll_full_1/divbuf_0/OUT5 20.26fF
C1549 divider_2/tspc_0/Z2 divider_2/tspc_1/Q 0.14fF
C1550 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z3 0.06fF
C1551 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z3 0.05fF
C1552 divider_2/nor_0/A divider_2/tspc_2/Z1 0.03fF
C1553 pll_full_1/divbuf_0/a_492_n240# pll_full_1/divbuf_0/IN 0.13fF
C1554 pll_full_1/ro_complete_0/cbank_2/switch_4/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C1555 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z4 0.12fF
C1556 divider_0/tspc_1/Q divider_0/tspc_0/Z3 0.45fF
C1557 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z4 0.28fF
C1558 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/a_630_n680# 0.01fF
C1559 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1560 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1561 divider_0/and_0/OUT divider_0/and_0/B 0.01fF
C1562 ro_complete_1/a5 ro_complete_1/cbank_1/switch_0/vin 0.09fF
C1563 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/v 1.30fF
C1564 pll_full_1/divider_0/and_0/B pll_full_1/divider_0/and_0/Z1 0.07fF
C1565 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C1566 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/Z2 0.36fF
C1567 divider_1/tspc_0/Z2 divider_1/tspc_0/Z4 0.36fF
C1568 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1569 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z3 0.11fF
C1570 divbuf_5/IN divbuf_5/OUT5 0.00fF
C1571 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divbuf_0/IN 0.04fF
C1572 divbuf_7/a_492_n240# divbuf_7/IN 0.13fF
C1573 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/clk 0.45fF
C1574 divbuf_12/OUT4 divbuf_12/OUT 1.11fF
C1575 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z4 0.14fF
C1576 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/z5 0.11fF
C1577 divider_2/tspc_1/Z1 divider_2/tspc_1/Z3 0.06fF
C1578 divider_2/and_0/A divider_2/and_0/B 0.18fF
C1579 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/nor_0/B 0.20fF
C1580 ro_complete_1/a2 ro_complete_1/cbank_0/switch_3/vin 0.09fF
C1581 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Q 0.91fF
C1582 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1583 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 pll_full_1/divider_0/clk 0.12fF
C1584 ro_complete_1/cbank_1/switch_2/vin ro_complete_1/cbank_1/v 1.30fF
C1585 pll_full_1/pd_0/REF pll_full_1/pd_0/R 0.61fF
C1586 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/v 0.08fF
C1587 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C1588 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C1589 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/R 0.33fF
C1590 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1591 divbuf_11/OUT2 divbuf_11/OUT3 1.37fF
C1592 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z3 0.16fF
C1593 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z4 0.21fF
C1594 pd_1/R pd_1/tspc_r_1/Z3 0.29fF
C1595 divider_2/prescaler_0/tspc_2/D divider_2/prescaler_0/nand_0/z1 0.24fF
C1596 divbuf_0/OUT divbuf_0/OUT3 0.26fF
C1597 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z3 0.65fF
C1598 divbuf_2/OUT5 divbuf_2/a_492_n240# 0.01fF
C1599 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/v 1.30fF
C1600 ro_complete_0/cbank_0/v ro_complete_0/cbank_2/v 0.04fF
C1601 pll_full_1/pd_0/tspc_r_0/Z1 pll_full_1/pd_0/tspc_r_0/Z3 0.09fF
C1602 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT4 5.16fF
C1603 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1604 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/clk 0.60fF
C1605 ro_complete_1/a0 ro_complete_1/cbank_2/v 0.05fF
C1606 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/R 0.02fF
C1607 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/IN 0.13fF
C1608 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1609 divider_1/tspc_1/Z3 divider_1/tspc_1/Z4 0.65fF
C1610 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Q 0.04fF
C1611 divider_1/prescaler_0/Out divider_1/clk 0.51fF
C1612 divbuf_20/a_492_n240# divbuf_20/OUT2 0.42fF
C1613 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C1614 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1615 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1616 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z2 0.25fF
C1617 divbuf_22/OUT5 divbuf_22/OUT 43.38fF
C1618 pll_full_1/pd_0/tspc_r_1/Z4 pll_full_1/pd_0/tspc_r_1/z5 0.04fF
C1619 pll_full_0/divider_0/and_0/B pll_full_0/divider_0/and_0/Z1 0.07fF
C1620 divider_2/tspc_2/Q divider_2/tspc_1/Z4 0.15fF
C1621 divbuf_13/a_492_n240# divbuf_13/OUT 0.00fF
C1622 pd_1/UP pd_1/tspc_r_1/z5 0.03fF
C1623 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/nor_0/B 0.06fF
C1624 pll_full_1/ro_complete_0/cbank_0/v pll_full_1/ro_complete_0/cbank_2/v 0.04fF
C1625 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/z5 0.20fF
C1626 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/Qbar 0.21fF
C1627 divider_2/and_0/OUT divider_2/and_0/out1 0.31fF
C1628 divider_2/prescaler_0/tspc_2/D divider_2/clk 0.26fF
C1629 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1630 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1631 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1632 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_2/D 0.16fF
C1633 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.03fF
C1634 divbuf_14/a_492_n240# divbuf_14/OUT5 0.01fF
C1635 divider_0/prescaler_0/tspc_0/D divider_0/prescaler_0/nand_1/z1 0.21fF
C1636 divider_1/tspc_0/a_630_n680# divider_1/tspc_0/Z3 0.05fF
C1637 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/nor_0/B 0.20fF
C1638 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/nand_1/z1 0.01fF
C1639 divider_1/prescaler_0/tspc_2/Z2 divider_1/clk 0.11fF
C1640 divbuf_21/IN divbuf_21/OUT5 0.00fF
C1641 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/clk 0.12fF
C1642 pd_1/DIV pd_1/tspc_r_0/Z3 0.65fF
C1643 pd_0/REF pd_0/tspc_r_1/Z3 0.65fF
C1644 divbuf_12/a_492_n240# divbuf_12/IN 0.13fF
C1645 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1646 divider_2/tspc_2/Q divider_2/tspc_2/Z3 0.05fF
C1647 divider_2/nor_0/B divider_2/tspc_1/Q 0.51fF
C1648 divbuf_24/OUT4 divbuf_24/OUT 1.11fF
C1649 divider_0/tspc_1/Q divider_0/tspc_0/Z4 0.15fF
C1650 divbuf_3/OUT2 divbuf_3/a_492_n240# 0.42fF
C1651 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/tspc_r_1/Z1 0.71fF
C1652 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_0/Z3 0.11fF
C1653 divider_0/tspc_2/Z1 divider_0/tspc_2/Z4 0.00fF
C1654 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z4 0.36fF
C1655 divider_1/tspc_2/Z1 divider_1/tspc_2/Z3 0.06fF
C1656 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/clk 0.60fF
C1657 divbuf_23/OUT2 divbuf_23/OUT3 1.37fF
C1658 divider_2/tspc_1/Z2 divider_2/tspc_1/Z4 0.36fF
C1659 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/D 0.05fF
C1660 divbuf_15/OUT divbuf_15/OUT3 0.26fF
C1661 divbuf_2/OUT3 divbuf_2/OUT4 5.16fF
C1662 divbuf_7/OUT ro_complete_0/cbank_1/v 0.05fF
C1663 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z4 0.36fF
C1664 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 pll_full_1/divider_0/clk 0.12fF
C1665 ro_complete_1/a3 ro_complete_1/cbank_2/v 0.05fF
C1666 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_0/B 0.06fF
C1667 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/ro_complete_0/cbank_2/v 0.04fF
C1668 divbuf_10/OUT2 divbuf_10/OUT5 0.02fF
C1669 divbuf_10/OUT3 divbuf_10/OUT4 5.16fF
C1670 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C1671 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z3 0.16fF
C1672 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1673 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C1674 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C1675 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Q 0.04fF
C1676 divbuf_22/a_492_n240# divbuf_22/OUT2 0.42fF
C1677 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/a4 0.12fF
C1678 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_1/Z4 0.02fF
C1679 pd_1/tspc_r_0/z5 pd_1/tspc_r_1/z5 0.02fF
C1680 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Qbar1 0.38fF
C1681 divbuf_9/OUT5 divbuf_9/OUT 43.38fF
C1682 divider_2/tspc_1/Z4 divider_2/nor_0/A 0.02fF
C1683 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z2 0.01fF
C1684 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/Out 0.21fF
C1685 divbuf_0/OUT3 divbuf_0/OUT5 0.01fF
C1686 pll_full_0/pd_0/UP pll_full_0/pd_0/tspc_r_1/z5 0.03fF
C1687 divbuf_3/OUT divbuf_3/OUT4 1.11fF
C1688 ro_complete_1/a4 ro_complete_1/cbank_1/switch_1/vin 0.09fF
C1689 ro_complete_0/cbank_2/switch_0/vin ro_complete_0/cbank_2/v 1.45fF
C1690 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT2 0.06fF
C1691 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT3 0.01fF
C1692 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1693 pll_full_1/divider_0/tspc_2/Z2 pll_full_1/divider_0/tspc_2/Z4 0.36fF
C1694 divbuf_4/OUT3 divbuf_4/OUT5 0.01fF
C1695 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/z5 0.04fF
C1696 divider_1/nor_1/Z1 divider_1/nor_0/B 0.18fF
C1697 divider_2/mc2 divider_2/and_0/OUT 0.05fF
C1698 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z4 0.00fF
C1699 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/D 0.03fF
C1700 divbuf_8/IN divbuf_8/OUT5 0.00fF
C1701 pll_full_1/divbuf_1/OUT3 pll_full_1/divbuf_1/OUT 0.26fF
C1702 pll_full_1/divbuf_1/OUT4 pll_full_1/divbuf_1/OUT5 20.26fF
C1703 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Z1 0.02fF
C1704 divbuf_24/a_492_n240# divbuf_24/IN 0.13fF
C1705 pll_full_1/ro_complete_0/cbank_2/switch_0/vin pll_full_1/ro_complete_0/cbank_2/v 1.45fF
C1706 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z4 0.12fF
C1707 divider_2/tspc_2/Z1 divider_2/tspc_2/Z2 1.07fF
C1708 divider_2/nor_0/A divider_2/tspc_2/Z3 0.38fF
C1709 divbuf_4/OUT ro_complete_0/cbank_1/switch_0/vin 0.12fF
C1710 divider_0/mc2 divider_0/and_0/OUT 0.05fF
C1711 divider_0/tspc_0/Z1 divider_0/nor_1/B 0.03fF
C1712 divbuf_5/OUT ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1713 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/v 1.30fF
C1714 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/nor_0/A 0.15fF
C1715 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1716 pll_full_1/pd_0/REF pll_full_1/divbuf_1/a_492_n240# 0.13fF
C1717 pll_full_1/ro_complete_0/cbank_2/v pll_full_1/divider_0/clk 1.36fF
C1718 ro_complete_1/a3 ro_complete_1/cbank_1/switch_2/vin 0.09fF
C1719 pll_full_1/cp_0/upbar pll_full_1/cp_0/down 0.02fF
C1720 divbuf_5/OUT3 divbuf_5/OUT5 0.01fF
C1721 divider_1/tspc_0/a_630_n680# divider_1/tspc_0/Z4 0.12fF
C1722 divider_1/tspc_1/Q divider_1/tspc_0/Z3 0.45fF
C1723 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z4 0.28fF
C1724 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/Z2 1.07fF
C1725 divider_1/and_0/OUT divider_1/and_0/B 0.01fF
C1726 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/clk 0.12fF
C1727 pd_0/UP pd_0/tspc_r_1/z5 0.03fF
C1728 divider_2/tspc_1/Q divider_2/tspc_1/Z3 0.05fF
C1729 divider_2/tspc_1/Z1 divider_2/tspc_1/Z4 0.00fF
C1730 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z3 0.06fF
C1731 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1732 pll_full_1/ro_complete_0/cbank_0/switch_2/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1733 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_1/Q 0.01fF
C1734 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C1735 divbuf_15/OUT divbuf_15/a_492_n240# 0.00fF
C1736 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/D 0.09fF
C1737 ro_complete_1/a2 ro_complete_1/cbank_2/switch_3/vin 0.09fF
C1738 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/cbank_0/v 1.30fF
C1739 divbuf_3/OUT ro_complete_0/cbank_1/v 0.05fF
C1740 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/a_492_n240# 0.00fF
C1741 divbuf_1/OUT4 divbuf_1/OUT3 5.16fF
C1742 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/switch_5/vin 0.20fF
C1743 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/DOWN 0.03fF
C1744 io_clamp_low[2] io_analog[6] 0.53fF
C1745 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z1 0.08fF
C1746 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Q 0.91fF
C1747 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1748 divbuf_11/OUT2 divbuf_11/OUT5 0.02fF
C1749 divbuf_11/OUT3 divbuf_11/OUT4 5.16fF
C1750 divbuf_19/OUT2 divbuf_19/OUT3 1.37fF
C1751 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z4 0.36fF
C1752 pd_1/DOWN pd_1/tspc_r_1/Qbar 0.02fF
C1753 pd_1/R pd_1/UP 0.45fF
C1754 divbuf_18/OUT4 divbuf_18/OUT 1.11fF
C1755 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/Q 0.04fF
C1756 divider_2/prescaler_0/tspc_1/Z3 divider_2/clk 0.45fF
C1757 divbuf_9/a_492_n240# divbuf_9/OUT2 0.42fF
C1758 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/OUT2 0.02fF
C1759 divbuf_0/OUT divbuf_0/OUT4 1.11fF
C1760 divider_0/tspc_0/Z1 divider_0/tspc_0/Z2 1.07fF
C1761 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divbuf_0/IN 0.05fF
C1762 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C1763 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/and_0/A 0.80fF
C1764 pll_full_1/ro_complete_0/cbank_1/switch_2/vin pll_full_1/divider_0/clk 1.46fF
C1765 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Qbar1 0.38fF
C1766 divbuf_14/IN divbuf_14/OUT5 0.00fF
C1767 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/Z1 0.04fF
C1768 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/clk 0.05fF
C1769 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT5 0.01fF
C1770 pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_0/ro_complete_0/cbank_2/v 1.45fF
C1771 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/tspc_r_1/Z3 0.38fF
C1772 pll_full_1/pd_0/DIV pll_full_1/pd_0/R 0.51fF
C1773 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/nor_0/A 0.15fF
C1774 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1775 pll_full_0/ro_complete_0/cbank_2/v pll_full_0/divider_0/clk 1.36fF
C1776 pd_0/tspc_r_0/Z3 pd_0/R 0.27fF
C1777 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/Qbar 0.01fF
C1778 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/a3 0.13fF
C1779 cp_0/a_1710_0# cp_0/out 0.84fF
C1780 pd_1/tspc_r_1/Z2 pd_1/tspc_r_1/Z4 0.14fF
C1781 divbuf_13/IN divbuf_13/OUT5 0.00fF
C1782 divbuf_5/OUT divbuf_6/OUT 3.23fF
C1783 divider_0/prescaler_0/Out divider_0/prescaler_0/m1_2700_2190# 0.11fF
C1784 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/nand_0/z1 0.07fF
C1785 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.05fF
C1786 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C1787 divider_1/mc2 divider_1/nor_1/B 0.15fF
C1788 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C1789 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/v 1.30fF
C1790 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1791 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1792 divbuf_5/a_492_n240# divbuf_5/OUT2 0.42fF
C1793 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_1/Q 0.01fF
C1794 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C1795 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C1796 divbuf_21/OUT2 divbuf_21/OUT 0.06fF
C1797 divbuf_21/OUT3 divbuf_21/OUT5 0.01fF
C1798 divider_1/prescaler_0/tspc_0/D divider_1/prescaler_0/nand_1/z1 0.21fF
C1799 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Qbar1 0.38fF
C1800 divider_2/prescaler_0/m1_2700_2190# divider_2/and_0/OUT 0.14fF
C1801 pll_full_1/ro_complete_0/cbank_2/switch_5/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C1802 divbuf_2/OUT divbuf_2/OUT3 0.26fF
C1803 divider_0/nor_0/B divider_0/nor_1/B 0.47fF
C1804 divider_0/tspc_0/Z3 divider_0/tspc_0/Z4 0.65fF
C1805 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.05fF
C1806 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/clk 0.01fF
C1807 divbuf_14/OUT5 divbuf_14/OUT4 20.26fF
C1808 divider_0/tspc_2/Z3 divider_0/tspc_2/Z4 0.65fF
C1809 divbuf_6/OUT divbuf_6/OUT3 0.26fF
C1810 ro_complete_1/a5 ro_complete_1/cbank_1/v 0.10fF
C1811 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/cbank_0/v 1.30fF
C1812 divider_1/tspc_1/Q divider_1/tspc_0/Z4 0.15fF
C1813 divbuf_6/a_492_n240# divbuf_6/OUT5 0.01fF
C1814 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/DOWN 0.03fF
C1815 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divbuf_0/IN 0.05fF
C1816 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C1817 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/A 0.80fF
C1818 pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_0/divider_0/clk 1.46fF
C1819 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/Z1 0.04fF
C1820 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/clk 0.05fF
C1821 divbuf_19/IN divbuf_19/a_492_n240# 0.13fF
C1822 divider_1/tspc_2/Z1 divider_1/tspc_2/Z4 0.00fF
C1823 divbuf_23/OUT2 divbuf_23/OUT5 0.02fF
C1824 divbuf_23/OUT3 divbuf_23/OUT4 5.16fF
C1825 pd_1/DOWN pd_1/tspc_r_0/Qbar1 0.11fF
C1826 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Z1 0.02fF
C1827 divider_2/prescaler_0/tspc_2/Z4 divider_2/prescaler_0/tspc_2/D 0.11fF
C1828 pll_full_1/pd_0/UP pll_full_1/pd_0/tspc_r_1/Qbar 0.21fF
C1829 divbuf_2/OUT4 divbuf_2/OUT5 20.26fF
C1830 divbuf_14/OUT2 divbuf_14/OUT5 0.02fF
C1831 divider_0/nor_0/B divider_0/tspc_2/a_630_n680# 0.01fF
C1832 divider_1/nor_0/Z1 divider_1/nor_0/B 0.06fF
C1833 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/tspc_r_1/Z3 0.25fF
C1834 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z4 0.36fF
C1835 divbuf_10/OUT3 divbuf_10/OUT 0.26fF
C1836 divbuf_10/OUT4 divbuf_10/OUT5 20.26fF
C1837 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/DIV 0.19fF
C1838 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C1839 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C1840 pd_1/DOWN pd_1/and_pd_0/Z1 0.07fF
C1841 pd_1/REF pd_1/tspc_r_1/Z1 0.17fF
C1842 pd_1/tspc_r_1/Qbar1 pd_1/UP 0.11fF
C1843 divider_2/prescaler_0/tspc_2/Z3 divider_2/clk 0.45fF
C1844 divbuf_0/OUT4 divbuf_0/OUT5 20.26fF
C1845 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1846 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/tspc_r_1/Z4 0.14fF
C1847 divider_0/tspc_0/Z2 divider_0/nor_0/B 0.20fF
C1848 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/Out 0.04fF
C1849 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/and_0/OUT 0.06fF
C1850 divbuf_4/OUT divbuf_4/OUT2 0.06fF
C1851 ro_complete_1/a2 ro_complete_1/cbank_1/v 0.05fF
C1852 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT4 1.11fF
C1853 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z2 0.01fF
C1854 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/Out 0.21fF
C1855 pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1856 divider_2/nor_1/Z1 divider_2/nor_1/B 0.06fF
C1857 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C1858 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/clk 0.01fF
C1859 divbuf_8/OUT2 divbuf_8/OUT 0.06fF
C1860 divbuf_8/OUT3 divbuf_8/OUT5 0.01fF
C1861 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1862 divbuf_18/OUT3 divbuf_18/OUT4 5.16fF
C1863 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Z4 0.65fF
C1864 divider_2/tspc_2/Z2 divider_2/tspc_2/Z3 0.16fF
C1865 divider_2/nor_0/A divider_2/tspc_2/Z4 0.21fF
C1866 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_5/vin 0.20fF
C1867 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1868 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/Z2 0.11fF
C1869 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C1870 ro_complete_1/a3 ro_complete_1/cbank_2/switch_1/vin 0.13fF
C1871 divider_1/tspc_0/Z1 divider_1/nor_1/B 0.03fF
C1872 divbuf_7/a_492_n240# divbuf_7/OUT5 0.01fF
C1873 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z3 0.25fF
C1874 pd_0/tspc_r_1/Z2 pd_0/tspc_r_1/Z4 0.14fF
C1875 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C1876 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z4 0.00fF
C1877 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Q 0.21fF
C1878 divbuf_19/OUT3 divbuf_19/OUT4 5.16fF
C1879 divider_2/and_0/B divider_2/and_0/Z1 0.07fF
C1880 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_0/Z3 0.06fF
C1881 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C1882 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1883 ro_complete_1/a2 ro_complete_1/cbank_0/switch_2/vin 0.14fF
C1884 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/a4 0.09fF
C1885 divbuf_0/OUT5 divbuf_0/IN 0.00fF
C1886 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_0/vin 0.19fF
C1887 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/v 1.30fF
C1888 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.19fF
C1889 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/clk 0.01fF
C1890 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/v 1.30fF
C1891 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z3 0.11fF
C1892 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/D 0.09fF
C1893 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C1894 divbuf_11/OUT3 divbuf_11/OUT 0.26fF
C1895 divbuf_11/OUT4 divbuf_11/OUT5 20.26fF
C1896 cp_0/a_1710_n2840# cp_0/a_1710_0# 0.83fF
C1897 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C1898 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C1899 divider_2/prescaler_0/tspc_1/Z4 divider_2/clk 0.12fF
C1900 divbuf_0/OUT divbuf_0/OUT5 43.38fF
C1901 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C1902 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z1 0.17fF
C1903 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/UP 0.11fF
C1904 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_2/Q 0.22fF
C1905 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/nor_1/B 0.35fF
C1906 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C1907 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C1908 divbuf_1/OUT5 divbuf_1/IN 0.00fF
C1909 pll_full_0/divbuf_0/OUT4 pll_full_0/divbuf_0/OUT5 20.26fF
C1910 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1911 divider_0/tspc_2/Q divider_0/tspc_2/a_630_n680# 0.04fF
C1912 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/D 0.03fF
C1913 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/nor_0/A 0.35fF
C1914 pll_full_1/divider_0/prescaler_0/tspc_0/D pll_full_1/divider_0/clk 0.29fF
C1915 divbuf_4/a_492_n240# divbuf_4/IN 0.13fF
C1916 ro_complete_1/cbank_2/switch_2/vin ro_complete_1/cbank_2/v 1.30fF
C1917 divider_1/tspc_0/Z1 divider_1/tspc_0/Z2 1.07fF
C1918 pll_full_1/divbuf_1/a_492_n240# pll_full_1/divbuf_1/OUT2 0.42fF
C1919 divbuf_16/OUT2 divbuf_16/OUT 0.06fF
C1920 divbuf_20/a_492_n240# divbuf_20/OUT 0.00fF
C1921 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_0/Qbar 0.21fF
C1922 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z2 0.11fF
C1923 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C1924 pd_1/DIV pd_1/tspc_r_0/Z2 0.19fF
C1925 pd_0/DOWN pd_0/R 0.36fF
C1926 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z4 0.20fF
C1927 pd_0/DIV pd_0/tspc_r_0/z5 0.04fF
C1928 pd_0/tspc_r_0/Z1 pd_0/tspc_r_0/Z2 0.71fF
C1929 divider_2/prescaler_0/tspc_0/Z2 divider_2/and_0/OUT 0.06fF
C1930 divbuf_13/OUT2 divbuf_13/OUT 0.06fF
C1931 divbuf_13/OUT3 divbuf_13/OUT5 0.01fF
C1932 cp_0/a_1710_0# cp_0/down 0.32fF
C1933 divider_2/prescaler_0/tspc_1/Q divider_2/clk 0.60fF
C1934 divider_0/nor_0/B divider_0/tspc_1/Z1 0.03fF
C1935 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_4/vin 0.20fF
C1936 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/nor_1/B 0.00fF
C1937 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/and_0/OUT 0.06fF
C1938 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1939 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.38fF
C1940 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.11fF
C1941 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C1942 divider_0/prescaler_0/tspc_1/Q divider_0/nor_0/A 0.03fF
C1943 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/A 0.01fF
C1944 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z3 0.06fF
C1945 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C1946 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1947 divider_1/prescaler_0/Out divider_1/prescaler_0/m1_2700_2190# 0.11fF
C1948 divider_2/prescaler_0/Out divider_2/clk 0.51fF
C1949 divbuf_21/OUT4 divbuf_21/OUT 1.11fF
C1950 pll_full_1/pd_0/DOWN pll_full_1/cp_0/a_1710_0# 0.04fF
C1951 pll_full_1/pd_0/DIV pll_full_1/pd_0/tspc_r_0/Z4 0.02fF
C1952 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C1953 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/clk 0.01fF
C1954 pd_0/tspc_r_0/Z4 pd_0/tspc_r_1/Z4 0.02fF
C1955 pd_0/DOWN pd_0/and_pd_0/Out1 0.12fF
C1956 pd_0/REF pd_0/tspc_r_1/Z1 0.17fF
C1957 pd_0/tspc_r_1/Qbar1 pd_0/UP 0.11fF
C1958 divider_2/nor_1/B divider_2/tspc_0/Z1 0.03fF
C1959 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_2/D 0.16fF
C1960 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/clk 0.01fF
C1961 divbuf_12/a_492_n240# divbuf_12/OUT5 0.01fF
C1962 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/IN 5.26fF
C1963 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/a_492_n240# 0.01fF
C1964 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C1965 divider_0/nor_0/B divider_0/tspc_1/Z2 0.30fF
C1966 divbuf_2/OUT divbuf_2/OUT5 43.38fF
C1967 divbuf_4/OUT ro_complete_0/cbank_1/v 0.05fF
C1968 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C1969 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/and_0/A 0.26fF
C1970 divbuf_6/OUT divbuf_6/OUT5 43.38fF
C1971 divbuf_3/IN divbuf_3/OUT5 0.00fF
C1972 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C1973 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1974 divider_1/mc2 divider_1/nor_0/A 0.04fF
C1975 divbuf_14/OUT5 divbuf_14/OUT3 0.01fF
C1976 divbuf_6/OUT2 divbuf_6/OUT3 1.37fF
C1977 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Q 0.22fF
C1978 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/nor_1/B 0.35fF
C1979 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C1980 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C1981 divider_1/nor_0/B divider_1/nor_1/B 0.47fF
C1982 divider_1/tspc_0/Z3 divider_1/tspc_0/Z4 0.65fF
C1983 divider_1/nor_0/Z1 divider_1/and_0/A 0.80fF
C1984 divbuf_16/OUT divbuf_16/OUT5 43.38fF
C1985 divider_1/tspc_2/Z3 divider_1/tspc_2/Z4 0.65fF
C1986 filter_0/v divbuf_25/OUT5 43.38fF
C1987 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/nor_0/A 0.35fF
C1988 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/clk 0.29fF
C1989 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/z5 0.04fF
C1990 divbuf_18/OUT5 divbuf_18/OUT4 20.26fF
C1991 divbuf_23/OUT3 divbuf_23/OUT 0.26fF
C1992 divbuf_23/OUT4 divbuf_23/OUT5 20.26fF
C1993 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_0/Z4 0.00fF
C1994 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/divider_0/clk 1.46fF
C1995 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z3 0.29fF
C1996 divbuf_25/OUT4 divbuf_25/OUT5 20.26fF
C1997 divider_0/prescaler_0/Out divider_0/tspc_2/Z3 0.45fF
C1998 divider_0/nor_0/B divider_0/nor_0/A 1.21fF
C1999 divbuf_0/a_492_n240# divbuf_0/IN 0.13fF
C2000 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/and_0/B 0.29fF
C2001 ro_complete_1/a1 ro_complete_1/cbank_2/v 0.05fF
C2002 divider_2/tspc_0/Z4 divider_2/nor_1/B 0.22fF
C2003 divbuf_10/OUT5 divbuf_10/OUT 43.38fF
C2004 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_1/B 0.00fF
C2005 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C2006 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C2007 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C2008 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C2009 divbuf_16/OUT3 divbuf_16/OUT 0.26fF
C2010 divider_1/nor_0/B divider_1/tspc_2/a_630_n680# 0.01fF
C2011 divbuf_22/a_492_n240# divbuf_22/OUT 0.00fF
C2012 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/a4 0.09fF
C2013 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/a5 0.09fF
C2014 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/A 0.01fF
C2015 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z2 0.25fF
C2016 divider_2/prescaler_0/tspc_2/Z4 divider_2/clk 0.12fF
C2017 pll_full_1/divbuf_0/a_492_n240# pll_full_1/divbuf_0/OUT2 0.42fF
C2018 divider_0/tspc_0/Z1 divider_0/tspc_1/Q 0.01fF
C2019 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z3 0.06fF
C2020 divbuf_0/OUT divbuf_0/a_492_n240# 0.00fF
C2021 divbuf_0/OUT3 divbuf_0/OUT2 1.37fF
C2022 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z2 1.07fF
C2023 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Z3 0.38fF
C2024 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/nor_1/B 0.22fF
C2025 divbuf_4/OUT divbuf_4/OUT4 1.11fF
C2026 pll_full_1/pd_0/tspc_r_0/Z1 pll_full_1/pd_0/tspc_r_0/Z2 0.71fF
C2027 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT2 0.42fF
C2028 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C2029 divider_1/tspc_0/Z2 divider_1/nor_0/B 0.20fF
C2030 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/Out 0.04fF
C2031 divbuf_21/a_492_n240# divbuf_21/IN 0.13fF
C2032 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C2033 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/A 0.26fF
C2034 pd_0/R pd_0/tspc_r_1/Z3 0.29fF
C2035 divbuf_8/OUT4 divbuf_8/OUT 1.11fF
C2036 pll_full_1/divbuf_0/OUT4 pll_full_1/divbuf_0/OUT3 5.16fF
C2037 divider_2/tspc_2/Z2 divider_2/tspc_2/Z4 0.36fF
C2038 divbuf_24/a_492_n240# divbuf_24/OUT5 0.01fF
Xpd_0 vdda1 vssa1 pd_0/REF pd_0/DIV pd_0/UP pd_0/DOWN pd_0/R pd
Xpd_1 vdda1 vssa1 pd_1/REF pd_1/DIV pd_1/UP pd_1/DOWN pd_1/R pd
Xcp_0 cp_0/vbias vdda1 gnd cp_0/out cp_0/down cp_0/upbar cp
Xfilter_0 vssa1 filter_0/v filter
Xro_complete_0 divbuf_7/OUT divbuf_6/OUT divbuf_2/OUT divbuf_4/OUT divbuf_3/OUT divbuf_5/OUT
+ ro_complete
Xdivbuf_0 vdda1 divbuf_0/IN divbuf_0/OUT divbuf_0/OUT2 divbuf_0/OUT3 divbuf_0/OUT4
+ divbuf_0/OUT5 gnd divbuf
Xro_complete_1 ro_complete_1/a0 ro_complete_1/a1 ro_complete_1/a5 ro_complete_1/a4
+ ro_complete_1/a3 ro_complete_1/a2 ro_complete
Xdivbuf_1 vdda1 divbuf_1/IN divbuf_1/OUT divbuf_1/OUT2 divbuf_1/OUT3 divbuf_1/OUT4
+ divbuf_1/OUT5 gnd divbuf
Xdivbuf_2 vdda1 divbuf_2/IN divbuf_2/OUT divbuf_2/OUT2 divbuf_2/OUT3 divbuf_2/OUT4
+ divbuf_2/OUT5 gnd divbuf
Xdivbuf_3 vdda1 divbuf_3/IN divbuf_3/OUT divbuf_3/OUT2 divbuf_3/OUT3 divbuf_3/OUT4
+ divbuf_3/OUT5 gnd divbuf
Xdivbuf_4 vdda1 divbuf_4/IN divbuf_4/OUT divbuf_4/OUT2 divbuf_4/OUT3 divbuf_4/OUT4
+ divbuf_4/OUT5 gnd divbuf
Xdivbuf_5 vdda1 divbuf_5/IN divbuf_5/OUT divbuf_5/OUT2 divbuf_5/OUT3 divbuf_5/OUT4
+ divbuf_5/OUT5 gnd divbuf
Xdivbuf_6 vdda1 divbuf_6/IN divbuf_6/OUT divbuf_6/OUT2 divbuf_6/OUT3 divbuf_6/OUT4
+ divbuf_6/OUT5 gnd divbuf
Xdivbuf_10 vdda1 divbuf_10/IN divbuf_10/OUT divbuf_10/OUT2 divbuf_10/OUT3 divbuf_10/OUT4
+ divbuf_10/OUT5 gnd divbuf
Xdivbuf_20 vdda1 divbuf_20/IN divbuf_20/OUT divbuf_20/OUT2 divbuf_20/OUT3 divbuf_20/OUT4
+ divbuf_20/OUT5 vssa1 divbuf
Xdivbuf_21 vdda1 divbuf_21/IN divbuf_21/OUT divbuf_21/OUT2 divbuf_21/OUT3 divbuf_21/OUT4
+ divbuf_21/OUT5 vssa1 divbuf
Xdivbuf_7 vdda1 divbuf_7/IN divbuf_7/OUT divbuf_7/OUT2 divbuf_7/OUT3 divbuf_7/OUT4
+ divbuf_7/OUT5 gnd divbuf
Xdivbuf_11 vdda1 divbuf_11/IN divbuf_11/OUT divbuf_11/OUT2 divbuf_11/OUT3 divbuf_11/OUT4
+ divbuf_11/OUT5 gnd divbuf
Xdivbuf_22 vdda1 divbuf_22/IN divbuf_22/OUT divbuf_22/OUT2 divbuf_22/OUT3 divbuf_22/OUT4
+ divbuf_22/OUT5 vssa1 divbuf
Xdivbuf_8 vdda1 divbuf_8/IN divbuf_8/OUT divbuf_8/OUT2 divbuf_8/OUT3 divbuf_8/OUT4
+ divbuf_8/OUT5 gnd divbuf
Xdivbuf_12 vdda1 divbuf_12/IN divbuf_12/OUT divbuf_12/OUT2 divbuf_12/OUT3 divbuf_12/OUT4
+ divbuf_12/OUT5 gnd divbuf
Xdivbuf_23 vdda1 divbuf_23/IN divbuf_23/OUT divbuf_23/OUT2 divbuf_23/OUT3 divbuf_23/OUT4
+ divbuf_23/OUT5 vssa1 divbuf
Xdivbuf_9 vdda1 divbuf_9/IN divbuf_9/OUT divbuf_9/OUT2 divbuf_9/OUT3 divbuf_9/OUT4
+ divbuf_9/OUT5 gnd divbuf
Xdivbuf_13 vdda1 divbuf_13/IN divbuf_13/OUT divbuf_13/OUT2 divbuf_13/OUT3 divbuf_13/OUT4
+ divbuf_13/OUT5 gnd divbuf
Xdivbuf_24 vdda1 divbuf_24/IN divbuf_24/OUT divbuf_24/OUT2 divbuf_24/OUT3 divbuf_24/OUT4
+ divbuf_24/OUT5 vssa1 divbuf
Xdivider_0 gnd vdd divider_0/Out divider_0/clk divider_0/mc2 divider
Xdivbuf_14 vdda1 divbuf_14/IN divbuf_14/OUT divbuf_14/OUT2 divbuf_14/OUT3 divbuf_14/OUT4
+ divbuf_14/OUT5 gnd divbuf
Xdivbuf_25 vdda1 divbuf_25/IN filter_0/v divbuf_25/OUT2 divbuf_25/OUT3 divbuf_25/OUT4
+ divbuf_25/OUT5 vssa1 divbuf
Xdivbuf_15 vdda1 divbuf_15/IN divbuf_15/OUT divbuf_15/OUT2 divbuf_15/OUT3 divbuf_15/OUT4
+ divbuf_15/OUT5 gnd divbuf
Xdivider_1 vssa1 vdda1 divider_1/Out divider_1/clk divider_1/mc2 divider
Xdivbuf_16 vdda1 divbuf_16/IN divbuf_16/OUT divbuf_16/OUT2 divbuf_16/OUT3 divbuf_16/OUT4
+ divbuf_16/OUT5 vssa1 divbuf
Xdivider_2 vssa1 vdda1 divider_2/Out divider_2/clk divider_2/mc2 divider
Xdivbuf_17 vdda1 divbuf_17/IN divbuf_17/OUT divbuf_17/OUT2 divbuf_17/OUT3 divbuf_17/OUT4
+ divbuf_17/OUT5 vssa1 divbuf
Xdivbuf_18 vdda1 divbuf_18/IN divbuf_18/OUT divbuf_18/OUT2 divbuf_18/OUT3 divbuf_18/OUT4
+ divbuf_18/OUT5 vssa1 divbuf
Xdivbuf_19 vdda1 divbuf_19/IN divbuf_19/OUT divbuf_19/OUT2 divbuf_19/OUT3 divbuf_19/OUT4
+ divbuf_19/OUT5 vssa1 divbuf
Xpll_full_0 vdda1 pll_full
Xpll_full_1 vdda1 pll_full
C2039 io_analog[4] vssa1 43.96fF
C2040 io_analog[5] vssa1 44.13fF
C2041 io_analog[6] vssa1 43.46fF
C2042 io_in_3v3[0] vssa1 0.61fF
C2043 io_oeb[26] vssa1 0.61fF
C2044 io_in[0] vssa1 0.61fF
C2045 io_out[26] vssa1 0.61fF
C2046 io_out[0] vssa1 0.61fF
C2047 io_in[26] vssa1 0.61fF
C2048 io_oeb[0] vssa1 0.61fF
C2049 io_in_3v3[26] vssa1 0.61fF
C2050 io_in_3v3[1] vssa1 0.61fF
C2051 io_oeb[25] vssa1 0.61fF
C2052 io_in[1] vssa1 0.61fF
C2053 io_out[25] vssa1 0.61fF
C2054 io_out[1] vssa1 0.61fF
C2055 io_in[25] vssa1 0.61fF
C2056 io_oeb[1] vssa1 0.61fF
C2057 io_in_3v3[25] vssa1 0.61fF
C2058 io_in_3v3[2] vssa1 0.61fF
C2059 io_oeb[24] vssa1 0.61fF
C2060 io_in[2] vssa1 0.61fF
C2061 io_out[24] vssa1 0.61fF
C2062 io_out[2] vssa1 0.61fF
C2063 io_in[24] vssa1 0.61fF
C2064 io_oeb[2] vssa1 0.61fF
C2065 io_in_3v3[24] vssa1 0.61fF
C2066 io_in_3v3[3] vssa1 0.61fF
C2067 io_in[3] vssa1 0.61fF
C2068 gpio_noesd[17] vssa1 2.32fF
C2069 gpio_analog[17] vssa1 2.30fF
C2070 io_out[3] vssa1 0.61fF
C2071 io_oeb[3] vssa1 0.61fF
C2072 io_in_3v3[4] vssa1 0.61fF
C2073 io_in[4] vssa1 0.61fF
C2074 io_out[4] vssa1 0.61fF
C2075 io_oeb[4] vssa1 0.61fF
C2076 io_oeb[23] vssa1 0.61fF
C2077 io_out[23] vssa1 0.61fF
C2078 io_in[23] vssa1 0.61fF
C2079 io_in_3v3[23] vssa1 0.61fF
C2080 gpio_noesd[16] vssa1 2.30fF
C2081 gpio_analog[16] vssa1 2.30fF
C2082 io_in_3v3[5] vssa1 0.61fF
C2083 io_in[5] vssa1 0.61fF
C2084 io_out[5] vssa1 0.61fF
C2085 io_oeb[5] vssa1 0.61fF
C2086 io_oeb[22] vssa1 0.61fF
C2087 io_out[22] vssa1 0.61fF
C2088 io_in[22] vssa1 0.61fF
C2089 io_in_3v3[22] vssa1 0.61fF
C2090 gpio_noesd[15] vssa1 2.31fF
C2091 gpio_analog[15] vssa1 2.30fF
C2092 io_in_3v3[6] vssa1 0.61fF
C2093 io_in[6] vssa1 0.61fF
C2094 io_out[6] vssa1 0.61fF
C2095 io_oeb[6] vssa1 0.61fF
C2096 io_oeb[21] vssa1 0.61fF
C2097 io_out[21] vssa1 0.61fF
C2098 io_in[21] vssa1 0.61fF
C2099 io_in_3v3[21] vssa1 0.61fF
C2100 gpio_noesd[14] vssa1 2.30fF
C2101 gpio_analog[14] vssa1 2.29fF
C2102 vssd2 vssa1 38.54fF
C2103 vssd1 vssa1 13.04fF
C2104 vdda2 vssa1 38.30fF
C2105 io_oeb[20] vssa1 0.61fF
C2106 io_out[20] vssa1 0.61fF
C2107 io_in[20] vssa1 0.61fF
C2108 io_in_3v3[20] vssa1 0.61fF
C2109 gpio_noesd[13] vssa1 2.31fF
C2110 gpio_analog[13] vssa1 2.30fF
C2111 gpio_analog[0] vssa1 0.61fF
C2112 gpio_noesd[0] vssa1 0.61fF
C2113 io_in_3v3[7] vssa1 0.61fF
C2114 io_in[7] vssa1 0.61fF
C2115 io_out[7] vssa1 0.61fF
C2116 io_oeb[7] vssa1 0.61fF
C2117 io_oeb[19] vssa1 0.61fF
C2118 io_out[19] vssa1 0.61fF
C2119 io_in[19] vssa1 0.61fF
C2120 io_in_3v3[19] vssa1 0.61fF
C2121 gpio_noesd[12] vssa1 2.32fF
C2122 gpio_analog[12] vssa1 2.30fF
C2123 gpio_analog[1] vssa1 0.61fF
C2124 gpio_noesd[1] vssa1 0.61fF
C2125 io_in_3v3[8] vssa1 0.61fF
C2126 io_in[8] vssa1 0.61fF
C2127 io_out[8] vssa1 0.61fF
C2128 io_oeb[8] vssa1 0.61fF
C2129 io_oeb[18] vssa1 0.61fF
C2130 io_out[18] vssa1 0.61fF
C2131 io_in[18] vssa1 0.61fF
C2132 io_in_3v3[18] vssa1 0.61fF
C2133 gpio_noesd[11] vssa1 2.30fF
C2134 gpio_analog[11] vssa1 2.29fF
C2135 gpio_analog[2] vssa1 0.61fF
C2136 gpio_noesd[2] vssa1 0.61fF
C2137 io_in_3v3[9] vssa1 0.61fF
C2138 io_in[9] vssa1 0.61fF
C2139 io_out[9] vssa1 0.61fF
C2140 io_oeb[9] vssa1 0.61fF
C2141 io_oeb[17] vssa1 0.61fF
C2142 io_out[17] vssa1 0.61fF
C2143 io_in[17] vssa1 0.61fF
C2144 io_in_3v3[17] vssa1 0.61fF
C2145 gpio_noesd[10] vssa1 2.31fF
C2146 gpio_analog[10] vssa1 2.29fF
C2147 gpio_analog[3] vssa1 0.61fF
C2148 gpio_noesd[3] vssa1 0.61fF
C2149 io_in_3v3[10] vssa1 0.61fF
C2150 io_in[10] vssa1 0.61fF
C2151 io_out[10] vssa1 0.61fF
C2152 io_oeb[10] vssa1 0.61fF
C2153 io_oeb[16] vssa1 0.61fF
C2154 io_out[16] vssa1 0.61fF
C2155 io_in[16] vssa1 0.61fF
C2156 io_in_3v3[16] vssa1 0.61fF
C2157 gpio_noesd[9] vssa1 2.28fF
C2158 gpio_analog[9] vssa1 2.28fF
C2159 gpio_analog[4] vssa1 0.61fF
C2160 gpio_noesd[4] vssa1 0.61fF
C2161 io_in_3v3[11] vssa1 0.61fF
C2162 io_in[11] vssa1 0.61fF
C2163 io_out[11] vssa1 0.61fF
C2164 io_oeb[11] vssa1 0.61fF
C2165 io_oeb[15] vssa1 0.61fF
C2166 io_out[15] vssa1 0.61fF
C2167 io_in[15] vssa1 0.61fF
C2168 io_in_3v3[15] vssa1 0.61fF
C2169 gpio_noesd[8] vssa1 2.28fF
C2170 gpio_analog[8] vssa1 2.26fF
C2171 gpio_analog[5] vssa1 0.61fF
C2172 gpio_noesd[5] vssa1 0.61fF
C2173 io_in_3v3[12] vssa1 0.61fF
C2174 io_in[12] vssa1 0.61fF
C2175 io_out[12] vssa1 0.61fF
C2176 io_oeb[12] vssa1 0.61fF
C2177 io_oeb[14] vssa1 0.61fF
C2178 io_out[14] vssa1 0.61fF
C2179 io_in[14] vssa1 0.61fF
C2180 io_in_3v3[14] vssa1 0.61fF
C2181 gpio_noesd[7] vssa1 2.30fF
C2182 gpio_analog[7] vssa1 2.28fF
C2183 vssa2 vssa1 38.35fF
C2184 gpio_analog[6] vssa1 5.71fF
C2185 gpio_noesd[6] vssa1 5.70fF
C2186 io_in_3v3[13] vssa1 0.61fF
C2187 io_in[13] vssa1 0.61fF
C2188 io_out[13] vssa1 0.61fF
C2189 io_oeb[13] vssa1 0.61fF
C2190 vccd1 vssa1 39.84fF
C2191 vccd2 vssa1 38.46fF
C2192 io_analog[0] vssa1 19.99fF
C2193 io_analog[10] vssa1 19.36fF
C2194 io_analog[1] vssa1 13.17fF
C2195 io_analog[2] vssa1 12.57fF
C2196 io_analog[3] vssa1 12.83fF
C2197 io_clamp_high[0] vssa1 3.58fF
C2198 io_clamp_low[0] vssa1 3.58fF
C2199 io_clamp_high[1] vssa1 3.58fF
C2200 io_clamp_low[1] vssa1 3.58fF
C2201 io_clamp_high[2] vssa1 3.58fF
C2202 io_clamp_low[2] vssa1 3.58fF
C2203 io_analog[7] vssa1 12.74fF
C2204 io_analog[8] vssa1 13.08fF
C2205 io_analog[9] vssa1 13.08fF
C2206 user_irq[2] vssa1 0.63fF
C2207 user_irq[1] vssa1 0.63fF
C2208 user_irq[0] vssa1 0.63fF
C2209 user_clock2 vssa1 0.63fF
C2210 la_oenb[127] vssa1 0.63fF
C2211 la_data_out[127] vssa1 0.63fF
C2212 la_data_in[127] vssa1 0.63fF
C2213 la_oenb[126] vssa1 0.63fF
C2214 la_data_out[126] vssa1 0.63fF
C2215 la_data_in[126] vssa1 0.63fF
C2216 la_oenb[125] vssa1 0.63fF
C2217 la_data_out[125] vssa1 0.63fF
C2218 la_data_in[125] vssa1 0.63fF
C2219 la_oenb[124] vssa1 0.63fF
C2220 la_data_out[124] vssa1 0.63fF
C2221 la_data_in[124] vssa1 0.63fF
C2222 la_oenb[123] vssa1 0.63fF
C2223 la_data_out[123] vssa1 0.63fF
C2224 la_data_in[123] vssa1 0.63fF
C2225 la_oenb[122] vssa1 0.63fF
C2226 la_data_out[122] vssa1 0.63fF
C2227 la_data_in[122] vssa1 0.63fF
C2228 la_oenb[121] vssa1 0.63fF
C2229 la_data_out[121] vssa1 0.63fF
C2230 la_data_in[121] vssa1 0.63fF
C2231 la_oenb[120] vssa1 0.63fF
C2232 la_data_out[120] vssa1 0.63fF
C2233 la_data_in[120] vssa1 0.63fF
C2234 la_oenb[119] vssa1 0.63fF
C2235 la_data_out[119] vssa1 0.63fF
C2236 la_data_in[119] vssa1 0.63fF
C2237 la_oenb[118] vssa1 0.63fF
C2238 la_data_out[118] vssa1 0.63fF
C2239 la_data_in[118] vssa1 0.63fF
C2240 la_oenb[117] vssa1 0.63fF
C2241 la_data_out[117] vssa1 0.63fF
C2242 la_data_in[117] vssa1 0.63fF
C2243 la_oenb[116] vssa1 0.63fF
C2244 la_data_out[116] vssa1 0.63fF
C2245 la_data_in[116] vssa1 0.63fF
C2246 la_oenb[115] vssa1 0.63fF
C2247 la_data_out[115] vssa1 0.63fF
C2248 la_data_in[115] vssa1 0.63fF
C2249 la_oenb[114] vssa1 0.63fF
C2250 la_data_out[114] vssa1 0.63fF
C2251 la_data_in[114] vssa1 0.63fF
C2252 la_oenb[113] vssa1 0.63fF
C2253 la_data_out[113] vssa1 0.63fF
C2254 la_data_in[113] vssa1 0.63fF
C2255 la_oenb[112] vssa1 0.63fF
C2256 la_data_out[112] vssa1 0.63fF
C2257 la_data_in[112] vssa1 0.63fF
C2258 la_oenb[111] vssa1 0.63fF
C2259 la_data_out[111] vssa1 0.63fF
C2260 la_data_in[111] vssa1 0.63fF
C2261 la_oenb[110] vssa1 0.63fF
C2262 la_data_out[110] vssa1 0.63fF
C2263 la_data_in[110] vssa1 0.63fF
C2264 la_oenb[109] vssa1 0.63fF
C2265 la_data_out[109] vssa1 0.63fF
C2266 la_data_in[109] vssa1 0.63fF
C2267 la_oenb[108] vssa1 0.63fF
C2268 la_data_out[108] vssa1 0.63fF
C2269 la_data_in[108] vssa1 0.63fF
C2270 la_oenb[107] vssa1 0.63fF
C2271 la_data_out[107] vssa1 0.63fF
C2272 la_data_in[107] vssa1 0.63fF
C2273 la_oenb[106] vssa1 0.63fF
C2274 la_data_out[106] vssa1 0.63fF
C2275 la_data_in[106] vssa1 0.63fF
C2276 la_oenb[105] vssa1 0.63fF
C2277 la_data_out[105] vssa1 0.63fF
C2278 la_data_in[105] vssa1 0.63fF
C2279 la_oenb[104] vssa1 0.63fF
C2280 la_data_out[104] vssa1 0.63fF
C2281 la_data_in[104] vssa1 0.63fF
C2282 la_oenb[103] vssa1 0.63fF
C2283 la_data_out[103] vssa1 0.63fF
C2284 la_data_in[103] vssa1 0.63fF
C2285 la_oenb[102] vssa1 0.63fF
C2286 la_data_out[102] vssa1 0.63fF
C2287 la_data_in[102] vssa1 0.63fF
C2288 la_oenb[101] vssa1 0.63fF
C2289 la_data_out[101] vssa1 0.63fF
C2290 la_data_in[101] vssa1 0.63fF
C2291 la_oenb[100] vssa1 0.63fF
C2292 la_data_out[100] vssa1 0.63fF
C2293 la_data_in[100] vssa1 0.63fF
C2294 la_oenb[99] vssa1 0.63fF
C2295 la_data_out[99] vssa1 0.63fF
C2296 la_data_in[99] vssa1 0.63fF
C2297 la_oenb[98] vssa1 0.63fF
C2298 la_data_out[98] vssa1 0.63fF
C2299 la_data_in[98] vssa1 0.63fF
C2300 la_oenb[97] vssa1 0.63fF
C2301 la_data_out[97] vssa1 0.63fF
C2302 la_data_in[97] vssa1 0.63fF
C2303 la_oenb[96] vssa1 0.63fF
C2304 la_data_out[96] vssa1 0.63fF
C2305 la_data_in[96] vssa1 0.63fF
C2306 la_oenb[95] vssa1 0.63fF
C2307 la_data_out[95] vssa1 0.63fF
C2308 la_data_in[95] vssa1 0.63fF
C2309 la_oenb[94] vssa1 0.63fF
C2310 la_data_out[94] vssa1 0.63fF
C2311 la_data_in[94] vssa1 0.63fF
C2312 la_oenb[93] vssa1 0.63fF
C2313 la_data_out[93] vssa1 0.63fF
C2314 la_data_in[93] vssa1 0.63fF
C2315 la_oenb[92] vssa1 0.63fF
C2316 la_data_out[92] vssa1 0.63fF
C2317 la_data_in[92] vssa1 0.63fF
C2318 la_oenb[91] vssa1 0.63fF
C2319 la_data_out[91] vssa1 0.63fF
C2320 la_data_in[91] vssa1 0.63fF
C2321 la_oenb[90] vssa1 0.63fF
C2322 la_data_out[90] vssa1 0.63fF
C2323 la_data_in[90] vssa1 0.63fF
C2324 la_oenb[89] vssa1 0.63fF
C2325 la_data_out[89] vssa1 0.63fF
C2326 la_data_in[89] vssa1 0.63fF
C2327 la_oenb[88] vssa1 0.63fF
C2328 la_data_out[88] vssa1 0.63fF
C2329 la_data_in[88] vssa1 0.63fF
C2330 la_oenb[87] vssa1 0.63fF
C2331 la_data_out[87] vssa1 0.63fF
C2332 la_data_in[87] vssa1 0.63fF
C2333 la_oenb[86] vssa1 0.63fF
C2334 la_data_out[86] vssa1 0.63fF
C2335 la_data_in[86] vssa1 0.63fF
C2336 la_oenb[85] vssa1 0.63fF
C2337 la_data_out[85] vssa1 0.63fF
C2338 la_data_in[85] vssa1 0.63fF
C2339 la_oenb[84] vssa1 0.63fF
C2340 la_data_out[84] vssa1 0.63fF
C2341 la_data_in[84] vssa1 0.63fF
C2342 la_oenb[83] vssa1 0.63fF
C2343 la_data_out[83] vssa1 0.63fF
C2344 la_data_in[83] vssa1 0.63fF
C2345 la_oenb[82] vssa1 0.63fF
C2346 la_data_out[82] vssa1 0.63fF
C2347 la_data_in[82] vssa1 0.63fF
C2348 la_oenb[81] vssa1 0.63fF
C2349 la_data_out[81] vssa1 0.63fF
C2350 la_data_in[81] vssa1 0.63fF
C2351 la_oenb[80] vssa1 0.63fF
C2352 la_data_out[80] vssa1 0.63fF
C2353 la_data_in[80] vssa1 0.63fF
C2354 la_oenb[79] vssa1 0.63fF
C2355 la_data_out[79] vssa1 0.63fF
C2356 la_data_in[79] vssa1 0.63fF
C2357 la_oenb[78] vssa1 0.63fF
C2358 la_data_out[78] vssa1 0.63fF
C2359 la_data_in[78] vssa1 0.63fF
C2360 la_oenb[77] vssa1 0.63fF
C2361 la_data_out[77] vssa1 0.63fF
C2362 la_data_in[77] vssa1 0.63fF
C2363 la_oenb[76] vssa1 0.63fF
C2364 la_data_out[76] vssa1 0.63fF
C2365 la_data_in[76] vssa1 0.63fF
C2366 la_oenb[75] vssa1 0.63fF
C2367 la_data_out[75] vssa1 0.63fF
C2368 la_data_in[75] vssa1 0.63fF
C2369 la_oenb[74] vssa1 0.63fF
C2370 la_data_out[74] vssa1 0.63fF
C2371 la_data_in[74] vssa1 0.63fF
C2372 la_oenb[73] vssa1 0.63fF
C2373 la_data_out[73] vssa1 0.63fF
C2374 la_data_in[73] vssa1 0.63fF
C2375 la_oenb[72] vssa1 0.63fF
C2376 la_data_out[72] vssa1 0.63fF
C2377 la_data_in[72] vssa1 0.63fF
C2378 la_oenb[71] vssa1 0.63fF
C2379 la_data_out[71] vssa1 0.63fF
C2380 la_data_in[71] vssa1 0.63fF
C2381 la_oenb[70] vssa1 0.63fF
C2382 la_data_out[70] vssa1 0.63fF
C2383 la_data_in[70] vssa1 0.63fF
C2384 la_oenb[69] vssa1 0.63fF
C2385 la_data_out[69] vssa1 0.63fF
C2386 la_data_in[69] vssa1 0.63fF
C2387 la_oenb[68] vssa1 0.63fF
C2388 la_data_out[68] vssa1 0.63fF
C2389 la_data_in[68] vssa1 0.63fF
C2390 la_oenb[67] vssa1 0.63fF
C2391 la_data_out[67] vssa1 0.63fF
C2392 la_data_in[67] vssa1 0.63fF
C2393 la_oenb[66] vssa1 0.63fF
C2394 la_data_out[66] vssa1 0.63fF
C2395 la_data_in[66] vssa1 0.63fF
C2396 la_oenb[65] vssa1 0.63fF
C2397 la_data_out[65] vssa1 0.63fF
C2398 la_data_in[65] vssa1 0.63fF
C2399 la_oenb[64] vssa1 0.63fF
C2400 la_data_out[64] vssa1 0.63fF
C2401 la_data_in[64] vssa1 0.63fF
C2402 la_oenb[63] vssa1 0.63fF
C2403 la_data_out[63] vssa1 0.63fF
C2404 la_data_in[63] vssa1 0.63fF
C2405 la_oenb[62] vssa1 0.63fF
C2406 la_data_out[62] vssa1 0.63fF
C2407 la_data_in[62] vssa1 0.63fF
C2408 la_oenb[61] vssa1 0.63fF
C2409 la_data_out[61] vssa1 0.63fF
C2410 la_data_in[61] vssa1 0.63fF
C2411 la_oenb[60] vssa1 0.63fF
C2412 la_data_out[60] vssa1 0.63fF
C2413 la_data_in[60] vssa1 0.63fF
C2414 la_oenb[59] vssa1 0.63fF
C2415 la_data_out[59] vssa1 0.63fF
C2416 la_data_in[59] vssa1 0.63fF
C2417 la_oenb[58] vssa1 0.63fF
C2418 la_data_out[58] vssa1 0.63fF
C2419 la_data_in[58] vssa1 0.63fF
C2420 la_oenb[57] vssa1 0.63fF
C2421 la_data_out[57] vssa1 0.63fF
C2422 la_data_in[57] vssa1 0.63fF
C2423 la_oenb[56] vssa1 0.63fF
C2424 la_data_out[56] vssa1 0.63fF
C2425 la_data_in[56] vssa1 0.63fF
C2426 la_oenb[55] vssa1 0.63fF
C2427 la_data_out[55] vssa1 0.63fF
C2428 la_data_in[55] vssa1 0.63fF
C2429 la_oenb[54] vssa1 0.63fF
C2430 la_data_out[54] vssa1 0.63fF
C2431 la_data_in[54] vssa1 0.63fF
C2432 la_oenb[53] vssa1 0.63fF
C2433 la_data_out[53] vssa1 0.63fF
C2434 la_data_in[53] vssa1 0.63fF
C2435 la_oenb[52] vssa1 0.63fF
C2436 la_data_out[52] vssa1 0.63fF
C2437 la_data_in[52] vssa1 0.63fF
C2438 la_oenb[51] vssa1 0.63fF
C2439 la_data_out[51] vssa1 0.63fF
C2440 la_data_in[51] vssa1 0.63fF
C2441 la_oenb[50] vssa1 0.63fF
C2442 la_data_out[50] vssa1 0.63fF
C2443 la_data_in[50] vssa1 0.63fF
C2444 la_oenb[49] vssa1 0.63fF
C2445 la_data_out[49] vssa1 0.63fF
C2446 la_data_in[49] vssa1 0.63fF
C2447 la_oenb[48] vssa1 0.63fF
C2448 la_data_out[48] vssa1 0.63fF
C2449 la_data_in[48] vssa1 0.63fF
C2450 la_oenb[47] vssa1 0.63fF
C2451 la_data_out[47] vssa1 0.63fF
C2452 la_data_in[47] vssa1 0.63fF
C2453 la_oenb[46] vssa1 0.63fF
C2454 la_data_out[46] vssa1 0.63fF
C2455 la_data_in[46] vssa1 0.63fF
C2456 la_oenb[45] vssa1 0.63fF
C2457 la_data_out[45] vssa1 0.63fF
C2458 la_data_in[45] vssa1 0.63fF
C2459 la_oenb[44] vssa1 0.63fF
C2460 la_data_out[44] vssa1 0.63fF
C2461 la_data_in[44] vssa1 0.63fF
C2462 la_oenb[43] vssa1 0.63fF
C2463 la_data_out[43] vssa1 0.63fF
C2464 la_data_in[43] vssa1 0.63fF
C2465 la_oenb[42] vssa1 0.63fF
C2466 la_data_out[42] vssa1 0.63fF
C2467 la_data_in[42] vssa1 0.63fF
C2468 la_oenb[41] vssa1 0.63fF
C2469 la_data_out[41] vssa1 0.63fF
C2470 la_data_in[41] vssa1 0.63fF
C2471 la_oenb[40] vssa1 0.63fF
C2472 la_data_out[40] vssa1 0.63fF
C2473 la_data_in[40] vssa1 0.63fF
C2474 la_oenb[39] vssa1 0.63fF
C2475 la_data_out[39] vssa1 0.63fF
C2476 la_data_in[39] vssa1 0.63fF
C2477 la_oenb[38] vssa1 0.63fF
C2478 la_data_out[38] vssa1 0.63fF
C2479 la_data_in[38] vssa1 0.63fF
C2480 la_oenb[37] vssa1 0.63fF
C2481 la_data_out[37] vssa1 0.63fF
C2482 la_data_in[37] vssa1 0.63fF
C2483 la_oenb[36] vssa1 0.63fF
C2484 la_data_out[36] vssa1 0.63fF
C2485 la_data_in[36] vssa1 0.63fF
C2486 la_oenb[35] vssa1 0.63fF
C2487 la_data_out[35] vssa1 0.63fF
C2488 la_data_in[35] vssa1 0.63fF
C2489 la_oenb[34] vssa1 0.63fF
C2490 la_data_out[34] vssa1 0.63fF
C2491 la_data_in[34] vssa1 0.63fF
C2492 la_oenb[33] vssa1 0.63fF
C2493 la_data_out[33] vssa1 0.63fF
C2494 la_data_in[33] vssa1 0.63fF
C2495 la_oenb[32] vssa1 0.63fF
C2496 la_data_out[32] vssa1 0.63fF
C2497 la_data_in[32] vssa1 0.63fF
C2498 la_oenb[31] vssa1 0.63fF
C2499 la_data_out[31] vssa1 0.63fF
C2500 la_data_in[31] vssa1 0.63fF
C2501 la_oenb[30] vssa1 0.63fF
C2502 la_data_out[30] vssa1 0.63fF
C2503 la_data_in[30] vssa1 0.63fF
C2504 la_oenb[29] vssa1 0.63fF
C2505 la_data_out[29] vssa1 0.63fF
C2506 la_data_in[29] vssa1 0.63fF
C2507 la_oenb[28] vssa1 0.63fF
C2508 la_data_out[28] vssa1 0.63fF
C2509 la_data_in[28] vssa1 0.63fF
C2510 la_oenb[27] vssa1 0.63fF
C2511 la_data_out[27] vssa1 0.63fF
C2512 la_data_in[27] vssa1 0.63fF
C2513 la_oenb[26] vssa1 0.63fF
C2514 la_data_out[26] vssa1 0.63fF
C2515 la_data_in[26] vssa1 0.63fF
C2516 la_oenb[25] vssa1 0.63fF
C2517 la_data_out[25] vssa1 0.63fF
C2518 la_data_in[25] vssa1 0.63fF
C2519 la_oenb[24] vssa1 0.63fF
C2520 la_data_out[24] vssa1 0.63fF
C2521 la_data_in[24] vssa1 0.63fF
C2522 la_oenb[23] vssa1 0.63fF
C2523 la_data_out[23] vssa1 0.63fF
C2524 la_data_in[23] vssa1 0.63fF
C2525 la_oenb[22] vssa1 0.63fF
C2526 la_data_out[22] vssa1 0.63fF
C2527 la_data_in[22] vssa1 0.63fF
C2528 la_oenb[21] vssa1 0.63fF
C2529 la_data_out[21] vssa1 0.63fF
C2530 la_data_in[21] vssa1 0.63fF
C2531 la_oenb[20] vssa1 0.63fF
C2532 la_data_out[20] vssa1 0.63fF
C2533 la_data_in[20] vssa1 0.63fF
C2534 la_oenb[19] vssa1 0.63fF
C2535 la_data_out[19] vssa1 0.63fF
C2536 la_data_in[19] vssa1 0.63fF
C2537 la_oenb[18] vssa1 0.63fF
C2538 la_data_out[18] vssa1 0.63fF
C2539 la_data_in[18] vssa1 0.63fF
C2540 la_oenb[17] vssa1 0.63fF
C2541 la_data_out[17] vssa1 0.63fF
C2542 la_data_in[17] vssa1 0.63fF
C2543 la_oenb[16] vssa1 0.63fF
C2544 la_data_out[16] vssa1 0.63fF
C2545 la_data_in[16] vssa1 0.63fF
C2546 la_oenb[15] vssa1 0.63fF
C2547 la_data_out[15] vssa1 0.63fF
C2548 la_data_in[15] vssa1 0.63fF
C2549 la_oenb[14] vssa1 0.63fF
C2550 la_data_out[14] vssa1 0.63fF
C2551 la_data_in[14] vssa1 0.63fF
C2552 la_oenb[13] vssa1 0.63fF
C2553 la_data_out[13] vssa1 0.63fF
C2554 la_data_in[13] vssa1 0.63fF
C2555 la_oenb[12] vssa1 0.63fF
C2556 la_data_out[12] vssa1 0.63fF
C2557 la_data_in[12] vssa1 0.63fF
C2558 la_oenb[11] vssa1 0.63fF
C2559 la_data_out[11] vssa1 0.63fF
C2560 la_data_in[11] vssa1 0.63fF
C2561 la_oenb[10] vssa1 0.63fF
C2562 la_data_out[10] vssa1 0.63fF
C2563 la_data_in[10] vssa1 0.63fF
C2564 la_oenb[9] vssa1 0.63fF
C2565 la_data_out[9] vssa1 0.63fF
C2566 la_data_in[9] vssa1 0.63fF
C2567 la_oenb[8] vssa1 0.63fF
C2568 la_data_out[8] vssa1 0.63fF
C2569 la_data_in[8] vssa1 0.63fF
C2570 la_oenb[7] vssa1 0.63fF
C2571 la_data_out[7] vssa1 0.63fF
C2572 la_data_in[7] vssa1 0.63fF
C2573 la_oenb[6] vssa1 0.63fF
C2574 la_data_out[6] vssa1 0.63fF
C2575 la_data_in[6] vssa1 0.63fF
C2576 la_oenb[5] vssa1 0.63fF
C2577 la_data_out[5] vssa1 0.63fF
C2578 la_data_in[5] vssa1 0.63fF
C2579 la_oenb[4] vssa1 0.63fF
C2580 la_data_out[4] vssa1 0.63fF
C2581 la_data_in[4] vssa1 0.63fF
C2582 la_oenb[3] vssa1 0.63fF
C2583 la_data_out[3] vssa1 0.63fF
C2584 la_data_in[3] vssa1 0.63fF
C2585 la_oenb[2] vssa1 0.63fF
C2586 la_data_out[2] vssa1 0.63fF
C2587 la_data_in[2] vssa1 0.63fF
C2588 la_oenb[1] vssa1 0.63fF
C2589 la_data_out[1] vssa1 0.63fF
C2590 la_data_in[1] vssa1 0.63fF
C2591 la_oenb[0] vssa1 0.63fF
C2592 la_data_out[0] vssa1 0.63fF
C2593 la_data_in[0] vssa1 0.63fF
C2594 wbs_dat_o[31] vssa1 0.63fF
C2595 wbs_dat_i[31] vssa1 0.63fF
C2596 wbs_adr_i[31] vssa1 0.63fF
C2597 wbs_dat_o[30] vssa1 0.63fF
C2598 wbs_dat_i[30] vssa1 0.63fF
C2599 wbs_adr_i[30] vssa1 0.63fF
C2600 wbs_dat_o[29] vssa1 0.63fF
C2601 wbs_dat_i[29] vssa1 0.63fF
C2602 wbs_adr_i[29] vssa1 0.63fF
C2603 wbs_dat_o[28] vssa1 0.63fF
C2604 wbs_dat_i[28] vssa1 0.63fF
C2605 wbs_adr_i[28] vssa1 0.63fF
C2606 wbs_dat_o[27] vssa1 0.63fF
C2607 wbs_dat_i[27] vssa1 0.63fF
C2608 wbs_adr_i[27] vssa1 0.63fF
C2609 wbs_dat_o[26] vssa1 0.63fF
C2610 wbs_dat_i[26] vssa1 0.63fF
C2611 wbs_adr_i[26] vssa1 0.63fF
C2612 wbs_dat_o[25] vssa1 0.63fF
C2613 wbs_dat_i[25] vssa1 0.63fF
C2614 wbs_adr_i[25] vssa1 0.63fF
C2615 wbs_dat_o[24] vssa1 0.63fF
C2616 wbs_dat_i[24] vssa1 0.63fF
C2617 wbs_adr_i[24] vssa1 0.63fF
C2618 wbs_dat_o[23] vssa1 0.63fF
C2619 wbs_dat_i[23] vssa1 0.63fF
C2620 wbs_adr_i[23] vssa1 0.63fF
C2621 wbs_dat_o[22] vssa1 0.63fF
C2622 wbs_dat_i[22] vssa1 0.63fF
C2623 wbs_adr_i[22] vssa1 0.63fF
C2624 wbs_dat_o[21] vssa1 0.63fF
C2625 wbs_dat_i[21] vssa1 0.63fF
C2626 wbs_adr_i[21] vssa1 0.63fF
C2627 wbs_dat_o[20] vssa1 0.63fF
C2628 wbs_dat_i[20] vssa1 0.63fF
C2629 wbs_adr_i[20] vssa1 0.63fF
C2630 wbs_dat_o[19] vssa1 0.63fF
C2631 wbs_dat_i[19] vssa1 0.63fF
C2632 wbs_adr_i[19] vssa1 0.63fF
C2633 wbs_dat_o[18] vssa1 0.63fF
C2634 wbs_dat_i[18] vssa1 0.63fF
C2635 wbs_adr_i[18] vssa1 0.63fF
C2636 wbs_dat_o[17] vssa1 0.63fF
C2637 wbs_dat_i[17] vssa1 0.63fF
C2638 wbs_adr_i[17] vssa1 0.63fF
C2639 wbs_dat_o[16] vssa1 0.63fF
C2640 wbs_dat_i[16] vssa1 0.63fF
C2641 wbs_adr_i[16] vssa1 0.63fF
C2642 wbs_dat_o[15] vssa1 0.63fF
C2643 wbs_dat_i[15] vssa1 0.63fF
C2644 wbs_adr_i[15] vssa1 0.63fF
C2645 wbs_dat_o[14] vssa1 0.63fF
C2646 wbs_dat_i[14] vssa1 0.63fF
C2647 wbs_adr_i[14] vssa1 0.63fF
C2648 wbs_dat_o[13] vssa1 0.63fF
C2649 wbs_dat_i[13] vssa1 0.63fF
C2650 wbs_adr_i[13] vssa1 0.63fF
C2651 wbs_dat_o[12] vssa1 0.63fF
C2652 wbs_dat_i[12] vssa1 0.63fF
C2653 wbs_adr_i[12] vssa1 0.63fF
C2654 wbs_dat_o[11] vssa1 0.63fF
C2655 wbs_dat_i[11] vssa1 0.63fF
C2656 wbs_adr_i[11] vssa1 0.63fF
C2657 wbs_dat_o[10] vssa1 0.63fF
C2658 wbs_dat_i[10] vssa1 0.63fF
C2659 wbs_adr_i[10] vssa1 0.63fF
C2660 wbs_dat_o[9] vssa1 0.63fF
C2661 wbs_dat_i[9] vssa1 0.63fF
C2662 wbs_adr_i[9] vssa1 0.63fF
C2663 wbs_dat_o[8] vssa1 0.63fF
C2664 wbs_dat_i[8] vssa1 0.63fF
C2665 wbs_adr_i[8] vssa1 0.63fF
C2666 wbs_dat_o[7] vssa1 0.63fF
C2667 wbs_dat_i[7] vssa1 0.63fF
C2668 wbs_adr_i[7] vssa1 0.63fF
C2669 wbs_dat_o[6] vssa1 0.63fF
C2670 wbs_dat_i[6] vssa1 0.63fF
C2671 wbs_adr_i[6] vssa1 0.63fF
C2672 wbs_dat_o[5] vssa1 0.63fF
C2673 wbs_dat_i[5] vssa1 0.63fF
C2674 wbs_adr_i[5] vssa1 0.63fF
C2675 wbs_dat_o[4] vssa1 0.63fF
C2676 wbs_dat_i[4] vssa1 0.63fF
C2677 wbs_adr_i[4] vssa1 0.63fF
C2678 wbs_sel_i[3] vssa1 0.63fF
C2679 wbs_dat_o[3] vssa1 0.63fF
C2680 wbs_dat_i[3] vssa1 0.63fF
C2681 wbs_adr_i[3] vssa1 0.63fF
C2682 wbs_sel_i[2] vssa1 0.63fF
C2683 wbs_dat_o[2] vssa1 0.63fF
C2684 wbs_dat_i[2] vssa1 0.63fF
C2685 wbs_adr_i[2] vssa1 0.63fF
C2686 wbs_sel_i[1] vssa1 0.63fF
C2687 wbs_dat_o[1] vssa1 0.63fF
C2688 wbs_dat_i[1] vssa1 0.63fF
C2689 wbs_adr_i[1] vssa1 0.63fF
C2690 wbs_sel_i[0] vssa1 0.63fF
C2691 wbs_dat_o[0] vssa1 0.63fF
C2692 wbs_dat_i[0] vssa1 0.63fF
C2693 wbs_adr_i[0] vssa1 0.63fF
C2694 wbs_we_i vssa1 0.63fF
C2695 wbs_stb_i vssa1 0.63fF
C2696 wbs_cyc_i vssa1 0.63fF
C2697 wbs_ack_o vssa1 0.63fF
C2698 wb_rst_i vssa1 0.63fF
C2699 wb_clk_i vssa1 0.63fF
C2700 m2_494098_659718# vssa1 0.80fF **FLOATING
C2701 li_200624_47978# vssa1 61.68fF **FLOATING
C2702 li_534900_144658# vssa1 71.26fF **FLOATING
C2703 li_464674_144658# vssa1 72.10fF **FLOATING
C2704 li_379946_144658# vssa1 71.49fF **FLOATING
C2705 pll_full_1/divider_0/and_0/Z1 vssa1 0.65fF
C2706 pll_full_1/divider_0/and_0/B vssa1 2.45fF
C2707 pll_full_1/divider_0/and_0/A vssa1 2.35fF
C2708 pll_full_1/divider_0/and_0/out1 vssa1 2.99fF
C2709 pll_full_1/divider_0/tspc_2/Z4 vssa1 0.86fF
C2710 pll_full_1/divider_0/tspc_2/Z3 vssa1 2.26fF
C2711 pll_full_1/divider_0/tspc_2/Z2 vssa1 1.46fF
C2712 pll_full_1/divider_0/tspc_2/Z1 vssa1 0.99fF
C2713 pll_full_1/divider_0/nor_0/A vssa1 7.08fF
C2714 pll_full_1/divider_0/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C2715 pll_full_1/divider_0/tspc_1/Z4 vssa1 0.86fF
C2716 pll_full_1/divider_0/tspc_1/Z3 vssa1 2.26fF
C2717 pll_full_1/divider_0/tspc_1/Z2 vssa1 1.46fF
C2718 pll_full_1/divider_0/tspc_1/Z1 vssa1 0.99fF
C2719 pll_full_1/divider_0/nor_0/B vssa1 7.12fF
C2720 pll_full_1/divider_0/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C2721 pll_full_1/divider_0/tspc_2/Q vssa1 3.14fF
C2722 pll_full_1/divider_0/tspc_0/Z4 vssa1 0.86fF
C2723 pll_full_1/divbuf_0/IN vssa1 9.89fF
C2724 pll_full_1/divider_0/tspc_0/Z3 vssa1 2.26fF
C2725 pll_full_1/divider_0/tspc_0/Z2 vssa1 1.46fF
C2726 pll_full_1/divider_0/tspc_0/Z1 vssa1 0.99fF
C2727 pll_full_1/divider_0/nor_1/B vssa1 6.48fF
C2728 pll_full_1/divider_0/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C2729 pll_full_1/divider_0/tspc_1/Q vssa1 3.12fF
C2730 pll_full_1/divider_0/clk vssa1 33.42fF
C2731 pll_full_1/divider_0/prescaler_0/nand_1/z1 vssa1 0.36fF
C2732 pll_full_1/divider_0/prescaler_0/tspc_0/D vssa1 2.64fF
C2733 pll_full_1/divider_0/prescaler_0/tspc_2/Q vssa1 3.72fF
C2734 pll_full_1/divider_0/prescaler_0/tspc_1/Q vssa1 3.61fF
C2735 pll_full_1/divider_0/prescaler_0/nand_0/z1 vssa1 0.36fF
C2736 pll_full_1/divider_0/prescaler_0/tspc_2/D vssa1 3.12fF
C2737 pll_full_1/divider_0/and_0/OUT vssa1 5.67fF
C2738 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C2739 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C2740 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 vssa1 1.19fF
C2741 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C2742 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# vssa1 1.47fF **FLOATING
C2743 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C2744 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C2745 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C2746 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C2747 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C2748 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C2749 pll_full_1/divider_0/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C2750 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C2751 pll_full_1/divider_0/prescaler_0/Out vssa1 4.59fF
C2752 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C2753 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C2754 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C2755 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C2756 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C2757 pll_full_1/divider_0/nor_1/Z1 vssa1 1.34fF
C2758 pll_full_1/divider_0/nor_0/Z1 vssa1 1.34fF
C2759 pll_full_1/divbuf_1/OUT vssa1 363.82fF
C2760 pll_full_1/divbuf_1/OUT5 vssa1 350.37fF
C2761 pll_full_1/divbuf_1/OUT4 vssa1 133.72fF
C2762 pll_full_1/divbuf_1/OUT3 vssa1 34.03fF
C2763 pll_full_1/divbuf_1/OUT2 vssa1 8.71fF
C2764 pll_full_1/divbuf_1/a_492_n240# vssa1 2.46fF **FLOATING
C2765 pll_full_1/divbuf_0/OUT5 vssa1 350.37fF
C2766 pll_full_1/divbuf_0/OUT4 vssa1 133.72fF
C2767 pll_full_1/divbuf_0/OUT3 vssa1 34.03fF
C2768 pll_full_1/divbuf_0/OUT2 vssa1 8.71fF
C2769 pll_full_1/divbuf_0/a_492_n240# vssa1 2.46fF **FLOATING
C2770 pll_full_1/ro_complete_0/cbank_2/v vssa1 16.43fF
C2771 pll_full_1/ro_complete_0/cbank_2/switch_5/vin vssa1 0.78fF
C2772 pll_full_1/ro_complete_0/cbank_2/switch_4/vin vssa1 1.50fF
C2773 pll_full_1/ro_complete_0/cbank_2/switch_2/vin vssa1 1.30fF
C2774 pll_full_1/ro_complete_0/cbank_2/switch_3/vin vssa1 0.56fF
C2775 pll_full_1/ro_complete_0/cbank_2/switch_1/vin vssa1 1.14fF
C2776 pll_full_1/ro_complete_0/cbank_2/switch_0/vin vssa1 1.02fF
C2777 pll_full_1/ro_complete_0/cbank_1/switch_5/vin vssa1 0.78fF
C2778 pll_full_1/ro_complete_0/a0 vssa1 5.35fF
C2779 pll_full_1/ro_complete_0/cbank_1/switch_4/vin vssa1 1.50fF
C2780 pll_full_1/ro_complete_0/a1 vssa1 6.54fF
C2781 pll_full_1/ro_complete_0/cbank_1/switch_2/vin vssa1 1.30fF
C2782 pll_full_1/ro_complete_0/a3 vssa1 5.96fF
C2783 pll_full_1/ro_complete_0/cbank_1/switch_3/vin vssa1 0.56fF
C2784 pll_full_1/ro_complete_0/a2 vssa1 5.21fF
C2785 pll_full_1/ro_complete_0/cbank_1/switch_1/vin vssa1 1.14fF
C2786 pll_full_1/ro_complete_0/a4 vssa1 5.81fF
C2787 pll_full_1/ro_complete_0/cbank_1/switch_0/vin vssa1 1.02fF
C2788 pll_full_1/ro_complete_0/a5 vssa1 6.74fF
C2789 pll_full_1/ro_complete_0/cbank_0/v vssa1 15.12fF
C2790 pll_full_1/ro_complete_0/cbank_0/switch_5/vin vssa1 0.78fF
C2791 pll_full_1/ro_complete_0/cbank_0/switch_4/vin vssa1 1.50fF
C2792 pll_full_1/ro_complete_0/cbank_0/switch_2/vin vssa1 1.30fF
C2793 pll_full_1/ro_complete_0/cbank_0/switch_3/vin vssa1 0.56fF
C2794 pll_full_1/ro_complete_0/cbank_0/switch_1/vin vssa1 1.14fF
C2795 pll_full_1/ro_complete_0/cbank_0/switch_0/vin vssa1 1.02fF
C2796 pll_full_1/ro_complete_0/ro_var_extend_0/vcont vssa1 0.27fF
C2797 pll_full_1/filter_0/a_4216_n5230# vssa1 418.90fF **FLOATING
C2798 pll_full_1/filter_0/a_4216_n2998# vssa1 1.39fF **FLOATING
C2799 pll_full_1/cp_0/down vssa1 1.54fF
C2800 pll_full_1/cp_0/upbar vssa1 1.79fF
C2801 pll_full_1/cp_0/a_7110_n2840# vssa1 0.17fF **FLOATING
C2802 pll_full_1/cp_0/a_3060_n2840# vssa1 1.71fF **FLOATING
C2803 pll_full_1/cp_0/a_7110_0# vssa1 0.17fF **FLOATING
C2804 pll_full_1/cp_0/a_6370_0# vssa1 0.40fF **FLOATING
C2805 pll_full_1/cp_0/a_3060_0# vssa1 2.49fF **FLOATING
C2806 pll_full_1/cp_0/a_1710_0# vssa1 7.47fF **FLOATING
C2807 pll_full_1/pd_0/and_pd_0/Z1 vssa1 0.39fF
C2808 pll_full_1/pd_0/and_pd_0/Out1 vssa1 2.22fF
C2809 pll_full_1/pd_0/tspc_r_1/z5 vssa1 1.10fF
C2810 pll_full_1/pd_0/tspc_r_1/Z4 vssa1 1.07fF
C2811 pll_full_1/pd_0/tspc_r_1/Qbar vssa1 0.88fF
C2812 pll_full_1/pd_0/tspc_r_1/Z2 vssa1 1.22fF
C2813 pll_full_1/pd_0/tspc_r_1/Z1 vssa1 0.67fF
C2814 pll_full_1/pd_0/UP vssa1 6.41fF
C2815 pll_full_1/pd_0/tspc_r_1/Qbar1 vssa1 1.34fF
C2816 pll_full_1/pd_0/tspc_r_1/Z3 vssa1 2.12fF
C2817 pll_full_1/pd_0/REF vssa1 6.48fF
C2818 pll_full_1/pd_0/tspc_r_0/z5 vssa1 1.10fF
C2819 pll_full_1/pd_0/tspc_r_0/Z4 vssa1 1.07fF
C2820 pll_full_1/pd_0/R vssa1 3.05fF
C2821 pll_full_1/pd_0/tspc_r_0/Qbar vssa1 0.79fF
C2822 pll_full_1/pd_0/tspc_r_0/Z2 vssa1 1.22fF
C2823 pll_full_1/pd_0/tspc_r_0/Z1 vssa1 0.67fF
C2824 pll_full_1/pd_0/DOWN vssa1 7.34fF
C2825 pll_full_1/pd_0/tspc_r_0/Qbar1 vssa1 1.34fF
C2826 pll_full_1/pd_0/tspc_r_0/Z3 vssa1 2.12fF
C2827 pll_full_1/pd_0/DIV vssa1 372.69fF
C2828 pll_full_0/divider_0/and_0/Z1 vssa1 0.65fF
C2829 pll_full_0/divider_0/and_0/B vssa1 2.45fF
C2830 pll_full_0/divider_0/and_0/A vssa1 2.35fF
C2831 pll_full_0/divider_0/and_0/out1 vssa1 2.99fF
C2832 pll_full_0/divider_0/tspc_2/Z4 vssa1 0.86fF
C2833 pll_full_0/divider_0/tspc_2/Z3 vssa1 2.26fF
C2834 pll_full_0/divider_0/tspc_2/Z2 vssa1 1.46fF
C2835 pll_full_0/divider_0/tspc_2/Z1 vssa1 0.99fF
C2836 pll_full_0/divider_0/nor_0/A vssa1 7.08fF
C2837 pll_full_0/divider_0/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C2838 pll_full_0/divider_0/tspc_1/Z4 vssa1 0.86fF
C2839 pll_full_0/divider_0/tspc_1/Z3 vssa1 2.26fF
C2840 pll_full_0/divider_0/tspc_1/Z2 vssa1 1.46fF
C2841 pll_full_0/divider_0/tspc_1/Z1 vssa1 0.99fF
C2842 pll_full_0/divider_0/nor_0/B vssa1 7.12fF
C2843 pll_full_0/divider_0/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C2844 pll_full_0/divider_0/tspc_2/Q vssa1 3.14fF
C2845 pll_full_0/divider_0/tspc_0/Z4 vssa1 0.86fF
C2846 pll_full_0/divbuf_0/IN vssa1 9.89fF
C2847 pll_full_0/divider_0/tspc_0/Z3 vssa1 2.26fF
C2848 pll_full_0/divider_0/tspc_0/Z2 vssa1 1.46fF
C2849 pll_full_0/divider_0/tspc_0/Z1 vssa1 0.99fF
C2850 pll_full_0/divider_0/nor_1/B vssa1 6.48fF
C2851 pll_full_0/divider_0/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C2852 pll_full_0/divider_0/tspc_1/Q vssa1 3.12fF
C2853 pll_full_0/divider_0/clk vssa1 33.42fF
C2854 pll_full_0/divider_0/prescaler_0/nand_1/z1 vssa1 0.36fF
C2855 pll_full_0/divider_0/prescaler_0/tspc_0/D vssa1 2.64fF
C2856 pll_full_0/divider_0/prescaler_0/tspc_2/Q vssa1 3.72fF
C2857 pll_full_0/divider_0/prescaler_0/tspc_1/Q vssa1 3.61fF
C2858 pll_full_0/divider_0/prescaler_0/nand_0/z1 vssa1 0.36fF
C2859 pll_full_0/divider_0/prescaler_0/tspc_2/D vssa1 3.12fF
C2860 pll_full_0/divider_0/and_0/OUT vssa1 5.67fF
C2861 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C2862 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C2863 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 vssa1 1.19fF
C2864 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C2865 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# vssa1 1.47fF **FLOATING
C2866 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C2867 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C2868 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C2869 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C2870 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C2871 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C2872 pll_full_0/divider_0/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C2873 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C2874 pll_full_0/divider_0/prescaler_0/Out vssa1 4.59fF
C2875 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C2876 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C2877 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C2878 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C2879 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C2880 pll_full_0/divider_0/nor_1/Z1 vssa1 1.34fF
C2881 pll_full_0/divider_0/nor_0/Z1 vssa1 1.34fF
C2882 pll_full_0/divbuf_1/OUT vssa1 363.82fF
C2883 pll_full_0/divbuf_1/OUT5 vssa1 350.37fF
C2884 pll_full_0/divbuf_1/OUT4 vssa1 133.72fF
C2885 pll_full_0/divbuf_1/OUT3 vssa1 34.03fF
C2886 pll_full_0/divbuf_1/OUT2 vssa1 8.71fF
C2887 pll_full_0/divbuf_1/a_492_n240# vssa1 2.46fF **FLOATING
C2888 pll_full_0/divbuf_0/OUT5 vssa1 350.37fF
C2889 pll_full_0/divbuf_0/OUT4 vssa1 133.72fF
C2890 pll_full_0/divbuf_0/OUT3 vssa1 34.03fF
C2891 pll_full_0/divbuf_0/OUT2 vssa1 8.71fF
C2892 pll_full_0/divbuf_0/a_492_n240# vssa1 2.46fF **FLOATING
C2893 pll_full_0/ro_complete_0/cbank_2/v vssa1 16.43fF
C2894 pll_full_0/ro_complete_0/cbank_2/switch_5/vin vssa1 0.78fF
C2895 pll_full_0/ro_complete_0/cbank_2/switch_4/vin vssa1 1.50fF
C2896 pll_full_0/ro_complete_0/cbank_2/switch_2/vin vssa1 1.30fF
C2897 pll_full_0/ro_complete_0/cbank_2/switch_3/vin vssa1 0.56fF
C2898 pll_full_0/ro_complete_0/cbank_2/switch_1/vin vssa1 1.14fF
C2899 pll_full_0/ro_complete_0/cbank_2/switch_0/vin vssa1 1.02fF
C2900 pll_full_0/ro_complete_0/cbank_1/switch_5/vin vssa1 0.78fF
C2901 pll_full_0/ro_complete_0/a0 vssa1 5.35fF
C2902 pll_full_0/ro_complete_0/cbank_1/switch_4/vin vssa1 1.50fF
C2903 pll_full_0/ro_complete_0/a1 vssa1 6.54fF
C2904 pll_full_0/ro_complete_0/cbank_1/switch_2/vin vssa1 1.30fF
C2905 pll_full_0/ro_complete_0/a3 vssa1 5.96fF
C2906 pll_full_0/ro_complete_0/cbank_1/switch_3/vin vssa1 0.56fF
C2907 pll_full_0/ro_complete_0/a2 vssa1 5.21fF
C2908 pll_full_0/ro_complete_0/cbank_1/switch_1/vin vssa1 1.14fF
C2909 pll_full_0/ro_complete_0/a4 vssa1 5.81fF
C2910 pll_full_0/ro_complete_0/cbank_1/switch_0/vin vssa1 1.02fF
C2911 pll_full_0/ro_complete_0/a5 vssa1 6.74fF
C2912 pll_full_0/ro_complete_0/cbank_0/v vssa1 15.12fF
C2913 pll_full_0/ro_complete_0/cbank_0/switch_5/vin vssa1 0.78fF
C2914 pll_full_0/ro_complete_0/cbank_0/switch_4/vin vssa1 1.50fF
C2915 pll_full_0/ro_complete_0/cbank_0/switch_2/vin vssa1 1.30fF
C2916 pll_full_0/ro_complete_0/cbank_0/switch_3/vin vssa1 0.56fF
C2917 pll_full_0/ro_complete_0/cbank_0/switch_1/vin vssa1 1.14fF
C2918 pll_full_0/ro_complete_0/cbank_0/switch_0/vin vssa1 1.02fF
C2919 pll_full_0/ro_complete_0/ro_var_extend_0/vcont vssa1 0.27fF
C2920 pll_full_0/filter_0/a_4216_n5230# vssa1 418.90fF **FLOATING
C2921 pll_full_0/filter_0/a_4216_n2998# vssa1 1.39fF **FLOATING
C2922 pll_full_0/cp_0/down vssa1 1.54fF
C2923 pll_full_0/cp_0/upbar vssa1 1.79fF
C2924 pll_full_0/cp_0/a_7110_n2840# vssa1 0.17fF **FLOATING
C2925 pll_full_0/cp_0/a_3060_n2840# vssa1 1.71fF **FLOATING
C2926 pll_full_0/cp_0/a_7110_0# vssa1 0.17fF **FLOATING
C2927 pll_full_0/cp_0/a_6370_0# vssa1 0.40fF **FLOATING
C2928 pll_full_0/cp_0/a_3060_0# vssa1 2.49fF **FLOATING
C2929 pll_full_0/cp_0/a_1710_0# vssa1 7.47fF **FLOATING
C2930 pll_full_0/pd_0/and_pd_0/Z1 vssa1 0.39fF
C2931 pll_full_0/pd_0/and_pd_0/Out1 vssa1 2.22fF
C2932 pll_full_0/pd_0/tspc_r_1/z5 vssa1 1.10fF
C2933 pll_full_0/pd_0/tspc_r_1/Z4 vssa1 1.07fF
C2934 pll_full_0/pd_0/tspc_r_1/Qbar vssa1 0.88fF
C2935 pll_full_0/pd_0/tspc_r_1/Z2 vssa1 1.22fF
C2936 pll_full_0/pd_0/tspc_r_1/Z1 vssa1 0.67fF
C2937 pll_full_0/pd_0/UP vssa1 6.41fF
C2938 pll_full_0/pd_0/tspc_r_1/Qbar1 vssa1 1.34fF
C2939 pll_full_0/pd_0/tspc_r_1/Z3 vssa1 2.12fF
C2940 pll_full_0/pd_0/REF vssa1 6.48fF
C2941 pll_full_0/pd_0/tspc_r_0/z5 vssa1 1.10fF
C2942 pll_full_0/pd_0/tspc_r_0/Z4 vssa1 1.07fF
C2943 pll_full_0/pd_0/R vssa1 3.05fF
C2944 pll_full_0/pd_0/tspc_r_0/Qbar vssa1 0.79fF
C2945 pll_full_0/pd_0/tspc_r_0/Z2 vssa1 1.22fF
C2946 pll_full_0/pd_0/tspc_r_0/Z1 vssa1 0.67fF
C2947 pll_full_0/pd_0/DOWN vssa1 7.34fF
C2948 pll_full_0/pd_0/tspc_r_0/Qbar1 vssa1 1.34fF
C2949 pll_full_0/pd_0/tspc_r_0/Z3 vssa1 2.12fF
C2950 pll_full_0/pd_0/DIV vssa1 372.69fF
C2951 divbuf_19/OUT vssa1 363.82fF
C2952 divbuf_19/OUT5 vssa1 350.37fF
C2953 divbuf_19/OUT4 vssa1 133.72fF
C2954 divbuf_19/OUT3 vssa1 34.03fF
C2955 divbuf_19/OUT2 vssa1 8.71fF
C2956 divbuf_19/IN vssa1 0.89fF
C2957 divbuf_19/a_492_n240# vssa1 2.46fF **FLOATING
C2958 divbuf_18/OUT vssa1 363.82fF
C2959 divbuf_18/OUT5 vssa1 350.37fF
C2960 divbuf_18/OUT4 vssa1 133.72fF
C2961 divbuf_18/OUT3 vssa1 34.03fF
C2962 divbuf_18/OUT2 vssa1 8.71fF
C2963 divbuf_18/IN vssa1 0.89fF
C2964 divbuf_18/a_492_n240# vssa1 2.46fF **FLOATING
C2965 divbuf_17/OUT vssa1 363.82fF
C2966 divbuf_17/OUT5 vssa1 350.37fF
C2967 divbuf_17/OUT4 vssa1 133.72fF
C2968 divbuf_17/OUT3 vssa1 34.03fF
C2969 divbuf_17/OUT2 vssa1 8.71fF
C2970 divbuf_17/IN vssa1 0.89fF
C2971 divbuf_17/a_492_n240# vssa1 2.46fF **FLOATING
C2972 divider_2/and_0/Z1 vssa1 0.74fF
C2973 divider_2/and_0/B vssa1 2.25fF
C2974 divider_2/and_0/A vssa1 2.19fF
C2975 divider_2/and_0/out1 vssa1 2.93fF
C2976 divider_2/tspc_2/Z4 vssa1 0.86fF
C2977 divider_2/tspc_2/Z3 vssa1 2.26fF
C2978 divider_2/tspc_2/Z2 vssa1 1.46fF
C2979 divider_2/tspc_2/Z1 vssa1 0.99fF
C2980 divider_2/nor_0/A vssa1 7.04fF
C2981 divider_2/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C2982 divider_2/tspc_1/Z4 vssa1 0.86fF
C2983 divider_2/tspc_1/Z3 vssa1 2.26fF
C2984 divider_2/tspc_1/Z2 vssa1 1.46fF
C2985 divider_2/tspc_1/Z1 vssa1 0.99fF
C2986 divider_2/nor_0/B vssa1 7.05fF
C2987 divider_2/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C2988 divider_2/tspc_2/Q vssa1 3.14fF
C2989 divider_2/tspc_0/Z4 vssa1 0.86fF
C2990 divider_2/Out vssa1 1.60fF
C2991 divider_2/tspc_0/Z3 vssa1 2.26fF
C2992 divider_2/tspc_0/Z2 vssa1 1.46fF
C2993 divider_2/tspc_0/Z1 vssa1 0.99fF
C2994 divider_2/nor_1/B vssa1 6.44fF
C2995 divider_2/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C2996 divider_2/tspc_1/Q vssa1 3.12fF
C2997 divider_2/clk vssa1 5.63fF
C2998 divider_2/prescaler_0/nand_1/z1 vssa1 0.36fF
C2999 divider_2/prescaler_0/tspc_0/D vssa1 2.64fF
C3000 divider_2/prescaler_0/tspc_2/Q vssa1 3.74fF
C3001 divider_2/prescaler_0/tspc_1/Q vssa1 3.61fF
C3002 divider_2/prescaler_0/nand_0/z1 vssa1 0.36fF
C3003 divider_2/prescaler_0/tspc_2/D vssa1 3.12fF
C3004 divider_2/and_0/OUT vssa1 5.62fF
C3005 divider_2/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C3006 divider_2/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C3007 divider_2/prescaler_0/tspc_2/Z2 vssa1 1.46fF
C3008 divider_2/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C3009 divider_2/prescaler_0/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C3010 divider_2/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C3011 divider_2/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C3012 divider_2/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C3013 divider_2/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C3014 divider_2/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C3015 divider_2/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C3016 divider_2/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C3017 divider_2/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C3018 divider_2/prescaler_0/Out vssa1 4.59fF
C3019 divider_2/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C3020 divider_2/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C3021 divider_2/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C3022 divider_2/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C3023 divider_2/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C3024 divider_2/nor_1/Z1 vssa1 1.34fF
C3025 divider_2/mc2 vssa1 5.29fF
C3026 divider_2/nor_0/Z1 vssa1 1.34fF
C3027 divbuf_16/OUT vssa1 363.82fF
C3028 divbuf_16/OUT5 vssa1 350.37fF
C3029 divbuf_16/OUT4 vssa1 133.72fF
C3030 divbuf_16/OUT3 vssa1 34.03fF
C3031 divbuf_16/OUT2 vssa1 8.71fF
C3032 divbuf_16/IN vssa1 0.89fF
C3033 divbuf_16/a_492_n240# vssa1 2.46fF **FLOATING
C3034 divider_1/and_0/Z1 vssa1 0.74fF
C3035 divider_1/and_0/B vssa1 2.25fF
C3036 divider_1/and_0/A vssa1 2.19fF
C3037 divider_1/and_0/out1 vssa1 2.93fF
C3038 divider_1/tspc_2/Z4 vssa1 0.86fF
C3039 divider_1/tspc_2/Z3 vssa1 2.26fF
C3040 divider_1/tspc_2/Z2 vssa1 1.46fF
C3041 divider_1/tspc_2/Z1 vssa1 0.99fF
C3042 divider_1/nor_0/A vssa1 7.04fF
C3043 divider_1/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C3044 divider_1/tspc_1/Z4 vssa1 0.86fF
C3045 divider_1/tspc_1/Z3 vssa1 2.26fF
C3046 divider_1/tspc_1/Z2 vssa1 1.46fF
C3047 divider_1/tspc_1/Z1 vssa1 0.99fF
C3048 divider_1/nor_0/B vssa1 7.05fF
C3049 divider_1/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C3050 divider_1/tspc_2/Q vssa1 3.14fF
C3051 divider_1/tspc_0/Z4 vssa1 0.86fF
C3052 divider_1/Out vssa1 1.60fF
C3053 divider_1/tspc_0/Z3 vssa1 2.26fF
C3054 divider_1/tspc_0/Z2 vssa1 1.46fF
C3055 divider_1/tspc_0/Z1 vssa1 0.99fF
C3056 divider_1/nor_1/B vssa1 6.33fF
C3057 divider_1/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C3058 divider_1/tspc_1/Q vssa1 3.12fF
C3059 divider_1/clk vssa1 5.63fF
C3060 divider_1/prescaler_0/nand_1/z1 vssa1 0.36fF
C3061 divider_1/prescaler_0/tspc_0/D vssa1 2.64fF
C3062 divider_1/prescaler_0/tspc_2/Q vssa1 3.74fF
C3063 divider_1/prescaler_0/tspc_1/Q vssa1 3.61fF
C3064 divider_1/prescaler_0/nand_0/z1 vssa1 0.36fF
C3065 divider_1/prescaler_0/tspc_2/D vssa1 3.12fF
C3066 divider_1/and_0/OUT vssa1 5.62fF
C3067 divider_1/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C3068 divider_1/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C3069 divider_1/prescaler_0/tspc_2/Z2 vssa1 1.46fF
C3070 divider_1/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C3071 divider_1/prescaler_0/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C3072 divider_1/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C3073 divider_1/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C3074 divider_1/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C3075 divider_1/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C3076 divider_1/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C3077 divider_1/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C3078 divider_1/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C3079 divider_1/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C3080 divider_1/prescaler_0/Out vssa1 4.59fF
C3081 divider_1/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C3082 divider_1/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C3083 divider_1/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C3084 divider_1/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C3085 divider_1/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C3086 divider_1/nor_1/Z1 vssa1 1.34fF
C3087 divider_1/mc2 vssa1 5.29fF
C3088 divider_1/nor_0/Z1 vssa1 1.34fF
C3089 divbuf_15/OUT vssa1 363.82fF
C3090 divbuf_15/OUT5 vssa1 350.37fF
C3091 divbuf_15/OUT4 vssa1 133.72fF
C3092 divbuf_15/OUT3 vssa1 34.03fF
C3093 divbuf_15/OUT2 vssa1 8.71fF
C3094 divbuf_15/IN vssa1 0.89fF
C3095 divbuf_15/a_492_n240# vssa1 2.46fF **FLOATING
C3096 divbuf_25/OUT5 vssa1 350.37fF
C3097 divbuf_25/OUT4 vssa1 133.72fF
C3098 divbuf_25/OUT3 vssa1 34.03fF
C3099 divbuf_25/OUT2 vssa1 8.71fF
C3100 divbuf_25/IN vssa1 0.89fF
C3101 divbuf_25/a_492_n240# vssa1 2.46fF **FLOATING
C3102 divbuf_14/OUT vssa1 363.82fF
C3103 divbuf_14/OUT5 vssa1 350.37fF
C3104 divbuf_14/OUT4 vssa1 133.72fF
C3105 divbuf_14/OUT3 vssa1 34.03fF
C3106 divbuf_14/OUT2 vssa1 8.71fF
C3107 divbuf_14/IN vssa1 0.89fF
C3108 divbuf_14/a_492_n240# vssa1 2.46fF **FLOATING
C3109 divider_0/and_0/Z1 vssa1 0.74fF
C3110 divider_0/and_0/B vssa1 2.25fF
C3111 divider_0/and_0/A vssa1 2.19fF
C3112 divider_0/and_0/out1 vssa1 2.93fF
C3113 divider_0/tspc_2/Z4 vssa1 0.86fF
C3114 divider_0/tspc_2/Z3 vssa1 2.26fF
C3115 divider_0/tspc_2/Z2 vssa1 1.46fF
C3116 divider_0/tspc_2/Z1 vssa1 0.99fF
C3117 divider_0/nor_0/A vssa1 7.04fF
C3118 divider_0/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C3119 divider_0/tspc_1/Z4 vssa1 0.86fF
C3120 divider_0/tspc_1/Z3 vssa1 2.26fF
C3121 divider_0/tspc_1/Z2 vssa1 1.46fF
C3122 divider_0/tspc_1/Z1 vssa1 0.99fF
C3123 divider_0/nor_0/B vssa1 7.05fF
C3124 divider_0/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C3125 divider_0/tspc_2/Q vssa1 3.14fF
C3126 divider_0/tspc_0/Z4 vssa1 0.86fF
C3127 divider_0/Out vssa1 1.60fF
C3128 divider_0/tspc_0/Z3 vssa1 2.26fF
C3129 divider_0/tspc_0/Z2 vssa1 1.46fF
C3130 divider_0/tspc_0/Z1 vssa1 0.99fF
C3131 divider_0/nor_1/B vssa1 6.33fF
C3132 divider_0/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C3133 divider_0/tspc_1/Q vssa1 3.12fF
C3134 divider_0/clk vssa1 5.63fF
C3135 divider_0/prescaler_0/nand_1/z1 vssa1 0.36fF
C3136 divider_0/prescaler_0/tspc_0/D vssa1 2.64fF
C3137 divider_0/prescaler_0/tspc_2/Q vssa1 3.64fF
C3138 divider_0/prescaler_0/tspc_1/Q vssa1 3.61fF
C3139 divider_0/prescaler_0/nand_0/z1 vssa1 0.36fF
C3140 divider_0/prescaler_0/tspc_2/D vssa1 3.12fF
C3141 divider_0/and_0/OUT vssa1 5.62fF
C3142 divider_0/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C3143 divider_0/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C3144 divider_0/prescaler_0/tspc_2/Z2 vssa1 1.46fF
C3145 divider_0/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C3146 divider_0/prescaler_0/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C3147 divider_0/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C3148 divider_0/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C3149 divider_0/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C3150 divider_0/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C3151 divider_0/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C3152 divider_0/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C3153 divider_0/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C3154 divider_0/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C3155 divider_0/prescaler_0/Out vssa1 4.59fF
C3156 divider_0/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C3157 divider_0/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C3158 divider_0/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C3159 divider_0/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C3160 divider_0/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C3161 divider_0/nor_1/Z1 vssa1 1.34fF
C3162 divider_0/mc2 vssa1 5.29fF
C3163 divider_0/nor_0/Z1 vssa1 1.34fF
C3164 divbuf_24/OUT vssa1 363.82fF
C3165 divbuf_24/OUT5 vssa1 350.37fF
C3166 divbuf_24/OUT4 vssa1 133.72fF
C3167 divbuf_24/OUT3 vssa1 34.03fF
C3168 divbuf_24/OUT2 vssa1 8.71fF
C3169 divbuf_24/IN vssa1 0.89fF
C3170 divbuf_24/a_492_n240# vssa1 2.46fF **FLOATING
C3171 divbuf_13/OUT vssa1 363.82fF
C3172 divbuf_13/OUT5 vssa1 350.37fF
C3173 divbuf_13/OUT4 vssa1 133.72fF
C3174 divbuf_13/OUT3 vssa1 34.03fF
C3175 divbuf_13/OUT2 vssa1 8.71fF
C3176 divbuf_13/IN vssa1 0.89fF
C3177 divbuf_13/a_492_n240# vssa1 2.46fF **FLOATING
C3178 divbuf_9/OUT vssa1 363.82fF
C3179 divbuf_9/OUT5 vssa1 350.37fF
C3180 divbuf_9/OUT4 vssa1 133.72fF
C3181 divbuf_9/OUT3 vssa1 34.03fF
C3182 divbuf_9/OUT2 vssa1 8.71fF
C3183 divbuf_9/IN vssa1 0.89fF
C3184 divbuf_9/a_492_n240# vssa1 2.46fF **FLOATING
C3185 divbuf_23/OUT vssa1 363.82fF
C3186 divbuf_23/OUT5 vssa1 350.37fF
C3187 divbuf_23/OUT4 vssa1 133.72fF
C3188 divbuf_23/OUT3 vssa1 34.03fF
C3189 divbuf_23/OUT2 vssa1 8.71fF
C3190 divbuf_23/IN vssa1 0.89fF
C3191 divbuf_23/a_492_n240# vssa1 2.46fF **FLOATING
C3192 divbuf_12/OUT vssa1 363.82fF
C3193 divbuf_12/OUT5 vssa1 350.37fF
C3194 divbuf_12/OUT4 vssa1 133.72fF
C3195 divbuf_12/OUT3 vssa1 34.03fF
C3196 divbuf_12/OUT2 vssa1 8.71fF
C3197 divbuf_12/IN vssa1 0.89fF
C3198 divbuf_12/a_492_n240# vssa1 2.46fF **FLOATING
C3199 divbuf_8/OUT vssa1 363.82fF
C3200 divbuf_8/OUT5 vssa1 350.37fF
C3201 divbuf_8/OUT4 vssa1 133.72fF
C3202 divbuf_8/OUT3 vssa1 34.03fF
C3203 divbuf_8/OUT2 vssa1 8.71fF
C3204 divbuf_8/IN vssa1 0.89fF
C3205 divbuf_8/a_492_n240# vssa1 2.46fF **FLOATING
C3206 divbuf_22/OUT vssa1 363.82fF
C3207 divbuf_22/OUT5 vssa1 350.37fF
C3208 divbuf_22/OUT4 vssa1 133.72fF
C3209 divbuf_22/OUT3 vssa1 34.03fF
C3210 divbuf_22/OUT2 vssa1 8.71fF
C3211 divbuf_22/IN vssa1 0.89fF
C3212 divbuf_22/a_492_n240# vssa1 2.46fF **FLOATING
C3213 divbuf_11/OUT vssa1 363.82fF
C3214 divbuf_11/OUT5 vssa1 350.37fF
C3215 divbuf_11/OUT4 vssa1 133.72fF
C3216 divbuf_11/OUT3 vssa1 34.03fF
C3217 divbuf_11/OUT2 vssa1 8.71fF
C3218 divbuf_11/IN vssa1 0.89fF
C3219 divbuf_11/a_492_n240# vssa1 2.46fF **FLOATING
C3220 divbuf_7/OUT5 vssa1 350.37fF
C3221 divbuf_7/OUT4 vssa1 133.72fF
C3222 divbuf_7/OUT3 vssa1 34.03fF
C3223 divbuf_7/OUT2 vssa1 8.71fF
C3224 divbuf_7/IN vssa1 0.89fF
C3225 divbuf_7/a_492_n240# vssa1 2.46fF **FLOATING
C3226 divbuf_21/OUT vssa1 363.82fF
C3227 divbuf_21/OUT5 vssa1 350.37fF
C3228 divbuf_21/OUT4 vssa1 133.72fF
C3229 divbuf_21/OUT3 vssa1 34.03fF
C3230 divbuf_21/OUT2 vssa1 8.71fF
C3231 divbuf_21/IN vssa1 0.89fF
C3232 divbuf_21/a_492_n240# vssa1 2.46fF **FLOATING
C3233 divbuf_20/OUT vssa1 363.82fF
C3234 divbuf_20/OUT5 vssa1 350.37fF
C3235 divbuf_20/OUT4 vssa1 133.72fF
C3236 divbuf_20/OUT3 vssa1 34.03fF
C3237 divbuf_20/OUT2 vssa1 8.71fF
C3238 divbuf_20/IN vssa1 0.89fF
C3239 divbuf_20/a_492_n240# vssa1 2.46fF **FLOATING
C3240 divbuf_10/OUT vssa1 363.82fF
C3241 divbuf_10/OUT5 vssa1 350.37fF
C3242 divbuf_10/OUT4 vssa1 133.72fF
C3243 divbuf_10/OUT3 vssa1 34.03fF
C3244 divbuf_10/OUT2 vssa1 8.71fF
C3245 divbuf_10/IN vssa1 0.89fF
C3246 divbuf_10/a_492_n240# vssa1 2.46fF **FLOATING
C3247 divbuf_6/OUT5 vssa1 350.37fF
C3248 divbuf_6/OUT4 vssa1 133.72fF
C3249 divbuf_6/OUT3 vssa1 34.03fF
C3250 divbuf_6/OUT2 vssa1 8.71fF
C3251 divbuf_6/IN vssa1 0.89fF
C3252 divbuf_6/a_492_n240# vssa1 2.46fF **FLOATING
C3253 divbuf_5/OUT5 vssa1 350.37fF
C3254 divbuf_5/OUT4 vssa1 133.72fF
C3255 divbuf_5/OUT3 vssa1 34.03fF
C3256 divbuf_5/OUT2 vssa1 8.71fF
C3257 divbuf_5/IN vssa1 0.89fF
C3258 divbuf_5/a_492_n240# vssa1 2.46fF **FLOATING
C3259 divbuf_4/OUT5 vssa1 350.37fF
C3260 divbuf_4/OUT4 vssa1 133.72fF
C3261 divbuf_4/OUT3 vssa1 34.03fF
C3262 divbuf_4/OUT2 vssa1 8.71fF
C3263 divbuf_4/IN vssa1 0.89fF
C3264 divbuf_4/a_492_n240# vssa1 2.46fF **FLOATING
C3265 divbuf_3/OUT5 vssa1 350.37fF
C3266 divbuf_3/OUT4 vssa1 133.72fF
C3267 divbuf_3/OUT3 vssa1 34.03fF
C3268 divbuf_3/OUT2 vssa1 8.71fF
C3269 divbuf_3/IN vssa1 0.89fF
C3270 divbuf_3/a_492_n240# vssa1 2.46fF **FLOATING
C3271 divbuf_2/OUT5 vssa1 350.37fF
C3272 divbuf_2/OUT4 vssa1 133.72fF
C3273 divbuf_2/OUT3 vssa1 34.03fF
C3274 divbuf_2/OUT2 vssa1 8.71fF
C3275 divbuf_2/IN vssa1 0.89fF
C3276 divbuf_2/a_492_n240# vssa1 2.46fF **FLOATING
C3277 divbuf_1/OUT vssa1 363.82fF
C3278 divbuf_1/OUT5 vssa1 350.37fF
C3279 divbuf_1/OUT4 vssa1 133.72fF
C3280 divbuf_1/OUT3 vssa1 34.03fF
C3281 divbuf_1/OUT2 vssa1 8.71fF
C3282 divbuf_1/IN vssa1 0.89fF
C3283 divbuf_1/a_492_n240# vssa1 2.46fF **FLOATING
C3284 ro_complete_1/cbank_2/v vssa1 16.43fF
C3285 ro_complete_1/cbank_2/switch_5/vin vssa1 0.78fF
C3286 ro_complete_1/cbank_2/switch_4/vin vssa1 1.50fF
C3287 ro_complete_1/cbank_2/switch_2/vin vssa1 1.30fF
C3288 ro_complete_1/cbank_2/switch_3/vin vssa1 0.56fF
C3289 ro_complete_1/cbank_2/switch_1/vin vssa1 1.14fF
C3290 ro_complete_1/cbank_2/switch_0/vin vssa1 1.02fF
C3291 ro_complete_1/cbank_1/v vssa1 16.43fF
C3292 ro_complete_1/cbank_1/switch_5/vin vssa1 0.78fF
C3293 ro_complete_1/a0 vssa1 5.35fF
C3294 ro_complete_1/cbank_1/switch_4/vin vssa1 1.50fF
C3295 ro_complete_1/a1 vssa1 6.54fF
C3296 ro_complete_1/cbank_1/switch_2/vin vssa1 1.30fF
C3297 ro_complete_1/a3 vssa1 5.96fF
C3298 ro_complete_1/cbank_1/switch_3/vin vssa1 0.56fF
C3299 ro_complete_1/a2 vssa1 5.21fF
C3300 ro_complete_1/cbank_1/switch_1/vin vssa1 1.14fF
C3301 ro_complete_1/a4 vssa1 5.81fF
C3302 ro_complete_1/cbank_1/switch_0/vin vssa1 1.02fF
C3303 ro_complete_1/a5 vssa1 6.74fF
C3304 ro_complete_1/cbank_0/v vssa1 15.12fF
C3305 ro_complete_1/cbank_0/switch_5/vin vssa1 0.78fF
C3306 ro_complete_1/cbank_0/switch_4/vin vssa1 1.50fF
C3307 ro_complete_1/cbank_0/switch_2/vin vssa1 1.30fF
C3308 ro_complete_1/cbank_0/switch_3/vin vssa1 0.56fF
C3309 ro_complete_1/cbank_0/switch_1/vin vssa1 1.14fF
C3310 ro_complete_1/cbank_0/switch_0/vin vssa1 1.02fF
C3311 ro_complete_1/ro_var_extend_0/vcont vssa1 0.27fF
C3312 divbuf_0/OUT vssa1 363.82fF
C3313 divbuf_0/OUT5 vssa1 350.37fF
C3314 divbuf_0/OUT4 vssa1 133.72fF
C3315 divbuf_0/OUT3 vssa1 34.03fF
C3316 divbuf_0/OUT2 vssa1 8.71fF
C3317 divbuf_0/IN vssa1 0.89fF
C3318 divbuf_0/a_492_n240# vssa1 2.46fF **FLOATING
C3319 ro_complete_0/cbank_2/v vssa1 16.43fF
C3320 ro_complete_0/cbank_2/switch_5/vin vssa1 0.78fF
C3321 ro_complete_0/cbank_2/switch_4/vin vssa1 1.50fF
C3322 ro_complete_0/cbank_2/switch_2/vin vssa1 1.30fF
C3323 ro_complete_0/cbank_2/switch_3/vin vssa1 0.56fF
C3324 ro_complete_0/cbank_2/switch_1/vin vssa1 1.14fF
C3325 ro_complete_0/cbank_2/switch_0/vin vssa1 1.02fF
C3326 ro_complete_0/cbank_1/v vssa1 16.46fF
C3327 ro_complete_0/cbank_1/switch_5/vin vssa1 0.78fF
C3328 divbuf_7/OUT vssa1 405.76fF
C3329 ro_complete_0/cbank_1/switch_4/vin vssa1 1.50fF
C3330 divbuf_6/OUT vssa1 402.77fF
C3331 ro_complete_0/cbank_1/switch_2/vin vssa1 1.30fF
C3332 divbuf_3/OUT vssa1 394.74fF
C3333 ro_complete_0/cbank_1/switch_3/vin vssa1 0.56fF
C3334 divbuf_5/OUT vssa1 397.92fF
C3335 ro_complete_0/cbank_1/switch_1/vin vssa1 1.14fF
C3336 divbuf_4/OUT vssa1 391.26fF
C3337 ro_complete_0/cbank_1/switch_0/vin vssa1 1.02fF
C3338 divbuf_2/OUT vssa1 387.66fF
C3339 ro_complete_0/cbank_0/v vssa1 15.12fF
C3340 ro_complete_0/cbank_0/switch_5/vin vssa1 0.78fF
C3341 ro_complete_0/cbank_0/switch_4/vin vssa1 1.50fF
C3342 ro_complete_0/cbank_0/switch_2/vin vssa1 1.30fF
C3343 ro_complete_0/cbank_0/switch_3/vin vssa1 0.56fF
C3344 ro_complete_0/cbank_0/switch_1/vin vssa1 1.14fF
C3345 ro_complete_0/cbank_0/switch_0/vin vssa1 1.02fF
C3346 ro_complete_0/ro_var_extend_0/vcont vssa1 0.27fF
C3347 filter_0/v vssa1 477.90fF
C3348 filter_0/a_4216_n5230# vssa1 418.47fF **FLOATING
C3349 filter_0/a_4216_n2998# vssa1 1.03fF **FLOATING
C3350 cp_0/down vssa1 1.54fF
C3351 cp_0/vbias vssa1 2.41fF
C3352 cp_0/out vssa1 5.34fF
C3353 cp_0/upbar vssa1 1.50fF
C3354 cp_0/a_7110_n2840# vssa1 0.17fF **FLOATING
C3355 cp_0/a_3060_n2840# vssa1 1.71fF **FLOATING
C3356 cp_0/a_7110_0# vssa1 0.17fF **FLOATING
C3357 cp_0/a_6370_0# vssa1 0.40fF **FLOATING
C3358 cp_0/a_3060_0# vssa1 1.66fF **FLOATING
C3359 cp_0/a_1710_0# vssa1 5.89fF **FLOATING
C3360 cp_0/a_1710_n2840# vssa1 4.91fF **FLOATING
C3361 cp_0/a_10_n50# vssa1 2.96fF **FLOATING
C3362 pd_1/and_pd_0/Z1 vssa1 0.39fF
C3363 pd_1/and_pd_0/Out1 vssa1 2.22fF
C3364 pd_1/tspc_r_1/z5 vssa1 1.10fF
C3365 pd_1/tspc_r_1/Z4 vssa1 1.07fF
C3366 pd_1/tspc_r_1/Qbar vssa1 0.88fF
C3367 pd_1/tspc_r_1/Z2 vssa1 1.22fF
C3368 pd_1/tspc_r_1/Z1 vssa1 0.67fF
C3369 pd_1/UP vssa1 2.21fF
C3370 pd_1/tspc_r_1/Qbar1 vssa1 1.34fF
C3371 pd_1/tspc_r_1/Z3 vssa1 2.12fF
C3372 pd_1/REF vssa1 1.80fF
C3373 pd_1/tspc_r_0/z5 vssa1 1.10fF
C3374 pd_1/tspc_r_0/Z4 vssa1 1.07fF
C3375 pd_1/R vssa1 3.05fF
C3376 pd_1/tspc_r_0/Qbar vssa1 0.79fF
C3377 pd_1/tspc_r_0/Z2 vssa1 1.22fF
C3378 pd_1/tspc_r_0/Z1 vssa1 0.67fF
C3379 pd_1/DOWN vssa1 3.08fF
C3380 pd_1/tspc_r_0/Qbar1 vssa1 1.34fF
C3381 pd_1/tspc_r_0/Z3 vssa1 2.12fF
C3382 pd_1/DIV vssa1 1.82fF
C3383 pd_0/and_pd_0/Z1 vssa1 0.39fF
C3384 pd_0/and_pd_0/Out1 vssa1 2.22fF
C3385 pd_0/tspc_r_1/z5 vssa1 1.10fF
C3386 pd_0/tspc_r_1/Z4 vssa1 1.07fF
C3387 pd_0/tspc_r_1/Qbar vssa1 0.88fF
C3388 pd_0/tspc_r_1/Z2 vssa1 1.22fF
C3389 pd_0/tspc_r_1/Z1 vssa1 0.67fF
C3390 pd_0/UP vssa1 2.21fF
C3391 pd_0/tspc_r_1/Qbar1 vssa1 1.34fF
C3392 pd_0/tspc_r_1/Z3 vssa1 2.12fF
C3393 pd_0/REF vssa1 1.80fF
C3394 pd_0/tspc_r_0/z5 vssa1 1.10fF
C3395 pd_0/tspc_r_0/Z4 vssa1 1.07fF
C3396 pd_0/R vssa1 3.05fF
C3397 pd_0/tspc_r_0/Qbar vssa1 0.79fF
C3398 pd_0/tspc_r_0/Z2 vssa1 1.22fF
C3399 pd_0/tspc_r_0/Z1 vssa1 0.67fF
C3400 pd_0/DOWN vssa1 3.08fF
C3401 pd_0/tspc_r_0/Qbar1 vssa1 1.34fF
C3402 pd_0/tspc_r_0/Z3 vssa1 2.12fF
C3403 pd_0/DIV vssa1 1.82fF
.ends
