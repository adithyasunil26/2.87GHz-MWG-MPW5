* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[5] io_analog[6] io_analog[7]
+ io_analog[8] io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
C0 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar1 0.30fF
C1 divider_0/prescaler_0/tspc_2/Z2 divider_0/and_0/OUT 0.05fF
C2 divbuf_2/IN divbuf_2/a_492_n240# 0.13fF
C3 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/clk 0.06fF
C4 pll_full_1/pd_0/UP pll_full_1/pd_0/tspc_r_1/z5 0.03fF
C5 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z2 0.14fF
C6 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C7 divbuf_19/IN divbuf_19/OUT5 0.00fF
C8 divbuf_17/OUT4 divbuf_17/OUT3 5.16fF
C9 divider_1/prescaler_0/Out divider_1/tspc_2/Z2 0.11fF
C10 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/clk 0.01fF
C11 divbuf_22/OUT2 divbuf_22/OUT3 1.37fF
C12 pd_0/DIV pd_0/tspc_r_0/Z3 0.65fF
C13 divider_2/mc2 divider_2/nor_1/B 0.15fF
C14 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/prescaler_0/Out 0.15fF
C15 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/Z4 0.20fF
C16 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/B 0.18fF
C17 divider_0/tspc_0/Z2 divider_0/tspc_1/Q 0.14fF
C18 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z3 0.16fF
C19 divbuf_16/a_492_n240# divbuf_16/OUT2 0.42fF
C20 divider_0/tspc_1/Z2 divider_0/nor_0/A 0.15fF
C21 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_0/D 0.32fF
C22 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/clk 0.01fF
C23 divbuf_4/OUT divbuf_4/OUT5 43.38fF
C24 io_clamp_low[2] io_analog[6] 0.53fF
C25 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C26 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C27 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/a3 0.09fF
C28 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z2 1.07fF
C29 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z4 0.12fF
C30 divbuf_21/a_492_n240# divbuf_21/OUT2 0.42fF
C31 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/B 0.31fF
C32 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/nor_0/A 0.55fF
C33 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C34 divbuf_18/OUT2 divbuf_18/OUT3 1.37fF
C35 divider_2/nor_1/Z1 divider_2/nor_0/B 0.18fF
C36 divider_2/prescaler_0/Out divider_2/tspc_2/a_630_n680# 0.01fF
C37 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_2/Q 0.19fF
C38 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/clk 0.01fF
C39 divbuf_8/OUT5 divbuf_8/OUT 43.38fF
C40 pd_1/tspc_r_0/Z1 pd_1/tspc_r_0/Z2 0.71fF
C41 pd_1/DIV pd_1/R 0.51fF
C42 pd_0/DOWN pd_0/tspc_r_1/Qbar 0.02fF
C43 pd_0/R pd_0/tspc_r_1/Qbar1 0.30fF
C44 divider_2/nor_1/B divider_2/nor_0/B 0.47fF
C45 divider_2/tspc_0/Z2 divider_2/tspc_0/Z1 1.07fF
C46 divider_2/tspc_2/Z3 divider_2/tspc_2/Z4 0.65fF
C47 divbuf_24/a_492_n240# divbuf_24/OUT 0.00fF
C48 divbuf_3/OUT ro_complete_0/cbank_2/switch_1/vin 0.13fF
C49 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C50 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z3 0.33fF
C51 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z2 1.07fF
C52 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z4 0.12fF
C53 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.15fF
C54 divbuf_16/a_492_n240# divbuf_16/IN 0.13fF
C55 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z2 0.01fF
C56 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C57 divider_1/nor_0/B divider_1/tspc_2/Q 0.22fF
C58 divider_1/tspc_0/a_630_n680# divider_1/nor_1/B 0.35fF
C59 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z4 0.08fF
C60 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z3 0.05fF
C61 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Q 0.51fF
C62 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z4 0.36fF
C63 filter_0/v divbuf_25/OUT2 0.06fF
C64 divbuf_7/IN divbuf_7/OUT5 0.00fF
C65 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/clk 0.06fF
C66 divider_1/tspc_2/a_630_n680# divider_1/nor_0/A 0.35fF
C67 divider_1/prescaler_0/tspc_0/D divider_1/clk 0.29fF
C68 pll_full_1/divider_0/and_0/B pll_full_1/divider_0/nor_0/Z1 0.18fF
C69 divbuf_23/a_492_n240# divbuf_23/IN 0.13fF
C70 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C71 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C72 pll_full_0/cp_0/a_1710_0# pll_full_0/cp_0/down 0.32fF
C73 divbuf_15/OUT4 divbuf_15/OUT 1.11fF
C74 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C75 divbuf_4/OUT ro_complete_0/cbank_2/v 0.05fF
C76 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/v 1.30fF
C77 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z2 0.01fF
C78 divider_0/tspc_2/Q divider_0/tspc_1/Z3 0.45fF
C79 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z4 0.08fF
C80 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z3 0.05fF
C81 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Q 0.04fF
C82 divider_2/tspc_0/Z4 divider_2/tspc_0/Z2 0.36fF
C83 divider_2/Out divider_2/tspc_0/Z3 0.05fF
C84 divbuf_16/a_492_n240# divbuf_16/OUT5 0.01fF
C85 ro_complete_1/a0 ro_complete_1/cbank_2/switch_4/vin 0.13fF
C86 ro_complete_1/cbank_0/v ro_complete_1/cbank_1/v 1.27fF
C87 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_1/a_630_n680# 0.04fF
C88 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_0/Z4 0.65fF
C89 divider_1/tspc_1/a_630_n680# divider_1/nor_1/B 0.00fF
C90 divider_1/prescaler_0/tspc_1/Z2 divider_1/and_0/OUT 0.06fF
C91 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z3 0.33fF
C92 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Q 0.38fF
C93 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/D 0.11fF
C94 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z3 0.06fF
C95 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C96 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/A 0.01fF
C97 divbuf_18/IN divbuf_18/OUT5 0.00fF
C98 divider_2/tspc_1/a_630_n680# divider_2/nor_1/B 0.00fF
C99 divider_1/and_0/out1 divider_1/and_0/A 0.01fF
C100 divbuf_9/OUT2 divbuf_9/OUT3 1.37fF
C101 cp_0/a_10_n50# cp_0/a_1710_0# 0.04fF
C102 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C103 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C104 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C105 ro_complete_0/cbank_2/switch_2/vin ro_complete_0/cbank_2/v 1.30fF
C106 divider_1/tspc_0/Z2 divider_1/tspc_0/a_630_n680# 0.01fF
C107 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z4 0.00fF
C108 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Z3 0.65fF
C109 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_1/Q 0.21fF
C110 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/clk 0.01fF
C111 divider_1/nor_0/B divider_1/and_0/A 0.26fF
C112 divbuf_20/OUT3 divbuf_20/OUT4 5.16fF
C113 divbuf_20/OUT2 divbuf_20/OUT5 0.02fF
C114 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/nor_0/A 0.01fF
C115 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z4 0.12fF
C116 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z3 0.16fF
C117 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C118 divbuf_8/a_492_n240# divbuf_8/OUT2 0.42fF
C119 pd_0/DOWN pd_0/tspc_r_0/z5 0.03fF
C120 pd_0/tspc_r_0/Z2 pd_0/R 0.21fF
C121 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z2 0.01fF
C122 divbuf_13/OUT5 divbuf_13/OUT 43.38fF
C123 pd_1/tspc_r_1/Z4 pd_1/tspc_r_1/z5 0.04fF
C124 ro_complete_0/cbank_1/switch_1/vin divbuf_3/OUT 0.14fF
C125 pll_full_1/ro_complete_0/cbank_2/switch_2/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C126 ro_complete_0/cbank_2/switch_3/vin divbuf_6/OUT 0.14fF
C127 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z1 0.08fF
C128 divider_0/mc2 divider_0/nor_1/B 0.15fF
C129 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/cbank_0/v 1.30fF
C130 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C131 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C132 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/a_630_n680# 0.12fF
C133 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z3 0.06fF
C134 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C135 divider_1/nor_1/B divider_1/and_0/B 0.29fF
C136 pll_full_1/pd_0/R pll_full_1/pd_0/tspc_r_0/Qbar1 0.01fF
C137 divbuf_12/IN divbuf_12/OUT5 0.00fF
C138 pd_0/DOWN pd_0/and_pd_0/Z1 0.07fF
C139 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/a1 0.14fF
C140 filter_0/a_4216_n5230# filter_0/v 0.91fF
C141 ro_complete_0/cbank_1/switch_4/vin divbuf_7/OUT 0.13fF
C142 divbuf_2/OUT ro_complete_0/cbank_2/switch_0/vin 0.09fF
C143 divider_0/nor_0/B divider_0/tspc_1/Z4 0.21fF
C144 divider_0/tspc_0/Z3 divider_0/nor_1/B 0.38fF
C145 pll_full_1/divider_0/prescaler_0/tspc_2/D pll_full_1/divider_0/prescaler_0/nand_0/z1 0.24fF
C146 divbuf_1/OUT divbuf_1/OUT3 0.26fF
C147 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT4 5.16fF
C148 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C149 divider_0/nor_0/A divider_0/and_0/B 0.08fF
C150 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/nor_1/B 0.22fF
C151 divider_1/tspc_1/Z1 divider_1/tspc_1/Z2 1.07fF
C152 divider_1/nor_0/B divider_1/tspc_1/Z3 0.38fF
C153 divider_1/tspc_1/Q divider_1/nor_1/B 0.22fF
C154 divbuf_6/OUT3 divbuf_6/OUT5 0.01fF
C155 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C156 divbuf_18/OUT2 divbuf_18/OUT5 0.02fF
C157 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z1 0.03fF
C158 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z3 0.05fF
C159 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/Z3 0.20fF
C160 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C161 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/DOWN 0.03fF
C162 divbuf_19/OUT5 divbuf_19/OUT3 0.01fF
C163 divider_2/nor_0/B divider_2/tspc_2/a_630_n680# 0.01fF
C164 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/D 0.03fF
C165 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C166 pll_full_1/ro_complete_0/a5 pll_full_1/divider_0/clk 0.15fF
C167 divbuf_6/OUT ro_complete_0/cbank_2/v 0.05fF
C168 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Q 0.20fF
C169 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/D 0.09fF
C170 divider_0/prescaler_0/tspc_0/Z2 divider_0/clk 0.11fF
C171 pll_full_1/divider_0/prescaler_0/tspc_2/D pll_full_1/divider_0/clk 0.26fF
C172 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/tspc_r_1/Z4 0.14fF
C173 pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C174 divider_2/tspc_0/Z4 divider_2/nor_0/B 0.02fF
C175 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/a_630_n680# 0.01fF
C176 divbuf_19/OUT2 divbuf_19/OUT 0.06fF
C177 divider_1/prescaler_0/tspc_2/Z2 divider_1/and_0/OUT 0.05fF
C178 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z3 0.05fF
C179 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Qbar1 0.38fF
C180 divider_2/tspc_0/Z2 divider_2/tspc_0/Z3 0.16fF
C181 divbuf_22/OUT3 divbuf_22/OUT4 5.16fF
C182 divbuf_22/OUT2 divbuf_22/OUT5 0.02fF
C183 pll_full_1/divider_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/Out 0.11fF
C184 pll_full_0/divider_0/and_0/A pll_full_0/divider_0/and_0/B 0.18fF
C185 divbuf_13/a_492_n240# divbuf_13/OUT2 0.42fF
C186 pd_1/REF pd_1/tspc_r_1/Z4 0.02fF
C187 pd_1/UP pd_1/tspc_r_1/Qbar 0.21fF
C188 pll_full_1/pd_0/DIV pll_full_1/divider_0/clk 2.26fF
C189 pll_full_1/ro_complete_0/a1 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C190 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/R 0.27fF
C191 divider_2/prescaler_0/tspc_1/Q divider_2/nor_0/A 0.03fF
C192 divider_0/tspc_0/Z2 divider_0/tspc_0/Z3 0.16fF
C193 divider_0/tspc_0/a_630_n680# divider_0/tspc_1/Q 0.01fF
C194 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z4 0.36fF
C195 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/Out 0.05fF
C196 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C197 divbuf_5/OUT divbuf_5/OUT3 0.26fF
C198 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Qbar1 0.12fF
C199 pll_full_1/pd_0/tspc_r_0/Z1 pll_full_1/pd_0/DIV 0.17fF
C200 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C201 divider_1/mc2 divider_1/prescaler_0/tspc_2/a_630_n680# 0.33fF
C202 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/nand_1/z1 0.22fF
C203 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/tspc_0/D 0.04fF
C204 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_0/B 0.18fF
C205 divider_1/tspc_0/Z2 divider_1/tspc_1/Q 0.14fF
C206 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z3 0.16fF
C207 divider_2/prescaler_0/Out divider_2/nor_0/A 0.15fF
C208 divider_1/tspc_1/Z2 divider_1/nor_0/A 0.15fF
C209 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_0/D 0.32fF
C210 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/clk 0.01fF
C211 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C212 pd_1/DIV pd_1/tspc_r_0/Z4 0.02fF
C213 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Qbar1 0.12fF
C214 divbuf_24/IN divbuf_24/OUT5 0.00fF
C215 pll_full_0/pd_0/DOWN pll_full_0/pd_0/R 0.36fF
C216 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z4 0.08fF
C217 divider_0/tspc_1/Q divider_0/tspc_1/a_630_n680# 0.04fF
C218 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z3 0.16fF
C219 divbuf_1/OUT2 divbuf_1/OUT 0.06fF
C220 divbuf_5/OUT ro_complete_0/cbank_1/v 0.05fF
C221 ro_complete_0/cbank_0/switch_4/vin divbuf_7/OUT 0.13fF
C222 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.05fF
C223 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/clk 0.64fF
C224 pll_full_1/pd_0/REF pll_full_1/pd_0/DOWN 1.48fF
C225 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/R 0.03fF
C226 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C227 divider_0/nor_0/A divider_0/tspc_2/Z2 0.23fF
C228 pll_full_1/pd_0/REF pll_full_1/divbuf_1/OUT5 0.00fF
C229 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/DOWN 0.12fF
C230 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C231 pll_full_0/ro_complete_0/a5 pll_full_0/divider_0/clk 0.15fF
C232 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z2 1.07fF
C233 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z4 0.12fF
C234 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z2 0.01fF
C235 divbuf_7/OUT3 divbuf_7/OUT5 0.01fF
C236 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C237 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/out1 0.31fF
C238 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/clk 0.26fF
C239 pd_0/tspc_r_1/Z4 pd_0/tspc_r_1/z5 0.04fF
C240 divider_2/nor_0/Z1 divider_2/and_0/B 0.18fF
C241 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/a0 0.13fF
C242 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C243 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C244 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/divider_0/clk 1.46fF
C245 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Out1 0.12fF
C246 divider_0/tspc_2/Q divider_0/tspc_1/Z4 0.15fF
C247 divider_0/tspc_0/Z4 divider_0/nor_1/B 0.22fF
C248 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z2 1.07fF
C249 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z4 0.12fF
C250 divbuf_2/OUT2 divbuf_2/OUT3 1.37fF
C251 divbuf_1/OUT5 divbuf_1/OUT4 20.26fF
C252 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/v 1.43fF
C253 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/DOWN 0.07fF
C254 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/DIV 0.04fF
C255 pll_full_0/ro_complete_0/a1 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C256 divider_2/Out divider_2/tspc_0/a_630_n680# 0.04fF
C257 divider_0/and_0/out1 divider_0/and_0/Z1 0.36fF
C258 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/nor_0/B 0.51fF
C259 divbuf_10/a_492_n240# divbuf_10/OUT5 0.01fF
C260 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z4 0.00fF
C261 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_1/Z3 0.05fF
C262 pll_full_0/divbuf_0/IN pll_full_0/divider_0/nor_1/B 0.27fF
C263 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z2 0.01fF
C264 divider_1/tspc_2/Q divider_1/tspc_1/Z3 0.45fF
C265 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z4 0.08fF
C266 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z3 0.05fF
C267 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Q 0.04fF
C268 divider_2/tspc_2/Q divider_2/nor_0/B 0.22fF
C269 divbuf_9/OUT3 divbuf_9/OUT4 5.16fF
C270 divbuf_9/OUT2 divbuf_9/OUT5 0.02fF
C271 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/cbank_0/switch_1/vin 0.19fF
C272 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C273 pll_full_1/ro_complete_0/cbank_0/v pll_full_1/divider_0/clk 1.27fF
C274 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/REF 0.19fF
C275 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C276 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C277 pll_full_0/pd_0/UP pll_full_0/pd_0/tspc_r_1/Qbar 0.21fF
C278 divbuf_25/a_492_n240# divbuf_25/OUT2 0.42fF
C279 divider_0/tspc_2/Q divider_0/tspc_2/Z3 0.05fF
C280 divider_0/prescaler_0/tspc_1/Z2 divider_0/clk 0.11fF
C281 divbuf_3/OUT divbuf_3/a_492_n240# 0.00fF
C282 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/switch_5/vin 0.20fF
C283 pll_full_0/pd_0/DIV pll_full_0/divider_0/clk 2.26fF
C284 divbuf_7/OUT divbuf_7/OUT2 0.06fF
C285 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/a_630_n680# 0.19fF
C286 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_2/a_630_n680# 0.04fF
C287 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_1/Z4 0.65fF
C288 divbuf_20/OUT3 divbuf_20/OUT 0.26fF
C289 divbuf_20/OUT4 divbuf_20/OUT5 20.26fF
C290 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z4 0.36fF
C291 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C292 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/clk 0.64fF
C293 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/D 0.05fF
C294 pd_0/tspc_r_0/Z2 pd_0/tspc_r_0/Z4 0.14fF
C295 pd_1/UP pd_1/and_pd_0/Z1 0.06fF
C296 pll_full_1/ro_complete_0/cbank_2/switch_4/vin pll_full_1/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C297 divbuf_4/OUT ro_complete_0/cbank_2/switch_1/vin 0.09fF
C298 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/v 1.30fF
C299 divider_0/tspc_0/Z2 divider_0/tspc_0/Z4 0.36fF
C300 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z3 0.11fF
C301 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C302 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C303 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/switch_5/vin 0.20fF
C304 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/a0 0.13fF
C305 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C306 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C307 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/divider_0/clk 1.46fF
C308 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z2 0.16fF
C309 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z1 0.08fF
C310 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z4 0.00fF
C311 pll_full_0/divider_0/tspc_1/Z4 pll_full_0/divider_0/nor_0/A 0.02fF
C312 divider_2/tspc_2/Q divider_2/tspc_1/a_630_n680# 0.01fF
C313 pd_1/tspc_r_0/Z2 pd_1/R 0.21fF
C314 pd_0/R pd_0/and_pd_0/Out1 0.33fF
C315 pd_0/REF pd_0/tspc_r_1/Z4 0.02fF
C316 pd_0/UP pd_0/tspc_r_1/Qbar 0.21fF
C317 divider_2/mc2 divider_2/nor_0/A 0.04fF
C318 divider_2/nor_0/B divider_2/tspc_1/Z2 0.30fF
C319 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z2 0.01fF
C320 divbuf_12/OUT3 divbuf_12/OUT5 0.01fF
C321 divbuf_12/OUT2 divbuf_12/OUT 0.06fF
C322 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C323 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C324 divider_2/and_0/out1 divider_2/and_0/B 0.18fF
C325 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/Out 0.21fF
C326 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C327 divider_0/mc2 divider_0/nor_0/A 0.04fF
C328 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C329 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.04fF
C330 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/clk 0.45fF
C331 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/v 1.30fF
C332 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/Z2 0.14fF
C333 filter_0/v divbuf_25/OUT3 0.26fF
C334 pll_full_1/divbuf_1/a_492_n240# pll_full_1/divbuf_1/OUT 0.00fF
C335 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/DIV 0.65fF
C336 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_0/Z4 0.02fF
C337 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C338 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/divider_0/clk 1.27fF
C339 divbuf_17/OUT2 divbuf_17/OUT3 1.37fF
C340 divider_1/nor_0/B divider_1/tspc_1/Z4 0.21fF
C341 divider_1/tspc_0/Z3 divider_1/nor_1/B 0.38fF
C342 divbuf_11/a_492_n240# divbuf_11/OUT5 0.01fF
C343 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z2 1.07fF
C344 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z3 0.38fF
C345 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z4 0.12fF
C346 divider_1/nor_0/A divider_1/and_0/B 0.08fF
C347 pd_1/DOWN pd_1/UP 0.46fF
C348 pd_1/tspc_r_0/z5 pd_1/tspc_r_0/Qbar1 0.20fF
C349 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z1 0.09fF
C350 divbuf_19/OUT divbuf_19/OUT4 1.11fF
C351 divider_2/and_0/OUT divider_2/prescaler_0/nand_0/z1 0.01fF
C352 divider_2/nor_0/B divider_2/nor_0/A 1.21fF
C353 pll_full_1/pd_0/DIV pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.03fF
C354 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C355 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z2 0.21fF
C356 divbuf_15/OUT5 divbuf_15/IN 0.00fF
C357 divbuf_25/OUT3 divbuf_25/OUT4 5.16fF
C358 ro_complete_0/cbank_1/switch_5/vin ro_complete_0/cbank_1/v 1.30fF
C359 divider_0/tspc_1/Z3 divider_0/tspc_1/Z4 0.65fF
C360 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Q 0.04fF
C361 divider_0/prescaler_0/Out divider_0/clk 0.51fF
C362 ro_complete_1/a0 ro_complete_1/cbank_2/switch_5/vin 0.09fF
C363 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/nor_0/B 0.22fF
C364 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C365 pll_full_1/divbuf_0/IN pll_full_1/divbuf_0/OUT5 0.00fF
C366 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z4 0.12fF
C367 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C368 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Q 0.20fF
C369 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/D 0.09fF
C370 divider_1/prescaler_0/tspc_0/Z2 divider_1/clk 0.11fF
C371 divbuf_22/OUT3 divbuf_22/OUT 0.26fF
C372 divbuf_22/OUT4 divbuf_22/OUT5 20.26fF
C373 pd_0/DIV pd_0/tspc_r_0/Z1 0.17fF
C374 pd_0/tspc_r_0/Qbar1 pd_0/DOWN 0.11fF
C375 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z2 0.01fF
C376 divider_2/tspc_2/Q divider_2/tspc_1/Z3 0.45fF
C377 divider_2/tspc_0/Z2 divider_2/tspc_0/a_630_n680# 0.01fF
C378 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/z5 0.11fF
C379 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z4 0.20fF
C380 divider_2/and_0/OUT divider_2/clk 0.04fF
C381 io_clamp_low[2] io_clamp_high[2] 0.53fF
C382 divbuf_5/OUT divbuf_3/OUT 3.09fF
C383 divbuf_4/OUT ro_complete_0/cbank_1/switch_1/vin 0.09fF
C384 pll_full_0/pd_0/UP pll_full_0/pd_0/and_pd_0/Z1 0.06fF
C385 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z3 0.05fF
C386 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.13fF
C387 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/and_0/OUT 0.14fF
C388 divbuf_5/OUT divbuf_5/OUT5 43.38fF
C389 divbuf_1/OUT divbuf_1/a_492_n240# 0.00fF
C390 divbuf_14/OUT divbuf_14/OUT5 43.38fF
C391 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/nand_1/z1 0.01fF
C392 divider_0/prescaler_0/tspc_2/Z2 divider_0/clk 0.11fF
C393 io_clamp_high[1] io_analog[5] 0.53fF
C394 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C395 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C396 divider_1/tspc_0/Z2 divider_1/tspc_0/Z3 0.16fF
C397 divider_1/tspc_0/a_630_n680# divider_1/tspc_1/Q 0.01fF
C398 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z4 0.36fF
C399 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/Out 0.05fF
C400 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/Out 0.21fF
C401 divbuf_21/a_492_n240# divbuf_21/OUT 0.00fF
C402 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C403 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/clk 0.45fF
C404 divider_2/prescaler_0/Out divider_2/tspc_2/Z2 0.11fF
C405 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/nand_1/z1 0.22fF
C406 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/tspc_0/D 0.04fF
C407 pd_0/R pd_0/tspc_r_1/Z2 0.21fF
C408 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C409 divider_2/nor_0/B divider_2/tspc_1/Z1 0.03fF
C410 divider_2/nor_0/A divider_2/and_0/A 0.01fF
C411 divbuf_24/OUT3 divbuf_24/OUT5 0.01fF
C412 divbuf_24/OUT2 divbuf_24/OUT 0.06fF
C413 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C414 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z4 0.36fF
C415 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.11fF
C416 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/clk 0.12fF
C417 ro_complete_1/a4 ro_complete_1/cbank_1/v 0.05fF
C418 divider_0/tspc_2/Z1 divider_0/tspc_2/Z3 0.06fF
C419 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C420 divider_1/tspc_1/Q divider_1/tspc_1/a_630_n680# 0.04fF
C421 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z3 0.16fF
C422 divbuf_6/a_492_n240# divbuf_6/IN 0.13fF
C423 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/nor_1/B 0.03fF
C424 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/pd_0/tspc_r_1/Z3 0.09fF
C425 divider_1/nor_0/A divider_1/tspc_2/Z2 0.23fF
C426 divbuf_23/a_492_n240# divbuf_23/OUT5 0.01fF
C427 pd_1/DOWN pd_1/tspc_r_0/z5 0.03fF
C428 pd_0/UP pd_0/and_pd_0/Z1 0.06fF
C429 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C430 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z2 0.19fF
C431 divbuf_19/OUT divbuf_19/a_492_n240# 0.00fF
C432 divider_2/prescaler_0/m1_2700_2190# divider_2/nor_0/A 0.01fF
C433 divider_2/tspc_1/Z2 divider_2/tspc_1/Z3 0.16fF
C434 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/D 0.15fF
C435 divider_2/mc2 divider_2/and_0/B 0.20fF
C436 divbuf_15/OUT4 divbuf_15/OUT3 5.16fF
C437 divbuf_15/OUT5 divbuf_15/OUT2 0.02fF
C438 divbuf_2/OUT2 divbuf_2/OUT5 0.02fF
C439 divbuf_2/OUT ro_complete_0/cbank_2/v 0.08fF
C440 divbuf_7/OUT ro_complete_0/cbank_1/switch_5/vin 0.09fF
C441 pll_full_0/pd_0/DIV pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C442 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C443 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z3 0.16fF
C444 divider_0/mc2 divider_0/and_0/B 0.20fF
C445 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/clk 0.45fF
C446 divbuf_3/OUT3 divbuf_3/OUT5 0.01fF
C447 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/IN 0.00fF
C448 divider_1/tspc_2/Q divider_1/tspc_1/Z4 0.15fF
C449 divider_1/tspc_0/Z4 divider_1/nor_1/B 0.22fF
C450 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z2 1.07fF
C451 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z4 0.12fF
C452 divbuf_10/OUT2 divbuf_10/OUT3 1.37fF
C453 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C454 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/and_0/OUT 0.14fF
C455 divider_1/and_0/out1 divider_1/and_0/Z1 0.36fF
C456 divbuf_9/OUT3 divbuf_9/OUT 0.26fF
C457 divbuf_9/OUT4 divbuf_9/OUT5 20.26fF
C458 pd_1/tspc_r_0/Z4 pd_1/tspc_r_1/Z4 0.02fF
C459 pd_1/REF pd_1/tspc_r_1/Z3 0.65fF
C460 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_2/v 0.08fF
C461 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C462 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C463 divider_2/nor_0/B divider_2/and_0/B 0.31fF
C464 divider_0/nor_1/Z1 divider_0/nor_0/B 0.18fF
C465 divbuf_0/OUT3 divbuf_0/OUT4 5.16fF
C466 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C467 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/z5 0.11fF
C468 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C469 divbuf_4/OUT divbuf_4/a_492_n240# 0.00fF
C470 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/v 1.30fF
C471 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C472 divbuf_7/OUT divbuf_7/OUT4 1.11fF
C473 divbuf_4/IN divbuf_4/OUT5 0.00fF
C474 ro_complete_1/cbank_1/v ro_complete_1/cbank_2/v 1.36fF
C475 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/nor_0/A 0.55fF
C476 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/D 0.11fF
C477 divider_1/tspc_2/Q divider_1/tspc_2/Z3 0.05fF
C478 divider_1/prescaler_0/tspc_1/Z2 divider_1/clk 0.11fF
C479 divbuf_20/OUT5 divbuf_20/OUT 43.38fF
C480 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C481 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/clk 0.12fF
C482 divbuf_8/a_492_n240# divbuf_8/OUT 0.00fF
C483 pll_full_1/divbuf_1/OUT2 pll_full_1/divbuf_1/OUT5 0.02fF
C484 pll_full_1/divbuf_0/OUT4 pll_full_1/divbuf_0/OUT5 20.26fF
C485 divider_2/tspc_0/Z2 divider_2/tspc_1/Q 0.14fF
C486 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z3 0.06fF
C487 pll_full_1/ro_complete_0/cbank_2/switch_4/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C488 divider_2/nor_0/A divider_2/tspc_2/Z1 0.03fF
C489 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z3 0.05fF
C490 divider_0/tspc_1/Q divider_0/tspc_0/Z3 0.45fF
C491 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z4 0.12fF
C492 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z4 0.28fF
C493 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C494 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.21fF
C495 ro_complete_1/a5 ro_complete_1/cbank_1/switch_0/vin 0.09fF
C496 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/v 1.30fF
C497 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C498 divider_0/and_0/OUT divider_0/and_0/B 0.01fF
C499 divbuf_5/IN divbuf_5/OUT5 0.00fF
C500 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/Z2 0.36fF
C501 divider_1/tspc_0/Z2 divider_1/tspc_0/Z4 0.36fF
C502 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z3 0.11fF
C503 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/a_630_n680# 0.19fF
C504 pll_full_1/divider_0/tspc_2/Z3 pll_full_1/divider_0/tspc_2/Z4 0.65fF
C505 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divbuf_0/IN 0.04fF
C506 divbuf_7/a_492_n240# divbuf_7/IN 0.13fF
C507 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/nor_1/Z1 0.06fF
C508 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/clk 0.45fF
C509 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z4 0.14fF
C510 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/z5 0.11fF
C511 divbuf_12/OUT4 divbuf_12/OUT 1.11fF
C512 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/OUT 0.31fF
C513 divider_2/tspc_1/Z1 divider_2/tspc_1/Z3 0.06fF
C514 divider_2/and_0/A divider_2/and_0/B 0.18fF
C515 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Q 0.91fF
C516 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C517 ro_complete_1/a2 ro_complete_1/cbank_0/switch_3/vin 0.09fF
C518 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 pll_full_1/divider_0/clk 0.12fF
C519 ro_complete_1/cbank_1/switch_2/vin ro_complete_1/cbank_1/v 1.30fF
C520 pll_full_1/pd_0/REF pll_full_1/pd_0/R 0.61fF
C521 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/v 0.08fF
C522 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C523 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_0/Z1 0.03fF
C524 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Z3 0.05fF
C525 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C526 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/R 0.33fF
C527 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C528 divbuf_11/OUT2 divbuf_11/OUT3 1.37fF
C529 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z4 0.21fF
C530 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z3 0.16fF
C531 pd_1/R pd_1/tspc_r_1/Z3 0.29fF
C532 divider_2/prescaler_0/tspc_2/D divider_2/prescaler_0/nand_0/z1 0.24fF
C533 divbuf_0/OUT divbuf_0/OUT3 0.26fF
C534 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z3 0.65fF
C535 divbuf_2/OUT5 divbuf_2/a_492_n240# 0.01fF
C536 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/v 1.30fF
C537 ro_complete_0/cbank_0/v ro_complete_0/cbank_2/v 0.04fF
C538 pll_full_1/pd_0/tspc_r_0/Z1 pll_full_1/pd_0/tspc_r_0/Z3 0.09fF
C539 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT4 5.16fF
C540 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C541 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/clk 0.60fF
C542 ro_complete_1/a0 ro_complete_1/cbank_2/v 0.05fF
C543 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/R 0.02fF
C544 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/IN 0.13fF
C545 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C546 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z2 0.14fF
C547 divbuf_20/a_492_n240# divbuf_20/OUT2 0.42fF
C548 divider_1/tspc_1/Z3 divider_1/tspc_1/Z4 0.65fF
C549 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Q 0.04fF
C550 divider_1/prescaler_0/Out divider_1/clk 0.51fF
C551 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C552 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C553 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C554 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z2 0.25fF
C555 divider_2/tspc_2/Q divider_2/tspc_1/Z4 0.15fF
C556 divbuf_22/OUT5 divbuf_22/OUT 43.38fF
C557 pll_full_1/pd_0/tspc_r_1/Z4 pll_full_1/pd_0/tspc_r_1/z5 0.04fF
C558 pll_full_0/divider_0/and_0/B pll_full_0/divider_0/and_0/Z1 0.07fF
C559 pd_1/UP pd_1/tspc_r_1/z5 0.03fF
C560 divbuf_13/a_492_n240# divbuf_13/OUT 0.00fF
C561 pll_full_1/ro_complete_0/cbank_0/v pll_full_1/ro_complete_0/cbank_2/v 0.04fF
C562 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/z5 0.20fF
C563 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/Qbar 0.21fF
C564 divider_2/and_0/OUT divider_2/and_0/out1 0.31fF
C565 divider_2/prescaler_0/tspc_2/D divider_2/clk 0.26fF
C566 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C567 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C568 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.21fF
C569 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_2/D 0.16fF
C570 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.03fF
C571 divbuf_14/a_492_n240# divbuf_14/OUT5 0.01fF
C572 divider_0/prescaler_0/tspc_0/D divider_0/prescaler_0/nand_1/z1 0.21fF
C573 io_clamp_low[0] io_analog[4] 0.53fF
C574 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/nor_0/B 0.20fF
C575 divider_1/tspc_0/a_630_n680# divider_1/tspc_0/Z3 0.05fF
C576 divbuf_21/IN divbuf_21/OUT5 0.00fF
C577 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/nand_1/z1 0.01fF
C578 divider_1/prescaler_0/tspc_2/Z2 divider_1/clk 0.11fF
C579 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/clk 0.12fF
C580 pd_1/DIV pd_1/tspc_r_0/Z3 0.65fF
C581 pd_0/REF pd_0/tspc_r_1/Z3 0.65fF
C582 divider_2/tspc_2/Q divider_2/tspc_2/Z3 0.05fF
C583 divider_2/nor_0/B divider_2/tspc_1/Q 0.51fF
C584 divbuf_12/a_492_n240# divbuf_12/IN 0.13fF
C585 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C586 divbuf_24/OUT4 divbuf_24/OUT 1.11fF
C587 divider_0/tspc_1/Q divider_0/tspc_0/Z4 0.15fF
C588 divider_0/tspc_2/Z1 divider_0/tspc_2/Z4 0.00fF
C589 divbuf_3/OUT2 divbuf_3/a_492_n240# 0.42fF
C590 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/tspc_r_1/Z1 0.71fF
C591 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_0/Z3 0.11fF
C592 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z4 0.36fF
C593 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/B 0.18fF
C594 divider_1/tspc_2/Z1 divider_1/tspc_2/Z3 0.06fF
C595 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/nor_1/Z1 0.18fF
C596 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/clk 0.60fF
C597 divider_2/tspc_1/Z2 divider_2/tspc_1/Z4 0.36fF
C598 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/D 0.05fF
C599 divbuf_23/OUT2 divbuf_23/OUT3 1.37fF
C600 divbuf_15/OUT divbuf_15/OUT3 0.26fF
C601 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z4 0.36fF
C602 divbuf_2/OUT3 divbuf_2/OUT4 5.16fF
C603 divbuf_7/OUT ro_complete_0/cbank_1/v 0.05fF
C604 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 pll_full_1/divider_0/clk 0.12fF
C605 ro_complete_1/a3 ro_complete_1/cbank_2/v 0.05fF
C606 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_0/B 0.06fF
C607 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/ro_complete_0/cbank_2/v 0.04fF
C608 divbuf_10/OUT3 divbuf_10/OUT4 5.16fF
C609 divbuf_10/OUT2 divbuf_10/OUT5 0.02fF
C610 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C611 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C612 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C613 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C614 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z3 0.16fF
C615 divbuf_22/a_492_n240# divbuf_22/OUT2 0.42fF
C616 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Q 0.04fF
C617 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/a4 0.12fF
C618 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_1/Z4 0.02fF
C619 pd_1/tspc_r_0/z5 pd_1/tspc_r_1/z5 0.02fF
C620 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Qbar1 0.38fF
C621 divider_2/tspc_1/Z4 divider_2/nor_0/A 0.02fF
C622 divbuf_9/OUT5 divbuf_9/OUT 43.38fF
C623 divbuf_0/OUT3 divbuf_0/OUT5 0.01fF
C624 pll_full_0/pd_0/UP pll_full_0/pd_0/tspc_r_1/z5 0.03fF
C625 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/Out 0.21fF
C626 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z2 0.01fF
C627 divbuf_3/OUT divbuf_3/OUT4 1.11fF
C628 ro_complete_1/a4 ro_complete_1/cbank_1/switch_1/vin 0.09fF
C629 ro_complete_0/cbank_2/switch_0/vin ro_complete_0/cbank_2/v 1.45fF
C630 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT3 0.01fF
C631 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT2 0.06fF
C632 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C633 divider_1/nor_1/Z1 divider_1/nor_0/B 0.18fF
C634 divbuf_4/OUT3 divbuf_4/OUT5 0.01fF
C635 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/and_0/B 0.29fF
C636 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/z5 0.04fF
C637 pll_full_1/divbuf_0/IN pll_full_1/divbuf_0/a_492_n240# 0.13fF
C638 divbuf_8/IN divbuf_8/OUT5 0.00fF
C639 divider_2/mc2 divider_2/and_0/OUT 0.05fF
C640 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z4 0.00fF
C641 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/D 0.03fF
C642 pll_full_1/divbuf_1/OUT3 pll_full_1/divbuf_1/OUT 0.26fF
C643 pll_full_1/divbuf_1/OUT4 pll_full_1/divbuf_1/OUT5 20.26fF
C644 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Z1 0.02fF
C645 divider_2/tspc_2/Z1 divider_2/tspc_2/Z2 1.07fF
C646 divider_2/nor_0/A divider_2/tspc_2/Z3 0.38fF
C647 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z4 0.12fF
C648 divbuf_24/a_492_n240# divbuf_24/IN 0.13fF
C649 divbuf_4/OUT ro_complete_0/cbank_1/switch_0/vin 0.12fF
C650 pll_full_1/ro_complete_0/cbank_2/switch_0/vin pll_full_1/ro_complete_0/cbank_2/v 1.45fF
C651 divbuf_5/OUT ro_complete_0/cbank_2/switch_2/vin 0.14fF
C652 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/v 1.30fF
C653 pll_full_1/pd_0/REF pll_full_1/divbuf_1/a_492_n240# 0.13fF
C654 divider_0/mc2 divider_0/and_0/OUT 0.05fF
C655 divider_0/tspc_0/Z1 divider_0/nor_1/B 0.03fF
C656 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C657 pll_full_1/ro_complete_0/cbank_2/v pll_full_1/divider_0/clk 1.36fF
C658 ro_complete_1/a3 ro_complete_1/cbank_1/switch_2/vin 0.09fF
C659 pll_full_1/cp_0/upbar pll_full_1/cp_0/down 0.02fF
C660 divider_1/tspc_1/Q divider_1/tspc_0/Z3 0.45fF
C661 divider_1/tspc_0/a_630_n680# divider_1/tspc_0/Z4 0.12fF
C662 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z4 0.28fF
C663 divbuf_5/OUT3 divbuf_5/OUT5 0.01fF
C664 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/clk 0.12fF
C665 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/Z2 1.07fF
C666 divider_1/and_0/OUT divider_1/and_0/B 0.01fF
C667 pd_0/UP pd_0/tspc_r_1/z5 0.03fF
C668 divider_2/tspc_1/Z1 divider_2/tspc_1/Z4 0.00fF
C669 divider_2/tspc_1/Q divider_2/tspc_1/Z3 0.05fF
C670 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z3 0.06fF
C671 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C672 pll_full_1/ro_complete_0/cbank_0/switch_2/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C673 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C674 ro_complete_1/a2 ro_complete_1/cbank_2/switch_3/vin 0.09fF
C675 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/cbank_0/v 1.30fF
C676 divbuf_3/OUT ro_complete_0/cbank_1/v 0.05fF
C677 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/a_492_n240# 0.00fF
C678 divbuf_15/OUT divbuf_15/a_492_n240# 0.00fF
C679 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/D 0.09fF
C680 divbuf_1/OUT4 divbuf_1/OUT3 5.16fF
C681 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/switch_5/vin 0.20fF
C682 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_0/Z2 1.07fF
C683 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_0/Z3 0.38fF
C684 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Z4 0.12fF
C685 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/DOWN 0.03fF
C686 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z1 0.08fF
C687 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Q 0.91fF
C688 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/a_630_n680# 0.19fF
C689 divbuf_11/OUT3 divbuf_11/OUT4 5.16fF
C690 divbuf_11/OUT2 divbuf_11/OUT5 0.02fF
C691 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z4 0.36fF
C692 divbuf_19/OUT2 divbuf_19/OUT3 1.37fF
C693 divbuf_9/a_492_n240# divbuf_9/OUT2 0.42fF
C694 pd_1/DOWN pd_1/tspc_r_1/Qbar 0.02fF
C695 pd_1/R pd_1/UP 0.45fF
C696 divbuf_18/OUT4 divbuf_18/OUT 1.11fF
C697 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/Q 0.04fF
C698 divider_2/prescaler_0/tspc_1/Z3 divider_2/clk 0.45fF
C699 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/OUT2 0.02fF
C700 divbuf_0/OUT divbuf_0/OUT4 1.11fF
C701 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Qbar1 0.38fF
C702 divider_0/tspc_0/Z1 divider_0/tspc_0/Z2 1.07fF
C703 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C704 pll_full_1/ro_complete_0/cbank_1/switch_2/vin pll_full_1/divider_0/clk 1.46fF
C705 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT5 0.01fF
C706 divbuf_14/IN divbuf_14/OUT5 0.00fF
C707 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/clk 0.05fF
C708 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Z1 0.03fF
C709 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_1/Z3 0.05fF
C710 pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_0/ro_complete_0/cbank_2/v 1.45fF
C711 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/tspc_r_1/Z3 0.38fF
C712 pll_full_1/pd_0/DIV pll_full_1/pd_0/R 0.51fF
C713 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/nor_0/A 0.15fF
C714 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C715 pll_full_0/ro_complete_0/cbank_2/v pll_full_0/divider_0/clk 1.36fF
C716 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/Qbar 0.01fF
C717 pd_0/tspc_r_0/Z3 pd_0/R 0.27fF
C718 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/a3 0.13fF
C719 divbuf_13/IN divbuf_13/OUT5 0.00fF
C720 cp_0/a_1710_0# cp_0/out 0.84fF
C721 pd_1/tspc_r_1/Z2 pd_1/tspc_r_1/Z4 0.14fF
C722 io_clamp_low[1] io_clamp_high[1] 0.53fF
C723 divbuf_5/OUT divbuf_6/OUT 3.23fF
C724 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C725 divider_0/prescaler_0/Out divider_0/prescaler_0/m1_2700_2190# 0.11fF
C726 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/nand_0/z1 0.07fF
C727 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.05fF
C728 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C729 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/v 1.30fF
C730 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C731 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C732 divider_1/mc2 divider_1/nor_1/B 0.15fF
C733 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C734 divbuf_5/a_492_n240# divbuf_5/OUT2 0.42fF
C735 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/and_0/B 0.31fF
C736 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_1/Q 0.01fF
C737 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C738 divider_1/prescaler_0/tspc_0/D divider_1/prescaler_0/nand_1/z1 0.21fF
C739 divbuf_21/OUT3 divbuf_21/OUT5 0.01fF
C740 divbuf_21/OUT2 divbuf_21/OUT 0.06fF
C741 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Qbar1 0.38fF
C742 divider_2/prescaler_0/m1_2700_2190# divider_2/and_0/OUT 0.14fF
C743 pll_full_1/ro_complete_0/cbank_2/switch_5/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C744 divbuf_2/OUT divbuf_2/OUT3 0.26fF
C745 divider_0/nor_0/B divider_0/nor_1/B 0.47fF
C746 divider_0/tspc_0/Z3 divider_0/tspc_0/Z4 0.65fF
C747 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.05fF
C748 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/clk 0.01fF
C749 divbuf_6/OUT divbuf_6/OUT3 0.26fF
C750 ro_complete_1/a5 ro_complete_1/cbank_1/v 0.10fF
C751 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/cbank_0/v 1.30fF
C752 divbuf_14/OUT5 divbuf_14/OUT4 20.26fF
C753 divider_0/tspc_2/Z3 divider_0/tspc_2/Z4 0.65fF
C754 divider_1/tspc_1/Q divider_1/tspc_0/Z4 0.15fF
C755 divbuf_6/a_492_n240# divbuf_6/OUT5 0.01fF
C756 pll_full_1/divider_0/and_0/A pll_full_1/divider_0/and_0/B 0.18fF
C757 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/DOWN 0.03fF
C758 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divbuf_0/IN 0.05fF
C759 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C760 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/A 0.80fF
C761 pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_0/divider_0/clk 1.46fF
C762 divbuf_19/IN divbuf_19/a_492_n240# 0.13fF
C763 divider_1/tspc_2/Z1 divider_1/tspc_2/Z4 0.00fF
C764 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/Z1 0.04fF
C765 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/clk 0.05fF
C766 divbuf_23/OUT3 divbuf_23/OUT4 5.16fF
C767 divbuf_23/OUT2 divbuf_23/OUT5 0.02fF
C768 pd_1/DOWN pd_1/tspc_r_0/Qbar1 0.11fF
C769 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Z1 0.02fF
C770 divider_2/prescaler_0/tspc_2/Z4 divider_2/prescaler_0/tspc_2/D 0.11fF
C771 pll_full_1/pd_0/UP pll_full_1/pd_0/tspc_r_1/Qbar 0.21fF
C772 divbuf_2/OUT4 divbuf_2/OUT5 20.26fF
C773 divbuf_14/OUT2 divbuf_14/OUT5 0.02fF
C774 divider_0/nor_0/B divider_0/tspc_2/a_630_n680# 0.01fF
C775 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/tspc_r_1/Z3 0.25fF
C776 divider_1/nor_0/Z1 divider_1/nor_0/B 0.06fF
C777 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z4 0.36fF
C778 divbuf_10/OUT3 divbuf_10/OUT 0.26fF
C779 divbuf_10/OUT4 divbuf_10/OUT5 20.26fF
C780 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/DIV 0.19fF
C781 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C782 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C783 pd_1/DOWN pd_1/and_pd_0/Z1 0.07fF
C784 pd_1/REF pd_1/tspc_r_1/Z1 0.17fF
C785 pd_1/tspc_r_1/Qbar1 pd_1/UP 0.11fF
C786 divider_2/prescaler_0/tspc_2/Z3 divider_2/clk 0.45fF
C787 divider_0/tspc_0/Z2 divider_0/nor_0/B 0.20fF
C788 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/Out 0.04fF
C789 divbuf_0/OUT4 divbuf_0/OUT5 20.26fF
C790 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C791 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/and_0/OUT 0.06fF
C792 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/tspc_r_1/Z4 0.14fF
C793 divbuf_4/OUT divbuf_4/OUT2 0.06fF
C794 ro_complete_1/a2 ro_complete_1/cbank_1/v 0.05fF
C795 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT4 1.11fF
C796 pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C797 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/Out 0.21fF
C798 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z2 0.01fF
C799 divider_2/nor_1/Z1 divider_2/nor_1/B 0.06fF
C800 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C801 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/clk 0.01fF
C802 divbuf_18/OUT3 divbuf_18/OUT4 5.16fF
C803 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Z4 0.65fF
C804 divbuf_8/OUT3 divbuf_8/OUT5 0.01fF
C805 divbuf_8/OUT2 divbuf_8/OUT 0.06fF
C806 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C807 divider_2/nor_0/A divider_2/tspc_2/Z4 0.21fF
C808 divider_2/tspc_2/Z2 divider_2/tspc_2/Z3 0.16fF
C809 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C810 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_5/vin 0.20fF
C811 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C812 ro_complete_1/a3 ro_complete_1/cbank_2/switch_1/vin 0.13fF
C813 divider_1/tspc_0/Z1 divider_1/nor_1/B 0.03fF
C814 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/and_0/B 0.08fF
C815 divbuf_7/a_492_n240# divbuf_7/OUT5 0.01fF
C816 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z3 0.25fF
C817 pd_0/tspc_r_1/Z2 pd_0/tspc_r_1/Z4 0.14fF
C818 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z4 0.00fF
C819 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Q 0.21fF
C820 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C821 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C822 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C823 divbuf_19/OUT3 divbuf_19/OUT4 5.16fF
C824 divider_2/and_0/B divider_2/and_0/Z1 0.07fF
C825 ro_complete_1/a2 ro_complete_1/cbank_0/switch_2/vin 0.14fF
C826 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/a4 0.09fF
C827 divbuf_0/OUT5 divbuf_0/IN 0.00fF
C828 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_0/vin 0.19fF
C829 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/v 1.30fF
C830 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.19fF
C831 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/clk 0.01fF
C832 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/v 1.30fF
C833 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_0/Z4 0.22fF
C834 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/tspc_0/Z3 0.16fF
C835 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C836 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z3 0.11fF
C837 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/D 0.09fF
C838 divbuf_11/OUT3 divbuf_11/OUT 0.26fF
C839 divbuf_11/OUT4 divbuf_11/OUT5 20.26fF
C840 cp_0/a_1710_n2840# cp_0/a_1710_0# 0.83fF
C841 divider_2/prescaler_0/tspc_1/Z4 divider_2/clk 0.12fF
C842 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C843 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C844 divbuf_0/OUT divbuf_0/OUT5 43.38fF
C845 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C846 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C847 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C848 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z1 0.17fF
C849 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/UP 0.11fF
C850 divider_0/tspc_2/Q divider_0/tspc_2/a_630_n680# 0.04fF
C851 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/D 0.03fF
C852 divbuf_1/OUT5 divbuf_1/IN 0.00fF
C853 pll_full_1/divider_0/prescaler_0/tspc_0/D pll_full_1/divider_0/clk 0.29fF
C854 pll_full_0/divbuf_0/OUT4 pll_full_0/divbuf_0/OUT5 20.26fF
C855 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C856 divbuf_4/a_492_n240# divbuf_4/IN 0.13fF
C857 ro_complete_1/cbank_2/switch_2/vin ro_complete_1/cbank_2/v 1.30fF
C858 pll_full_1/divbuf_1/a_492_n240# pll_full_1/divbuf_1/OUT2 0.42fF
C859 divider_1/tspc_0/Z1 divider_1/tspc_0/Z2 1.07fF
C860 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z2 1.07fF
C861 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Z3 0.38fF
C862 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_1/Z4 0.12fF
C863 divbuf_20/a_492_n240# divbuf_20/OUT 0.00fF
C864 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_0/Qbar 0.21fF
C865 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z2 0.11fF
C866 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C867 divbuf_16/OUT2 divbuf_16/OUT 0.06fF
C868 pd_1/DIV pd_1/tspc_r_0/Z2 0.19fF
C869 pd_0/DOWN pd_0/R 0.36fF
C870 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z4 0.20fF
C871 pd_0/DIV pd_0/tspc_r_0/z5 0.04fF
C872 pd_0/tspc_r_0/Z1 pd_0/tspc_r_0/Z2 0.71fF
C873 divider_2/prescaler_0/tspc_0/Z2 divider_2/and_0/OUT 0.06fF
C874 cp_0/a_1710_0# cp_0/down 0.32fF
C875 divider_2/prescaler_0/tspc_1/Q divider_2/clk 0.60fF
C876 divbuf_13/OUT3 divbuf_13/OUT5 0.01fF
C877 divbuf_13/OUT2 divbuf_13/OUT 0.06fF
C878 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_4/vin 0.20fF
C879 divider_0/nor_0/B divider_0/tspc_1/Z1 0.03fF
C880 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/and_0/OUT 0.06fF
C881 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C882 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.38fF
C883 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.11fF
C884 divider_0/prescaler_0/tspc_1/Q divider_0/nor_0/A 0.03fF
C885 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C886 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z3 0.06fF
C887 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C888 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C889 divider_1/prescaler_0/Out divider_1/prescaler_0/m1_2700_2190# 0.11fF
C890 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z1 0.03fF
C891 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z3 0.05fF
C892 divbuf_21/OUT4 divbuf_21/OUT 1.11fF
C893 pll_full_1/pd_0/DOWN pll_full_1/cp_0/a_1710_0# 0.04fF
C894 pll_full_1/pd_0/DIV pll_full_1/pd_0/tspc_r_0/Z4 0.02fF
C895 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C896 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/clk 0.01fF
C897 divider_2/prescaler_0/Out divider_2/clk 0.51fF
C898 pd_0/tspc_r_0/Z4 pd_0/tspc_r_1/Z4 0.02fF
C899 pd_0/DOWN pd_0/and_pd_0/Out1 0.12fF
C900 pd_0/REF pd_0/tspc_r_1/Z1 0.17fF
C901 pd_0/tspc_r_1/Qbar1 pd_0/UP 0.11fF
C902 divider_2/nor_1/B divider_2/tspc_0/Z1 0.03fF
C903 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_2/D 0.16fF
C904 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/clk 0.01fF
C905 divbuf_12/a_492_n240# divbuf_12/OUT5 0.01fF
C906 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/a_492_n240# 0.01fF
C907 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C908 divbuf_2/OUT divbuf_2/OUT5 43.38fF
C909 divbuf_4/OUT ro_complete_0/cbank_1/v 0.05fF
C910 divider_0/nor_0/B divider_0/tspc_1/Z2 0.30fF
C911 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C912 divider_1/mc2 divider_1/nor_0/A 0.04fF
C913 divbuf_14/OUT5 divbuf_14/OUT3 0.01fF
C914 divbuf_6/OUT divbuf_6/OUT5 43.38fF
C915 divbuf_3/IN divbuf_3/OUT5 0.00fF
C916 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C917 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C918 divbuf_6/OUT2 divbuf_6/OUT3 1.37fF
C919 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Q 0.22fF
C920 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/nor_1/B 0.35fF
C921 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C922 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C923 divider_1/nor_0/B divider_1/nor_1/B 0.47fF
C924 divider_1/tspc_0/Z3 divider_1/tspc_0/Z4 0.65fF
C925 divider_1/nor_0/Z1 divider_1/and_0/A 0.80fF
C926 filter_0/v divbuf_25/OUT5 43.38fF
C927 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/nor_0/A 0.35fF
C928 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/clk 0.29fF
C929 divbuf_16/OUT divbuf_16/OUT5 43.38fF
C930 divider_1/tspc_2/Z3 divider_1/tspc_2/Z4 0.65fF
C931 divbuf_23/OUT3 divbuf_23/OUT 0.26fF
C932 divbuf_23/OUT4 divbuf_23/OUT5 20.26fF
C933 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/z5 0.04fF
C934 divbuf_18/OUT5 divbuf_18/OUT4 20.26fF
C935 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z3 0.29fF
C936 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/divider_0/clk 1.46fF
C937 divbuf_0/a_492_n240# divbuf_0/IN 0.13fF
C938 divbuf_25/OUT4 divbuf_25/OUT5 20.26fF
C939 divider_0/prescaler_0/Out divider_0/tspc_2/Z3 0.45fF
C940 divider_0/nor_0/B divider_0/nor_0/A 1.21fF
C941 divider_2/tspc_0/Z4 divider_2/nor_1/B 0.22fF
C942 ro_complete_1/a1 ro_complete_1/cbank_2/v 0.05fF
C943 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/nor_0/B 0.02fF
C944 divbuf_10/OUT5 divbuf_10/OUT 43.38fF
C945 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_1/B 0.00fF
C946 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C947 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C948 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C949 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C950 divbuf_16/OUT3 divbuf_16/OUT 0.26fF
C951 divider_1/nor_0/B divider_1/tspc_2/a_630_n680# 0.01fF
C952 divbuf_22/a_492_n240# divbuf_22/OUT 0.00fF
C953 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/a4 0.09fF
C954 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/a5 0.09fF
C955 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/A 0.01fF
C956 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z2 0.25fF
C957 divider_2/prescaler_0/tspc_2/Z4 divider_2/clk 0.12fF
C958 pll_full_1/divbuf_0/a_492_n240# pll_full_1/divbuf_0/OUT2 0.42fF
C959 divbuf_0/OUT3 divbuf_0/OUT2 1.37fF
C960 divbuf_0/OUT divbuf_0/a_492_n240# 0.00fF
C961 divider_0/tspc_0/Z1 divider_0/tspc_1/Q 0.01fF
C962 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z3 0.06fF
C963 divbuf_4/OUT divbuf_4/OUT4 1.11fF
C964 pll_full_1/pd_0/tspc_r_0/Z1 pll_full_1/pd_0/tspc_r_0/Z2 0.71fF
C965 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT2 0.42fF
C966 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C967 divider_1/tspc_0/Z2 divider_1/nor_0/B 0.20fF
C968 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/Out 0.04fF
C969 divbuf_21/a_492_n240# divbuf_21/IN 0.13fF
C970 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/nor_0/Z1 0.06fF
C971 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C972 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/A 0.26fF
C973 divbuf_8/OUT4 divbuf_8/OUT 1.11fF
C974 pd_0/R pd_0/tspc_r_1/Z3 0.29fF
C975 pll_full_1/divbuf_0/OUT4 pll_full_1/divbuf_0/OUT3 5.16fF
C976 divbuf_24/a_492_n240# divbuf_24/OUT5 0.01fF
C977 divider_2/tspc_2/Z2 divider_2/tspc_2/Z4 0.36fF
C978 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a4 0.12fF
C979 divbuf_2/OUT ro_complete_0/cbank_1/switch_0/vin 0.09fF
C980 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/v 1.30fF
C981 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/IN 5.26fF
C982 divider_0/tspc_1/Z1 divider_0/tspc_2/Q 0.01fF
C983 divider_0/nor_0/B divider_0/tspc_1/a_630_n680# 0.35fF
C984 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/and_0/OUT 0.05fF
C985 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/clk 0.14fF
C986 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C987 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z4 0.00fF
C988 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/divider_0/clk 1.46fF
C989 divbuf_7/OUT2 divbuf_7/OUT3 1.37fF
C990 pll_full_1/divider_0/and_0/A pll_full_1/divider_0/nor_0/Z1 0.80fF
C991 pll_full_1/pd_0/R pll_full_1/pd_0/tspc_r_1/Z3 0.29fF
C992 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/B 0.29fF
C993 pd_1/tspc_r_0/Qbar pd_1/tspc_r_0/Qbar1 0.01fF
C994 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C995 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C996 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Z4 0.65fF
C997 pll_full_1/divider_0/and_0/Z1 pll_full_1/divider_0/and_0/OUT 0.04fF
C998 divbuf_15/OUT4 divbuf_15/OUT5 20.26fF
C999 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1000 divbuf_6/OUT ro_complete_0/cbank_1/v 0.05fF
C1001 divbuf_25/OUT3 divbuf_25/OUT2 1.37fF
C1002 divider_0/nor_0/Z1 divider_0/and_0/B 0.18fF
C1003 divider_0/tspc_2/Q divider_0/tspc_1/Z2 0.14fF
C1004 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z2 0.01fF
C1005 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/tspc_0/D 0.32fF
C1006 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C1007 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/cbank_1/v 1.43fF
C1008 divider_1/mc2 divider_1/and_0/B 0.20fF
C1009 divider_0/and_0/out1 divider_0/and_0/B 0.18fF
C1010 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/tspc_0/Z4 0.36fF
C1011 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divbuf_0/IN 0.05fF
C1012 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z4 0.28fF
C1013 divbuf_10/a_492_n240# divbuf_10/OUT2 0.42fF
C1014 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/R 0.27fF
C1015 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z2 1.07fF
C1016 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z3 0.38fF
C1017 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_1/B 0.22fF
C1018 divbuf_11/OUT5 divbuf_11/OUT 43.38fF
C1019 divbuf_9/a_492_n240# divbuf_9/OUT 0.00fF
C1020 pd_1/R pd_1/tspc_r_1/Qbar 0.03fF
C1021 divbuf_5/OUT ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1022 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/tspc_r_1/z5 0.02fF
C1023 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z2 0.25fF
C1024 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1025 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C1026 pll_full_1/ro_complete_0/cbank_1/switch_4/vin pll_full_1/divider_0/clk 1.46fF
C1027 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C1028 pll_full_1/pd_0/UP pll_full_1/pd_0/and_pd_0/Out1 0.33fF
C1029 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT2 1.37fF
C1030 divbuf_14/OUT divbuf_14/a_492_n240# 0.00fF
C1031 divider_0/nor_0/B divider_0/and_0/B 0.31fF
C1032 divider_0/tspc_2/Q divider_0/nor_0/A 0.55fF
C1033 divider_0/and_0/OUT divider_0/prescaler_0/nand_0/z1 0.01fF
C1034 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/switch_5/vin 0.20fF
C1035 divider_2/tspc_0/Z4 divider_2/tspc_0/Z1 0.00fF
C1036 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Z4 0.21fF
C1037 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/Z3 0.16fF
C1038 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Q 0.91fF
C1039 divider_1/tspc_2/Q divider_1/tspc_2/a_630_n680# 0.04fF
C1040 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/D 0.03fF
C1041 divbuf_20/IN divbuf_20/OUT5 0.00fF
C1042 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/and_0/OUT 0.05fF
C1043 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/z5 0.20fF
C1044 divbuf_8/a_492_n240# divbuf_8/IN 0.13fF
C1045 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1046 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1047 divider_2/tspc_0/Z3 divider_2/nor_1/B 0.38fF
C1048 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z3 0.33fF
C1049 divbuf_13/OUT4 divbuf_13/OUT 1.11fF
C1050 pd_1/UP pd_1/and_pd_0/Out1 0.33fF
C1051 io_clamp_low[0] io_clamp_high[0] 0.53fF
C1052 divbuf_18/OUT divbuf_18/a_492_n240# 0.00fF
C1053 divider_2/and_0/OUT divider_2/and_0/Z1 0.04fF
C1054 divider_2/prescaler_0/tspc_2/Q divider_2/clk 0.05fF
C1055 divbuf_4/OUT divbuf_3/OUT 2.71fF
C1056 divider_0/nor_0/B divider_0/tspc_1/Q 0.51fF
C1057 divbuf_0/OUT5 divbuf_0/a_492_n240# 0.01fF
C1058 pll_full_1/pd_0/UP pll_full_1/pd_0/and_pd_0/Z1 0.06fF
C1059 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1060 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1061 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.04fF
C1062 divbuf_1/OUT5 divbuf_1/OUT3 0.01fF
C1063 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C1064 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1065 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z4 0.65fF
C1066 divider_0/and_0/OUT divider_0/clk 0.04fF
C1067 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_0/a_630_n680# 0.04fF
C1068 divider_1/nor_0/B divider_1/tspc_1/Z1 0.03fF
C1069 pll_full_1/divbuf_0/IN pll_full_1/pd_0/DIV 5.26fF
C1070 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z2 1.07fF
C1071 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z3 0.38fF
C1072 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z4 0.12fF
C1073 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_1/z5 0.02fF
C1074 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1075 divider_1/prescaler_0/tspc_1/Q divider_1/nor_0/A 0.03fF
C1076 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_0/A 0.15fF
C1077 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C1078 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C1079 pd_1/tspc_r_0/Qbar pd_1/DOWN 0.21fF
C1080 pd_0/tspc_r_0/z5 pd_0/tspc_r_1/z5 0.02fF
C1081 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z2 0.25fF
C1082 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/nand_0/z1 0.07fF
C1083 divbuf_12/OUT2 divbuf_12/OUT3 1.37fF
C1084 pll_full_0/pd_0/DOWN pll_full_0/pd_0/UP 4.58fF
C1085 divbuf_6/OUT divbuf_7/OUT 2.98fF
C1086 divider_0/tspc_1/Z1 divider_0/tspc_1/Z3 0.06fF
C1087 divider_0/tspc_2/Q divider_0/tspc_1/a_630_n680# 0.01fF
C1088 divbuf_3/OUT ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1089 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C1090 divider_0/nor_0/A divider_0/and_0/A 0.01fF
C1091 divbuf_6/OUT3 divbuf_6/OUT4 5.16fF
C1092 divbuf_6/OUT2 divbuf_6/OUT5 0.02fF
C1093 divider_1/nor_0/B divider_1/tspc_1/Z2 0.30fF
C1094 pll_full_1/divider_0/and_0/B pll_full_1/divider_0/and_0/Z1 0.07fF
C1095 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/R 0.30fF
C1096 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Z2 0.25fF
C1097 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1098 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C1099 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/divider_0/clk 1.46fF
C1100 divbuf_17/a_492_n240# divbuf_17/OUT5 0.01fF
C1101 divbuf_16/OUT divbuf_16/OUT4 1.11fF
C1102 divbuf_11/a_492_n240# divbuf_11/OUT2 0.42fF
C1103 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z2 0.01fF
C1104 pd_1/R pd_1/tspc_r_0/Qbar1 0.01fF
C1105 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Q 0.05fF
C1106 divider_2/prescaler_0/m1_2700_2190# divider_2/clk 0.01fF
C1107 divbuf_23/OUT5 divbuf_23/OUT 43.38fF
C1108 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1109 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C1110 pll_full_0/pd_0/R pll_full_0/pd_0/UP 0.46fF
C1111 divider_0/prescaler_0/m1_2700_2190# divider_0/nor_0/A 0.01fF
C1112 divider_0/prescaler_0/Out divider_0/tspc_2/Z4 0.12fF
C1113 divider_0/tspc_1/Z2 divider_0/tspc_1/Z3 0.16fF
C1114 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/D 0.15fF
C1115 divbuf_3/OUT divbuf_3/OUT2 0.06fF
C1116 divbuf_2/OUT2 divbuf_2/a_492_n240# 0.42fF
C1117 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C1118 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/v 1.30fF
C1119 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1120 ro_complete_1/cbank_1/switch_5/vin ro_complete_1/cbank_1/v 1.30fF
C1121 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z4 0.01fF
C1122 divbuf_19/OUT2 divbuf_19/OUT5 0.02fF
C1123 divider_1/prescaler_0/Out divider_1/tspc_2/Z3 0.45fF
C1124 divider_1/nor_0/B divider_1/nor_0/A 1.21fF
C1125 pll_full_1/pd_0/DOWN pll_full_1/pd_0/R 0.36fF
C1126 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z2 0.01fF
C1127 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z3 0.45fF
C1128 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1129 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1130 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C1131 pd_0/DIV pd_0/tspc_r_0/Qbar1 0.12fF
C1132 divider_2/nor_0/Z1 divider_2/nor_0/B 0.06fF
C1133 divbuf_22/IN divbuf_22/OUT5 0.00fF
C1134 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/z5 0.11fF
C1135 pd_1/R pd_1/and_pd_0/Z1 0.02fF
C1136 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/Qbar 0.01fF
C1137 divbuf_13/a_492_n240# divbuf_13/IN 0.13fF
C1138 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C1139 divider_0/tspc_0/Z1 divider_0/tspc_0/Z3 0.06fF
C1140 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1141 divbuf_1/OUT2 divbuf_1/OUT5 0.02fF
C1142 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1143 pll_full_0/pd_0/UP pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C1144 divbuf_25/a_492_n240# divbuf_25/OUT5 0.01fF
C1145 divbuf_5/OUT divbuf_5/OUT2 0.06fF
C1146 io_clamp_high[2] io_analog[6] 0.53fF
C1147 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/a_492_n240# 0.01fF
C1148 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_0/Z4 0.04fF
C1149 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Q 0.15fF
C1150 divider_1/tspc_0/Z1 divider_1/tspc_1/Q 0.01fF
C1151 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z3 0.06fF
C1152 pll_full_1/divider_0/tspc_1/Z4 pll_full_1/divider_0/nor_0/A 0.02fF
C1153 pd_0/R pd_0/UP 0.45fF
C1154 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z3 0.65fF
C1155 divbuf_17/a_492_n240# divbuf_17/OUT 0.00fF
C1156 divider_2/tspc_2/Q divider_2/tspc_2/a_630_n680# 0.04fF
C1157 divider_2/tspc_0/Z3 divider_2/tspc_0/Z1 0.06fF
C1158 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/OUT3 0.01fF
C1159 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1160 divbuf_24/OUT2 divbuf_24/OUT3 1.37fF
C1161 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/Out 0.21fF
C1162 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z3 0.06fF
C1163 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.20fF
C1164 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.09fF
C1165 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/clk 0.11fF
C1166 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/a_630_n680# 0.19fF
C1167 divbuf_25/IN divbuf_25/OUT5 0.00fF
C1168 divider_0/nor_0/A divider_0/tspc_2/Z1 0.03fF
C1169 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z3 0.05fF
C1170 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/R 0.21fF
C1171 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1172 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C1173 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_1/B 0.06fF
C1174 divider_1/tspc_1/Z1 divider_1/tspc_2/Q 0.01fF
C1175 divider_1/nor_0/B divider_1/tspc_1/a_630_n680# 0.35fF
C1176 divbuf_7/OUT3 divbuf_7/OUT4 5.16fF
C1177 divbuf_7/OUT2 divbuf_7/OUT5 0.02fF
C1178 pll_full_1/divbuf_1/OUT2 pll_full_1/divbuf_1/OUT3 1.37fF
C1179 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT4 1.11fF
C1180 pd_1/DOWN pd_1/R 0.36fF
C1181 pd_0/UP pd_0/and_pd_0/Out1 0.33fF
C1182 divider_2/mc2 divider_2/and_0/out1 0.06fF
C1183 divider_2/nor_0/Z1 divider_2/and_0/A 0.80fF
C1184 divbuf_23/a_492_n240# divbuf_23/OUT2 0.42fF
C1185 divbuf_15/OUT5 divbuf_15/OUT 43.38fF
C1186 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C1187 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/Out 0.05fF
C1188 pll_full_1/ro_complete_0/a2 pll_full_1/divider_0/clk 0.11fF
C1189 divider_0/mc2 divider_0/and_0/out1 0.06fF
C1190 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z3 0.05fF
C1191 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/nand_1/z1 0.22fF
C1192 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/prescaler_0/tspc_0/D 0.04fF
C1193 divider_2/tspc_0/Z4 divider_2/tspc_0/Z3 0.65fF
C1194 divider_0/and_0/A divider_0/and_0/B 0.18fF
C1195 divbuf_3/a_492_n240# divbuf_3/OUT5 0.01fF
C1196 ro_complete_1/a0 ro_complete_1/cbank_1/switch_5/vin 0.09fF
C1197 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1198 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z4 0.21fF
C1199 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/nor_1/B 0.38fF
C1200 divider_1/tspc_2/Q divider_1/tspc_1/Z2 0.14fF
C1201 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z2 0.01fF
C1202 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/B 0.08fF
C1203 divider_2/nor_1/Z1 divider_2/and_0/B 0.78fF
C1204 divider_1/and_0/out1 divider_1/and_0/B 0.18fF
C1205 pll_full_0/pd_0/DIV pll_full_0/pd_0/R 0.51fF
C1206 divbuf_17/OUT5 divbuf_17/OUT 43.38fF
C1207 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_2/Q 0.19fF
C1208 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/clk 0.01fF
C1209 divider_2/nor_1/B divider_2/and_0/B 0.29fF
C1210 divbuf_9/IN divbuf_9/OUT5 0.00fF
C1211 pll_full_1/divbuf_0/OUT3 pll_full_1/divbuf_0/OUT2 1.37fF
C1212 divbuf_0/OUT divbuf_0/OUT2 0.06fF
C1213 ro_complete_0/cbank_0/switch_0/vin divbuf_4/OUT 0.12fF
C1214 divbuf_5/OUT ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1215 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Qbar 0.01fF
C1216 divider_0/mc2 divider_0/nor_0/B 0.06fF
C1217 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C1218 pll_full_1/ro_complete_0/cbank_1/switch_0/vin pll_full_1/divider_0/clk 1.58fF
C1219 divider_0/prescaler_0/tspc_2/D divider_0/prescaler_0/nand_0/z1 0.24fF
C1220 ro_complete_1/a2 ro_complete_1/cbank_2/switch_2/vin 0.14fF
C1221 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1222 divbuf_4/a_492_n240# divbuf_4/OUT5 0.01fF
C1223 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/v 1.30fF
C1224 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/Z4 0.36fF
C1225 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z2 1.07fF
C1226 divbuf_20/OUT3 divbuf_20/OUT5 0.01fF
C1227 divbuf_20/OUT2 divbuf_20/OUT 0.06fF
C1228 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/tspc_r_1/z5 0.20fF
C1229 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Z4 0.20fF
C1230 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C1231 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C1232 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/clk 0.11fF
C1233 divider_1/nor_0/B divider_1/and_0/B 0.31fF
C1234 divider_1/tspc_2/Q divider_1/nor_0/A 0.55fF
C1235 divider_1/and_0/OUT divider_1/prescaler_0/nand_0/z1 0.01fF
C1236 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1237 divider_2/tspc_0/Z2 divider_2/nor_0/B 0.20fF
C1238 divider_2/tspc_0/a_630_n680# divider_2/nor_1/B 0.35fF
C1239 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z4 0.08fF
C1240 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z3 0.05fF
C1241 divider_2/tspc_2/a_630_n680# divider_2/nor_0/A 0.35fF
C1242 divider_2/prescaler_0/tspc_0/D divider_2/clk 0.29fF
C1243 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1244 pll_full_0/pd_0/REF pll_full_0/divbuf_1/a_492_n240# 0.13fF
C1245 divider_0/tspc_0/Z1 divider_0/tspc_0/Z4 0.00fF
C1246 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1247 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1248 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1249 divbuf_17/IN divbuf_17/a_492_n240# 0.13fF
C1250 divider_1/mc2 divider_1/and_0/OUT 0.05fF
C1251 divbuf_14/OUT divbuf_14/OUT4 1.11fF
C1252 divider_0/and_0/OUT divider_0/and_0/out1 0.31fF
C1253 divider_0/prescaler_0/tspc_2/D divider_0/clk 0.26fF
C1254 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/switch_0/vin 0.19fF
C1255 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z1 0.06fF
C1256 divider_1/nor_0/B divider_1/tspc_1/Q 0.51fF
C1257 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z4 0.21fF
C1258 pll_full_1/divider_0/tspc_2/Z2 pll_full_1/divider_0/tspc_2/Z3 0.16fF
C1259 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_1/Q 0.01fF
C1260 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C1261 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/Out 0.05fF
C1262 pll_full_0/ro_complete_0/a2 pll_full_0/divider_0/clk 0.11fF
C1263 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C1264 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C1265 divider_1/and_0/OUT divider_1/clk 0.04fF
C1266 divbuf_12/OUT3 divbuf_12/OUT4 5.16fF
C1267 divbuf_12/OUT2 divbuf_12/OUT5 0.02fF
C1268 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/Qbar 0.01fF
C1269 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1270 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Qbar1 0.38fF
C1271 divider_2/prescaler_0/tspc_1/Z2 divider_2/and_0/OUT 0.06fF
C1272 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z3 0.33fF
C1273 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Q 0.38fF
C1274 divider_2/prescaler_0/tspc_0/Z2 divider_2/clk 0.11fF
C1275 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.03fF
C1276 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT3 0.26fF
C1277 divider_2/and_0/out1 divider_2/and_0/A 0.01fF
C1278 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C1279 divbuf_2/OUT ro_complete_0/cbank_1/v 0.10fF
C1280 ro_complete_0/cbank_0/switch_5/vin divbuf_7/OUT 0.09fF
C1281 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT 43.38fF
C1282 divbuf_14/OUT2 divbuf_14/OUT 0.06fF
C1283 divider_0/tspc_1/Z1 divider_0/tspc_1/Z4 0.00fF
C1284 divider_0/tspc_1/Q divider_0/tspc_1/Z3 0.05fF
C1285 divider_0/Out divider_0/nor_1/B 0.22fF
C1286 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/clk 0.11fF
C1287 divbuf_16/a_492_n240# divbuf_16/OUT 0.00fF
C1288 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/Z1 0.01fF
C1289 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/nor_1/B 0.35fF
C1290 divider_2/prescaler_0/Out divider_2/prescaler_0/m1_2700_2190# 0.11fF
C1291 divider_1/tspc_1/Z1 divider_1/tspc_1/Z3 0.06fF
C1292 divider_1/tspc_2/Q divider_1/tspc_1/a_630_n680# 0.01fF
C1293 divbuf_6/OUT4 divbuf_6/OUT5 20.26fF
C1294 pll_full_1/divbuf_1/a_492_n240# pll_full_1/divbuf_1/OUT5 0.01fF
C1295 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.04fF
C1296 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C1297 pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_0/divider_0/clk 1.58fF
C1298 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z2 0.23fF
C1299 divider_1/nor_0/A divider_1/and_0/A 0.01fF
C1300 pd_1/tspc_r_0/z5 pd_1/tspc_r_0/Z3 0.11fF
C1301 pll_full_1/ro_complete_0/cbank_0/switch_5/vin pll_full_1/ro_complete_0/a0 0.09fF
C1302 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/DOWN 0.11fF
C1303 divbuf_19/OUT divbuf_19/OUT3 0.26fF
C1304 divbuf_19/OUT5 divbuf_19/OUT4 20.26fF
C1305 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/clk 0.01fF
C1306 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C1307 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1308 divbuf_1/OUT5 divbuf_1/a_492_n240# 0.01fF
C1309 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a4 0.12fF
C1310 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1311 divider_0/tspc_1/Z2 divider_0/tspc_1/Z4 0.36fF
C1312 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/D 0.05fF
C1313 divider_0/prescaler_0/tspc_0/Z3 divider_0/clk 0.64fF
C1314 divbuf_17/IN divbuf_17/OUT5 0.00fF
C1315 ro_complete_1/cbank_0/v ro_complete_1/cbank_2/v 0.04fF
C1316 divider_1/prescaler_0/m1_2700_2190# divider_1/nor_0/A 0.01fF
C1317 divider_1/prescaler_0/Out divider_1/tspc_2/Z4 0.12fF
C1318 divider_1/tspc_1/Z2 divider_1/tspc_1/Z3 0.16fF
C1319 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/D 0.15fF
C1320 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z4 0.15fF
C1321 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/nor_1/B 0.22fF
C1322 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1323 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1324 pd_0/tspc_r_0/Z3 pd_0/DOWN 0.03fF
C1325 divbuf_22/OUT3 divbuf_22/OUT5 0.01fF
C1326 divbuf_22/OUT2 divbuf_22/OUT 0.06fF
C1327 pll_full_1/divider_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/Out 0.45fF
C1328 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/Z1 0.36fF
C1329 divider_2/mc2 divider_2/nor_0/B 0.06fF
C1330 divider_2/tspc_2/Q divider_2/tspc_1/Z2 0.14fF
C1331 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z4 0.20fF
C1332 pd_1/REF pd_1/tspc_r_1/z5 0.04fF
C1333 pd_1/tspc_r_1/Z1 pd_1/tspc_r_1/Z2 0.71fF
C1334 pll_full_0/pd_0/DOWN pll_full_0/cp_0/a_1710_0# 0.04fF
C1335 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/R 0.01fF
C1336 divbuf_18/OUT5 divbuf_18/a_492_n240# 0.01fF
C1337 divbuf_0/OUT5 divbuf_0/OUT2 0.02fF
C1338 ro_complete_0/cbank_0/switch_1/vin divbuf_3/OUT 0.13fF
C1339 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1340 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1341 pll_full_1/ro_complete_0/cbank_1/switch_5/vin pll_full_1/divider_0/clk 1.46fF
C1342 divbuf_5/OUT divbuf_5/OUT4 1.11fF
C1343 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1344 divider_0/tspc_1/Z4 divider_0/nor_0/A 0.02fF
C1345 io_clamp_low[1] io_analog[5] 0.53fF
C1346 divider_1/tspc_0/Z1 divider_1/tspc_0/Z3 0.06fF
C1347 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z4 0.00fF
C1348 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C1349 divbuf_21/a_492_n240# divbuf_21/OUT5 0.01fF
C1350 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/Z3 0.05fF
C1351 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/clk 0.11fF
C1352 pd_1/DIV pd_1/tspc_r_0/z5 0.04fF
C1353 divbuf_18/OUT3 divbuf_18/OUT 0.26fF
C1354 divider_2/tspc_2/Q divider_2/nor_0/A 0.55fF
C1355 divider_2/nor_1/B divider_2/tspc_1/Q 0.22fF
C1356 divbuf_24/OUT3 divbuf_24/OUT4 5.16fF
C1357 divbuf_24/OUT2 divbuf_24/OUT5 0.02fF
C1358 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a5 0.09fF
C1359 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/v 1.30fF
C1360 divider_0/nor_0/B divider_0/tspc_0/Z4 0.02fF
C1361 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1362 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1363 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/clk 0.51fF
C1364 divbuf_6/OUT divbuf_6/a_492_n240# 0.00fF
C1365 ro_complete_1/a4 ro_complete_1/cbank_2/switch_0/vin 0.12fF
C1366 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/a0 0.09fF
C1367 divider_0/tspc_2/Z1 divider_0/tspc_2/Z2 1.07fF
C1368 divider_0/nor_0/A divider_0/tspc_2/Z3 0.38fF
C1369 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z4 0.12fF
C1370 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z3 0.06fF
C1371 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C1372 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1373 divider_1/nor_0/A divider_1/tspc_2/Z1 0.03fF
C1374 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z3 0.05fF
C1375 divbuf_7/OUT4 divbuf_7/OUT5 20.26fF
C1376 pll_full_1/divbuf_1/OUT3 pll_full_1/divbuf_1/OUT4 5.16fF
C1377 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT5 43.38fF
C1378 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z1 0.17fF
C1379 divbuf_19/OUT5 divbuf_19/a_492_n240# 0.01fF
C1380 divider_2/mc2 divider_2/and_0/A 0.16fF
C1381 divider_2/prescaler_0/tspc_2/Z2 divider_2/and_0/OUT 0.05fF
C1382 divbuf_2/IN divbuf_2/OUT5 0.00fF
C1383 divbuf_7/OUT ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1384 ro_complete_0/cbank_0/v ro_complete_0/cbank_1/v 1.27fF
C1385 divbuf_14/IN divbuf_14/a_492_n240# 0.13fF
C1386 divider_0/mc2 divider_0/and_0/A 0.16fF
C1387 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z4 0.12fF
C1388 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1389 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/prescaler_0/nand_1/z1 0.01fF
C1390 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/clk 0.11fF
C1391 divbuf_3/OUT3 divbuf_3/OUT4 5.16fF
C1392 ro_complete_1/a0 ro_complete_1/cbank_1/v 0.05fF
C1393 divider_2/tspc_0/Z4 divider_2/tspc_0/a_630_n680# 0.12fF
C1394 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_1/a_630_n680# 0.00fF
C1395 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z3 0.05fF
C1396 divbuf_10/a_492_n240# divbuf_10/OUT 0.00fF
C1397 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1398 pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_0/divider_0/clk 1.46fF
C1399 divider_2/tspc_2/Q divider_2/tspc_1/Z1 0.01fF
C1400 divider_2/tspc_1/a_630_n680# divider_2/nor_0/B 0.35fF
C1401 divider_1/and_0/A divider_1/and_0/B 0.18fF
C1402 divbuf_9/OUT3 divbuf_9/OUT5 0.01fF
C1403 divbuf_9/OUT2 divbuf_9/OUT 0.06fF
C1404 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1405 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z4 0.02fF
C1406 divider_2/tspc_1/Z2 divider_2/nor_0/A 0.15fF
C1407 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_0/D 0.32fF
C1408 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/clk 0.01fF
C1409 divider_2/nor_0/B divider_2/and_0/A 0.26fF
C1410 divbuf_5/OUT ro_complete_0/cbank_2/switch_3/vin 0.09fF
C1411 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C1412 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z4 0.20fF
C1413 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C1414 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/pd_0/tspc_r_1/Z2 0.71fF
C1415 divbuf_1/OUT divbuf_1/OUT4 1.11fF
C1416 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_4/vin 0.20fF
C1417 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/and_pd_0/Out1 0.05fF
C1418 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/OUT2 0.02fF
C1419 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a3 0.13fF
C1420 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/Q 0.04fF
C1421 divider_0/prescaler_0/tspc_1/Z3 divider_0/clk 0.45fF
C1422 divbuf_7/OUT divbuf_7/OUT3 0.26fF
C1423 divbuf_4/OUT2 divbuf_4/OUT3 1.37fF
C1424 ro_complete_1/cbank_2/switch_0/vin ro_complete_1/cbank_2/v 1.45fF
C1425 divbuf_20/OUT4 divbuf_20/OUT 1.11fF
C1426 divider_1/prescaler_0/tspc_2/D divider_1/prescaler_0/nand_0/z1 0.24fF
C1427 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Z4 0.65fF
C1428 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1429 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/clk 0.51fF
C1430 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C1431 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z2 1.07fF
C1432 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z4 0.12fF
C1433 divbuf_8/a_492_n240# divbuf_8/OUT5 0.01fF
C1434 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT2 0.06fF
C1435 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C1436 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1437 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Out1 0.05fF
C1438 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z2 0.01fF
C1439 divider_0/nor_1/Z1 divider_0/nor_1/B 0.06fF
C1440 ro_complete_1/a2 ro_complete_1/cbank_1/switch_3/vin 0.09fF
C1441 divbuf_0/OUT2 divbuf_0/a_492_n240# 0.42fF
C1442 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1443 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1444 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/clk 0.14fF
C1445 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/and_pd_0/Z1 0.02fF
C1446 divbuf_14/OUT divbuf_14/OUT3 0.26fF
C1447 divbuf_5/OUT2 divbuf_5/OUT3 1.37fF
C1448 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z3 0.05fF
C1449 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/Z1 0.00fF
C1450 divider_1/tspc_0/Z1 divider_1/tspc_0/Z4 0.00fF
C1451 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z2 0.19fF
C1452 pll_full_1/divider_0/tspc_2/Z2 pll_full_1/divider_0/tspc_2/Z4 0.36fF
C1453 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z2 0.01fF
C1454 divider_1/and_0/OUT divider_1/and_0/out1 0.31fF
C1455 divider_1/prescaler_0/tspc_2/D divider_1/clk 0.26fF
C1456 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C1457 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/clk 0.11fF
C1458 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z4 0.20fF
C1459 pd_0/REF pd_0/tspc_r_1/z5 0.04fF
C1460 pd_0/tspc_r_1/Z1 pd_0/tspc_r_1/Z2 0.71fF
C1461 divider_2/tspc_1/Q divider_2/tspc_0/Z1 0.01fF
C1462 divider_2/tspc_1/Z1 divider_2/tspc_1/Z2 1.07fF
C1463 divider_2/nor_0/B divider_2/tspc_1/Z3 0.38fF
C1464 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z4 0.08fF
C1465 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z3 0.05fF
C1466 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Q 0.04fF
C1467 divbuf_12/OUT3 divbuf_12/OUT 0.26fF
C1468 divbuf_12/OUT4 divbuf_12/OUT5 20.26fF
C1469 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1470 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT4 1.11fF
C1471 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_1/Qbar 0.02fF
C1472 divbuf_14/OUT2 divbuf_14/a_492_n240# 0.42fF
C1473 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_1/Q 0.13fF
C1474 divider_0/prescaler_0/m1_2700_2190# divider_0/and_0/OUT 0.14fF
C1475 divbuf_5/OUT ro_complete_0/cbank_2/v 0.05fF
C1476 ro_complete_1/a3 ro_complete_1/cbank_1/v 0.05fF
C1477 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1478 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Z2 0.01fF
C1479 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/Z3 0.45fF
C1480 filter_0/v divbuf_25/OUT4 1.11fF
C1481 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C1482 divider_1/tspc_1/Z1 divider_1/tspc_1/Z4 0.00fF
C1483 divider_1/tspc_1/Q divider_1/tspc_1/Z3 0.05fF
C1484 divider_1/Out divider_1/nor_1/B 0.22fF
C1485 divbuf_11/a_492_n240# divbuf_11/OUT 0.00fF
C1486 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z3 0.06fF
C1487 cp_0/a_1710_n2840# cp_0/upbar 0.29fF
C1488 pd_1/R pd_1/REF 0.61fF
C1489 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z2 0.25fF
C1490 divbuf_18/OUT5 divbuf_18/OUT 43.38fF
C1491 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1492 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/switch_1/vin 0.19fF
C1493 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C1494 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar 0.03fF
C1495 divider_0/prescaler_0/tspc_2/Z4 divider_0/prescaler_0/tspc_2/D 0.11fF
C1496 divider_0/prescaler_0/tspc_0/Z4 divider_0/clk 0.12fF
C1497 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_4/vin 0.20fF
C1498 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C1499 divider_2/tspc_0/Z4 divider_2/tspc_1/Q 0.15fF
C1500 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z1 0.01fF
C1501 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/nor_0/B 0.35fF
C1502 divbuf_20/a_492_n240# divbuf_20/IN 0.13fF
C1503 pll_full_1/cp_0/down pll_full_1/cp_0/a_1710_0# 0.32fF
C1504 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/R 0.21fF
C1505 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1506 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1507 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/clk 0.14fF
C1508 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/B 0.78fF
C1509 divider_1/tspc_1/Z2 divider_1/tspc_1/Z4 0.36fF
C1510 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/D 0.05fF
C1511 divider_1/prescaler_0/tspc_0/Z3 divider_1/clk 0.64fF
C1512 divbuf_22/OUT4 divbuf_22/OUT 1.11fF
C1513 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z1 0.09fF
C1514 pd_0/DIV pd_0/tspc_r_0/Z2 0.19fF
C1515 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z3 0.05fF
C1516 divider_2/tspc_0/Z3 divider_2/tspc_0/a_630_n680# 0.05fF
C1517 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/prescaler_0/m1_2700_2190# 0.01fF
C1518 pll_full_1/divider_0/tspc_2/Z4 pll_full_1/divider_0/prescaler_0/Out 0.12fF
C1519 cp_0/upbar cp_0/down 0.02fF
C1520 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/z5 0.20fF
C1521 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/z5 0.11fF
C1522 divbuf_13/a_492_n240# divbuf_13/OUT5 0.01fF
C1523 divbuf_5/OUT ro_complete_0/cbank_1/switch_2/vin 0.14fF
C1524 divider_0/tspc_0/a_630_n680# divider_0/Out 0.04fF
C1525 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.91fF
C1526 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1527 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Out1 0.05fF
C1528 divider_0/prescaler_0/tspc_2/Z3 divider_0/clk 0.45fF
C1529 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/a1 0.14fF
C1530 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/a3 0.09fF
C1531 pll_full_0/divbuf_0/OUT2 pll_full_0/divbuf_0/a_492_n240# 0.42fF
C1532 ro_complete_1/cbank_2/switch_5/vin ro_complete_1/cbank_2/v 1.30fF
C1533 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1534 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/Z4 0.65fF
C1535 divbuf_21/OUT2 divbuf_21/OUT3 1.37fF
C1536 pll_full_1/pd_0/DIV pll_full_1/pd_0/tspc_r_0/Qbar1 0.12fF
C1537 divider_2/prescaler_0/Out divider_2/tspc_2/Z3 0.45fF
C1538 divider_1/tspc_1/Z4 divider_1/nor_0/A 0.02fF
C1539 pd_0/R pd_0/tspc_r_1/Qbar 0.03fF
C1540 pd_1/and_pd_0/Out1 pd_1/and_pd_0/Z1 0.18fF
C1541 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/z5 0.03fF
C1542 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/R 0.21fF
C1543 divider_2/nor_0/A divider_2/and_0/B 0.08fF
C1544 divbuf_24/OUT3 divbuf_24/OUT 0.26fF
C1545 divbuf_24/OUT4 divbuf_24/OUT5 20.26fF
C1546 divbuf_2/OUT divbuf_2/OUT2 0.06fF
C1547 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1548 divider_0/nor_0/A divider_0/tspc_2/Z4 0.21fF
C1549 divider_0/tspc_2/Z2 divider_0/tspc_2/Z3 0.16fF
C1550 divbuf_3/IN divbuf_3/a_492_n240# 0.13fF
C1551 divbuf_1/a_492_n240# divbuf_1/IN 0.13fF
C1552 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/v 1.30fF
C1553 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1554 divbuf_6/a_492_n240# divbuf_6/OUT2 0.42fF
C1555 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z3 0.45fF
C1556 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/nor_1/B 0.40fF
C1557 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z4 0.12fF
C1558 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C1559 divider_1/nor_0/B divider_1/tspc_0/Z4 0.02fF
C1560 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z4 0.00fF
C1561 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/A 0.01fF
C1562 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/B 0.01fF
C1563 divider_1/tspc_2/Z1 divider_1/tspc_2/Z2 1.07fF
C1564 divider_1/nor_0/A divider_1/tspc_2/Z3 0.38fF
C1565 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z4 0.12fF
C1566 divbuf_23/a_492_n240# divbuf_23/OUT 0.00fF
C1567 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Out1 0.05fF
C1568 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Q 0.20fF
C1569 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/D 0.09fF
C1570 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Z1 0.07fF
C1571 divbuf_15/OUT5 divbuf_15/OUT3 0.01fF
C1572 divbuf_15/OUT divbuf_15/OUT2 0.06fF
C1573 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C1574 divider_0/prescaler_0/Out divider_0/tspc_2/a_630_n680# 0.01fF
C1575 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1576 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Q 0.21fF
C1577 pll_full_1/divider_0/prescaler_0/tspc_0/D pll_full_1/divider_0/prescaler_0/nand_1/z1 0.21fF
C1578 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C1579 divider_0/and_0/B divider_0/and_0/Z1 0.07fF
C1580 divbuf_3/OUT4 divbuf_3/OUT5 20.26fF
C1581 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/nor_0/B 0.47fF
C1582 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_1/Z3 0.05fF
C1583 pll_full_1/pd_0/UP pll_full_1/pd_0/tspc_r_1/Z3 0.03fF
C1584 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z4 0.12fF
C1585 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z3 0.06fF
C1586 divbuf_10/IN divbuf_10/OUT5 0.00fF
C1587 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C1588 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1589 divbuf_22/a_492_n240# divbuf_22/IN 0.13fF
C1590 divbuf_9/OUT4 divbuf_9/OUT 1.11fF
C1591 cp_0/a_1710_n2840# cp_0/out 0.61fF
C1592 pd_1/DOWN pd_1/and_pd_0/Out1 0.12fF
C1593 pd_1/REF pd_1/tspc_r_1/Qbar1 0.12fF
C1594 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/nand_1/z1 0.22fF
C1595 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/tspc_0/D 0.04fF
C1596 divbuf_5/OUT ro_complete_0/cbank_0/switch_2/vin 0.14fF
C1597 ro_complete_0/cbank_0/switch_1/vin divbuf_4/OUT 0.09fF
C1598 ro_complete_0/cbank_0/switch_0/vin divbuf_2/OUT 0.09fF
C1599 pll_full_0/cp_0/upbar pll_full_0/cp_0/down 0.02fF
C1600 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C1601 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/z5 0.20fF
C1602 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z3 0.33fF
C1603 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.15fF
C1604 pll_full_1/ro_complete_0/a0 pll_full_1/divider_0/clk 0.11fF
C1605 divbuf_5/OUT divbuf_5/a_492_n240# 0.00fF
C1606 divbuf_3/OUT divbuf_3/OUT3 0.26fF
C1607 divbuf_1/OUT2 divbuf_1/OUT3 1.37fF
C1608 divider_0/prescaler_0/tspc_1/Z4 divider_0/clk 0.12fF
C1609 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT2 0.02fF
C1610 divbuf_7/OUT divbuf_7/OUT5 43.38fF
C1611 divbuf_4/OUT3 divbuf_4/OUT4 5.16fF
C1612 divbuf_4/OUT2 divbuf_4/OUT5 0.02fF
C1613 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_2/a_630_n680# 0.01fF
C1614 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Z4 0.02fF
C1615 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/Q 0.04fF
C1616 divider_1/prescaler_0/tspc_1/Z3 divider_1/clk 0.45fF
C1617 divbuf_8/OUT2 divbuf_8/OUT3 1.37fF
C1618 pll_full_1/divbuf_1/OUT3 pll_full_1/divbuf_1/OUT5 0.01fF
C1619 pll_full_1/divbuf_1/OUT2 pll_full_1/divbuf_1/OUT 0.06fF
C1620 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C1621 divbuf_18/OUT3 divbuf_18/OUT5 0.01fF
C1622 divider_2/tspc_0/Z3 divider_2/tspc_1/Q 0.45fF
C1623 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z3 0.16fF
C1624 divider_2/nor_0/A divider_2/tspc_2/Z2 0.23fF
C1625 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/and_pd_0/Z1 0.18fF
C1626 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C1627 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C1628 divider_0/prescaler_0/tspc_1/Q divider_0/clk 0.60fF
C1629 divider_1/nor_1/Z1 divider_1/nor_1/B 0.06fF
C1630 divbuf_5/OUT3 divbuf_5/OUT4 5.16fF
C1631 divbuf_5/OUT2 divbuf_5/OUT5 0.02fF
C1632 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C1633 divbuf_17/OUT4 divbuf_17/OUT5 20.26fF
C1634 divbuf_7/a_492_n240# divbuf_7/OUT2 0.42fF
C1635 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C1636 divbuf_12/OUT5 divbuf_12/OUT 43.38fF
C1637 pd_0/R pd_0/and_pd_0/Z1 0.02fF
C1638 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/z5 0.20fF
C1639 divider_2/nor_0/B divider_2/tspc_1/Z4 0.21fF
C1640 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z2 1.07fF
C1641 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z4 0.12fF
C1642 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT5 43.38fF
C1643 divider_2/and_0/out1 divider_2/and_0/Z1 0.36fF
C1644 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C1645 divbuf_2/OUT divbuf_2/a_492_n240# 0.00fF
C1646 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/a_492_n240# 0.01fF
C1647 divbuf_15/OUT5 divbuf_15/a_492_n240# 0.01fF
C1648 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_1/Q 0.21fF
C1649 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_2/D 0.16fF
C1650 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/D 0.03fF
C1651 ro_complete_1/a4 ro_complete_1/cbank_2/v 0.05fF
C1652 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_0/vin 0.19fF
C1653 divbuf_25/OUT2 divbuf_25/OUT5 0.02fF
C1654 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/Z4 0.15fF
C1655 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_0/Z2 0.40fF
C1656 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divbuf_0/IN 0.04fF
C1657 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_1/Q 0.13fF
C1658 divider_1/prescaler_0/m1_2700_2190# divider_1/and_0/OUT 0.14fF
C1659 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z4 0.15fF
C1660 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C1661 pll_full_0/ro_complete_0/a0 pll_full_0/divider_0/clk 0.11fF
C1662 divbuf_17/OUT3 divbuf_17/OUT5 0.01fF
C1663 divbuf_11/IN divbuf_11/OUT5 0.00fF
C1664 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/a_492_n240# 0.00fF
C1665 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z4 0.00fF
C1666 divbuf_9/a_492_n240# divbuf_9/IN 0.13fF
C1667 pd_1/R pd_1/tspc_r_1/Qbar1 0.30fF
C1668 pd_1/tspc_r_0/Z3 pd_1/tspc_r_0/Qbar1 0.38fF
C1669 pd_0/and_pd_0/Out1 pd_0/and_pd_0/Z1 0.18fF
C1670 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/Qbar 0.01fF
C1671 divider_2/prescaler_0/tspc_1/Z2 divider_2/clk 0.11fF
C1672 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Qbar1 0.12fF
C1673 pll_full_1/ro_complete_0/a3 pll_full_1/divider_0/clk 0.11fF
C1674 divbuf_7/OUT ro_complete_0/cbank_2/switch_5/vin 0.09fF
C1675 pll_full_1/pd_0/UP pll_full_1/pd_0/tspc_r_1/Qbar1 0.11fF
C1676 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C1677 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a4 0.09fF
C1678 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a5 0.09fF
C1679 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_1/Z2 0.01fF
C1680 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z3 0.45fF
C1681 divider_1/prescaler_0/tspc_2/Z4 divider_1/prescaler_0/tspc_2/D 0.11fF
C1682 divider_1/prescaler_0/tspc_0/Z4 divider_1/clk 0.12fF
C1683 filter_0/v divbuf_25/a_492_n240# 0.00fF
C1684 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C1685 pd_0/DIV pd_0/R 0.51fF
C1686 divbuf_17/OUT4 divbuf_17/OUT 1.11fF
C1687 divider_2/mc2 divider_2/prescaler_0/tspc_2/a_630_n680# 0.33fF
C1688 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z4 0.12fF
C1689 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1690 divbuf_13/OUT2 divbuf_13/OUT3 1.37fF
C1691 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C1692 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/tspc_r_0/Z2 0.71fF
C1693 divbuf_4/OUT divbuf_2/OUT 1.95fF
C1694 divider_0/mc2 divider_0/prescaler_0/tspc_2/a_630_n680# 0.33fF
C1695 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/v 1.30fF
C1696 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.09fF
C1697 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/a1 0.14fF
C1698 pll_full_1/pd_0/UP pll_full_1/pd_0/DOWN 4.58fF
C1699 divider_0/prescaler_0/tspc_2/Z4 divider_0/clk 0.12fF
C1700 io_clamp_high[0] io_analog[4] 0.53fF
C1701 divbuf_5/a_492_n240# divbuf_5/IN 0.13fF
C1702 divider_1/tspc_0/a_630_n680# divider_1/Out 0.04fF
C1703 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/nor_0/A 0.35fF
C1704 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/and_0/A 0.26fF
C1705 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C1706 divider_2/prescaler_0/Out divider_2/tspc_2/Z4 0.12fF
C1707 divider_1/prescaler_0/tspc_2/Z3 divider_1/clk 0.45fF
C1708 divbuf_21/OUT3 divbuf_21/OUT4 5.16fF
C1709 divbuf_21/OUT2 divbuf_21/OUT5 0.02fF
C1710 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/tspc_r_0/Z4 0.14fF
C1711 pd_1/DIV pd_1/tspc_r_0/Qbar1 0.12fF
C1712 pd_0/REF pd_0/tspc_r_1/Qbar1 0.12fF
C1713 divbuf_17/OUT3 divbuf_17/OUT 0.26fF
C1714 divbuf_12/a_492_n240# divbuf_12/OUT2 0.42fF
C1715 divbuf_24/OUT5 divbuf_24/OUT 43.38fF
C1716 filter_0/a_4216_n2998# filter_0/v 0.36fF
C1717 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z4 0.14fF
C1718 divbuf_6/OUT divbuf_6/OUT2 0.06fF
C1719 ro_complete_1/a5 ro_complete_1/cbank_2/switch_0/vin 0.09fF
C1720 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/and_pd_0/Out1 0.18fF
C1721 divider_0/tspc_2/Z2 divider_0/tspc_2/Z4 0.36fF
C1722 pll_full_0/ro_complete_0/a3 pll_full_0/divider_0/clk 0.11fF
C1723 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Z4 0.65fF
C1724 divider_1/nor_0/A divider_1/tspc_2/Z4 0.21fF
C1725 divider_1/tspc_2/Z2 divider_1/tspc_2/Z3 0.16fF
C1726 pd_1/DOWN pd_1/tspc_r_0/Z3 0.03fF
C1727 divider_2/tspc_1/Z3 divider_2/tspc_1/Z4 0.65fF
C1728 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Q 0.04fF
C1729 divbuf_23/IN divbuf_23/OUT5 0.00fF
C1730 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C1731 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_492_n240# 0.00fF
C1732 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C1733 divider_0/prescaler_0/Out divider_0/nor_0/A 0.15fF
C1734 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1735 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/clk 0.14fF
C1736 divider_0/nor_1/Z1 divider_0/and_0/B 0.78fF
C1737 divbuf_2/OUT3 divbuf_2/OUT5 0.01fF
C1738 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C1739 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/nor_0/B 0.20fF
C1740 divbuf_10/OUT3 divbuf_10/OUT5 0.01fF
C1741 divbuf_10/OUT2 divbuf_10/OUT 0.06fF
C1742 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C1743 divider_1/prescaler_0/Out divider_1/tspc_2/a_630_n680# 0.01fF
C1744 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z4 0.00fF
C1745 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Q 0.21fF
C1746 divbuf_19/OUT5 divbuf_19/OUT 43.38fF
C1747 divider_1/and_0/B divider_1/and_0/Z1 0.07fF
C1748 pll_full_1/divider_0/and_0/B pll_full_1/divider_0/nor_1/Z1 0.78fF
C1749 pd_1/tspc_r_1/Z3 pd_1/UP 0.03fF
C1750 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/nand_1/z1 0.01fF
C1751 divider_2/prescaler_0/tspc_2/Z2 divider_2/clk 0.11fF
C1752 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1753 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z3 0.05fF
C1754 divbuf_3/OUT divbuf_3/OUT5 43.38fF
C1755 ro_complete_0/cbank_1/v ro_complete_0/cbank_2/v 1.36fF
C1756 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT3 0.26fF
C1757 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT4 20.26fF
C1758 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1759 divbuf_4/OUT4 divbuf_4/OUT5 20.26fF
C1760 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_0/Qbar1 0.20fF
C1761 pll_full_0/filter_0/a_4216_n5230# pll_full_0/divider_0/clk 1.58fF
C1762 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C1763 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z3 0.33fF
C1764 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_2/Z3 0.05fF
C1765 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/nor_0/A 1.21fF
C1766 divbuf_16/OUT2 divbuf_16/OUT5 0.02fF
C1767 divider_1/prescaler_0/tspc_1/Z4 divider_1/clk 0.12fF
C1768 pd_0/DOWN pd_0/UP 0.46fF
C1769 pd_0/tspc_r_0/Z4 pd_0/tspc_r_0/z5 0.04fF
C1770 divbuf_18/IN divbuf_18/a_492_n240# 0.13fF
C1771 divider_2/tspc_0/a_630_n680# divider_2/tspc_1/Q 0.01fF
C1772 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z4 0.36fF
C1773 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_0/D 0.09fF
C1774 divbuf_8/OUT3 divbuf_8/OUT4 5.16fF
C1775 divbuf_8/OUT2 divbuf_8/OUT5 0.02fF
C1776 pll_full_1/divbuf_1/OUT4 pll_full_1/divbuf_1/OUT 1.11fF
C1777 divider_2/tspc_2/Z1 divider_2/tspc_2/Z3 0.06fF
C1778 divbuf_24/a_492_n240# divbuf_24/OUT2 0.42fF
C1779 divider_0/tspc_0/Z2 divider_0/nor_1/B 0.40fF
C1780 divider_0/tspc_0/Z3 divider_0/Out 0.05fF
C1781 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z3 0.33fF
C1782 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1783 divider_0/and_0/OUT divider_0/and_0/Z1 0.04fF
C1784 divider_0/prescaler_0/tspc_2/Q divider_0/clk 0.05fF
C1785 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/a0 0.13fF
C1786 divbuf_5/OUT4 divbuf_5/OUT5 20.26fF
C1787 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C1788 divbuf_16/OUT3 divbuf_16/OUT2 1.37fF
C1789 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/and_0/A 0.01fF
C1790 divbuf_16/IN divbuf_16/OUT5 0.00fF
C1791 divider_1/prescaler_0/tspc_1/Q divider_1/clk 0.60fF
C1792 pd_1/tspc_r_0/Z1 pd_1/tspc_r_0/Z3 0.09fF
C1793 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C1794 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z3 0.16fF
C1795 pll_full_1/divider_0/and_0/B pll_full_1/divider_0/and_0/OUT 0.01fF
C1796 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1797 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/Out 0.04fF
C1798 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/nand_0/z1 0.07fF
C1799 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/D 0.05fF
C1800 divbuf_1/OUT5 divbuf_1/OUT 43.38fF
C1801 divbuf_1/OUT2 divbuf_1/a_492_n240# 0.42fF
C1802 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C1803 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/v 1.30fF
C1804 divider_1/mc2 divider_1/and_0/out1 0.06fF
C1805 divbuf_14/OUT4 divbuf_14/OUT3 5.16fF
C1806 ro_complete_1/a1 ro_complete_1/cbank_1/v 0.05fF
C1807 pll_full_1/divider_0/nor_1/B pll_full_1/divbuf_0/IN 0.27fF
C1808 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_0/Z3 0.06fF
C1809 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_1/B 0.47fF
C1810 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/Z4 0.65fF
C1811 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z2 0.19fF
C1812 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_1/Q 0.21fF
C1813 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_2/D 0.16fF
C1814 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/D 0.03fF
C1815 divbuf_11/OUT3 divbuf_11/OUT5 0.01fF
C1816 divbuf_11/OUT2 divbuf_11/OUT 0.06fF
C1817 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divider_0/tspc_2/Z4 0.65fF
C1818 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/UP 0.03fF
C1819 divider_0/nor_0/Z1 divider_0/nor_0/B 0.06fF
C1820 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1821 divider_1/mc2 divider_1/nor_0/B 0.06fF
C1822 divbuf_14/OUT2 divbuf_14/OUT3 1.37fF
C1823 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Q 0.05fF
C1824 divider_0/prescaler_0/m1_2700_2190# divider_0/clk 0.01fF
C1825 divbuf_7/OUT ro_complete_0/cbank_2/v 0.05fF
C1826 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z4 0.15fF
C1827 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Z2 0.30fF
C1828 divbuf_20/a_492_n240# divbuf_20/OUT5 0.01fF
C1829 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Qbar1 0.38fF
C1830 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C1831 divbuf_16/OUT3 divbuf_16/OUT5 0.01fF
C1832 pd_1/DIV pd_1/tspc_r_0/Z1 0.17fF
C1833 pd_0/tspc_r_0/Qbar1 pd_0/R 0.01fF
C1834 pd_0/DIV pd_0/tspc_r_0/Z4 0.02fF
C1835 pd_0/DOWN pd_0/tspc_r_0/Qbar 0.21fF
C1836 divbuf_18/OUT2 divbuf_18/a_492_n240# 0.42fF
C1837 divider_2/and_0/OUT divider_2/and_0/B 0.01fF
C1838 divbuf_13/OUT3 divbuf_13/OUT4 5.16fF
C1839 divbuf_13/OUT2 divbuf_13/OUT5 0.02fF
C1840 ro_complete_0/cbank_1/switch_3/vin divbuf_6/OUT 0.14fF
C1841 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1842 pll_full_0/pd_0/REF pll_full_0/divbuf_1/OUT5 0.00fF
C1843 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z4 0.01fF
C1844 ro_complete_1/a4 ro_complete_1/cbank_2/switch_1/vin 0.09fF
C1845 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/v 1.30fF
C1846 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1847 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z2 0.01fF
C1848 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_1/Q 0.14fF
C1849 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/Out 0.04fF
C1850 divbuf_21/OUT3 divbuf_21/OUT 0.26fF
C1851 divbuf_21/OUT4 divbuf_21/OUT5 20.26fF
C1852 divider_2/prescaler_0/tspc_0/Z3 divider_2/clk 0.64fF
C1853 divider_1/prescaler_0/tspc_2/Z4 divider_1/clk 0.12fF
C1854 pd_0/tspc_r_1/Z3 pd_0/UP 0.03fF
C1855 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1856 pll_full_0/pd_0/DOWN pll_full_0/pd_0/REF 1.48fF
C1857 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C1858 divbuf_2/OUT divbuf_2/OUT4 1.11fF
C1859 divbuf_4/OUT ro_complete_0/cbank_2/switch_0/vin 0.12fF
C1860 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Q 0.15fF
C1861 divider_0/prescaler_0/tspc_0/Z2 divider_0/and_0/OUT 0.06fF
C1862 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/tspc_2/D 0.03fF
C1863 divbuf_6/OUT divbuf_6/OUT4 1.11fF
C1864 divbuf_3/OUT2 divbuf_3/OUT3 1.37fF
C1865 ro_complete_1/a3 ro_complete_1/cbank_2/switch_2/vin 0.09fF
C1866 divbuf_17/OUT2 divbuf_17/a_492_n240# 0.42fF
C1867 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/Z1 0.36fF
C1868 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/B 0.18fF
C1869 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1870 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT3 0.26fF
C1871 divbuf_19/OUT2 divbuf_19/a_492_n240# 0.42fF
C1872 divider_1/tspc_2/Z2 divider_1/tspc_2/Z4 0.36fF
C1873 divbuf_23/OUT3 divbuf_23/OUT5 0.01fF
C1874 divbuf_23/OUT2 divbuf_23/OUT 0.06fF
C1875 pll_full_1/pd_0/DIV pll_full_1/divider_0/and_0/OUT 0.01fF
C1876 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C1877 pll_full_0/pd_0/R pll_full_0/pd_0/REF 0.61fF
C1878 divbuf_15/OUT2 divbuf_15/OUT3 1.37fF
C1879 pll_full_1/ro_complete_0/a4 pll_full_1/divider_0/clk 0.01fF
C1880 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/a3 0.13fF
C1881 divbuf_3/OUT ro_complete_0/cbank_2/v 0.05fF
C1882 divbuf_15/IN divbuf_15/a_492_n240# 0.13fF
C1883 divbuf_25/OUT3 divbuf_25/OUT5 0.01fF
C1884 divbuf_25/a_492_n240# divbuf_25/IN 0.13fF
C1885 divider_0/prescaler_0/Out divider_0/tspc_2/Z2 0.11fF
C1886 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/clk 0.01fF
C1887 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/v 1.30fF
C1888 divider_2/Out divider_2/nor_1/B 0.22fF
C1889 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z2 0.01fF
C1890 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1891 divider_1/prescaler_0/Out divider_1/nor_0/A 0.15fF
C1892 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Z4 0.65fF
C1893 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/clk 0.14fF
C1894 divider_1/nor_1/Z1 divider_1/and_0/B 0.78fF
C1895 divbuf_10/OUT4 divbuf_10/OUT 1.11fF
C1896 divbuf_22/a_492_n240# divbuf_22/OUT5 0.01fF
C1897 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/Out 0.01fF
C1898 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1899 cp_0/a_10_n50# cp_0/vbias 0.19fF
C1900 pd_1/R pd_1/and_pd_0/Out1 0.33fF
C1901 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z1 0.09fF
C1902 pd_1/REF pd_1/tspc_r_1/Z2 0.19fF
C1903 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1904 divider_2/prescaler_0/tspc_0/D divider_2/prescaler_0/nand_1/z1 0.21fF
C1905 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1906 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z4 0.12fF
C1907 divbuf_4/OUT divbuf_4/OUT3 0.26fF
C1908 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/v 1.30fF
C1909 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_2/Q 0.19fF
C1910 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/clk 0.01fF
C1911 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z4 0.08fF
C1912 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z3 0.05fF
C1913 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/nor_0/A 0.15fF
C1914 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C1915 divbuf_17/OUT2 divbuf_17/OUT5 0.02fF
C1916 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_0/Qbar1 0.11fF
C1917 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/a_630_n680# 0.04fF
C1918 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C1919 pd_0/R pd_0/REF 0.61fF
C1920 divbuf_8/OUT3 divbuf_8/OUT 0.26fF
C1921 divbuf_8/OUT4 divbuf_8/OUT5 20.26fF
C1922 divider_2/tspc_2/Z1 divider_2/tspc_2/Z4 0.00fF
C1923 divbuf_3/OUT ro_complete_0/cbank_1/switch_2/vin 0.09fF
C1924 divider_0/nor_0/B divider_0/tspc_2/Q 0.22fF
C1925 divider_0/tspc_0/a_630_n680# divider_0/nor_1/B 0.35fF
C1926 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z4 0.08fF
C1927 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z3 0.05fF
C1928 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_4/vin 0.20fF
C1929 pll_full_1/pd_0/UP pll_full_1/pd_0/R 0.46fF
C1930 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C1931 divider_0/tspc_2/a_630_n680# divider_0/nor_0/A 0.35fF
C1932 divider_0/prescaler_0/tspc_0/D divider_0/clk 0.29fF
C1933 divider_1/tspc_0/Z2 divider_1/nor_1/B 0.40fF
C1934 divider_1/tspc_0/Z3 divider_1/Out 0.05fF
C1935 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z3 0.33fF
C1936 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z1 0.03fF
C1937 pll_full_0/ro_complete_0/a4 pll_full_0/divider_0/clk 0.01fF
C1938 divider_1/and_0/OUT divider_1/and_0/Z1 0.04fF
C1939 divider_1/prescaler_0/tspc_2/Q divider_1/clk 0.05fF
C1940 pll_full_1/pd_0/tspc_r_0/Qbar pll_full_1/pd_0/tspc_r_0/Qbar1 0.01fF
C1941 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/nor_0/A 0.03fF
C1942 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C1943 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z4 0.36fF
C1944 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C1945 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT2 0.06fF
C1946 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_5/vin 0.20fF
C1947 pll_full_0/pd_0/DIV pll_full_0/divider_0/and_0/OUT 0.01fF
C1948 divbuf_15/OUT2 divbuf_15/a_492_n240# 0.42fF
C1949 divider_0/tspc_1/a_630_n680# divider_0/nor_1/B 0.00fF
C1950 divider_0/prescaler_0/tspc_1/Z2 divider_0/and_0/OUT 0.06fF
C1951 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1952 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Q 0.38fF
C1953 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_0/D 0.11fF
C1954 divider_0/nor_0/Z1 divider_0/and_0/A 0.80fF
C1955 ro_complete_1/a5 ro_complete_1/cbank_2/v 0.08fF
C1956 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Z1 0.17fF
C1957 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1958 divider_1/mc2 divider_1/and_0/A 0.16fF
C1959 divider_0/and_0/out1 divider_0/and_0/A 0.01fF
C1960 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_0/Z4 0.00fF
C1961 divbuf_10/a_492_n240# divbuf_10/IN 0.13fF
C1962 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/nand_0/z1 0.07fF
C1963 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/D 0.05fF
C1964 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z2 0.30fF
C1965 divbuf_18/OUT2 divbuf_18/OUT 0.06fF
C1966 divbuf_17/OUT2 divbuf_17/OUT 0.06fF
C1967 divbuf_16/OUT5 divbuf_16/OUT4 20.26fF
C1968 divbuf_11/OUT4 divbuf_11/OUT 1.11fF
C1969 pd_1/R pd_1/tspc_r_1/Z2 0.21fF
C1970 divbuf_9/a_492_n240# divbuf_9/OUT5 0.01fF
C1971 pll_full_1/divbuf_1/OUT5 pll_full_1/divbuf_1/OUT 43.38fF
C1972 pll_full_1/ro_complete_0/cbank_1/switch_4/vin pll_full_1/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C1973 divider_0/tspc_0/Z2 divider_0/tspc_0/a_630_n680# 0.01fF
C1974 pll_full_1/ro_complete_0/a1 pll_full_1/divider_0/clk 0.11fF
C1975 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z1 0.09fF
C1976 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z2 0.19fF
C1977 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/tspc_r_1/Qbar1 0.01fF
C1978 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/clk 0.01fF
C1979 divider_0/nor_0/B divider_0/and_0/A 0.26fF
C1980 divbuf_7/OUT divbuf_7/a_492_n240# 0.00fF
C1981 divbuf_4/a_492_n240# divbuf_4/OUT2 0.42fF
C1982 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z3 0.06fF
C1983 divbuf_20/OUT2 divbuf_20/OUT3 1.37fF
C1984 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_1/Q 0.13fF
C1985 divbuf_16/OUT3 divbuf_16/OUT4 5.16fF
C1986 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Q 0.05fF
C1987 divider_1/prescaler_0/m1_2700_2190# divider_1/clk 0.01fF
C1988 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z3 0.45fF
C1989 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_0/A 1.21fF
C1990 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/z5 0.11fF
C1991 divider_2/tspc_0/Z2 divider_2/nor_1/B 0.40fF
C1992 divbuf_13/OUT3 divbuf_13/OUT 0.26fF
C1993 divbuf_13/OUT4 divbuf_13/OUT5 20.26fF
C1994 ro_complete_0/cbank_0/switch_3/vin divbuf_6/OUT 0.14fF
C1995 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/v 1.30fF
C1996 ro_complete_0/cbank_0/switch_2/vin divbuf_3/OUT 0.09fF
C1997 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C1998 ro_complete_1/a2 ro_complete_1/cbank_2/v 0.05fF
C1999 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/DOWN 0.02fF
C2000 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C2001 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/Out 0.05fF
C2002 divider_0/nor_1/B divider_0/and_0/B 0.29fF
C2003 divbuf_5/a_492_n240# divbuf_5/OUT5 0.01fF
C2004 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z3 0.16fF
C2005 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C2006 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/a_630_n680# 0.05fF
C2007 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z4 0.01fF
C2008 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z2 0.23fF
C2009 divbuf_21/OUT5 divbuf_21/OUT 43.38fF
C2010 divider_2/prescaler_0/tspc_0/Z4 divider_2/clk 0.12fF
C2011 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z1 0.09fF
C2012 pd_0/REF pd_0/tspc_r_1/Z2 0.19fF
C2013 divbuf_12/a_492_n240# divbuf_12/OUT 0.00fF
C2014 pll_full_1/filter_0/a_4216_n5230# pll_full_1/divider_0/clk 1.58fF
C2015 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/a1 0.14fF
C2016 pll_full_1/ro_complete_0/cbank_0/switch_2/vin pll_full_1/ro_complete_0/a3 0.09fF
C2017 divider_0/tspc_1/Z1 divider_0/tspc_1/Z2 1.07fF
C2018 divider_0/nor_0/B divider_0/tspc_1/Z3 0.38fF
C2019 divider_0/tspc_1/Q divider_0/nor_1/B 0.22fF
C2020 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/v 1.30fF
C2021 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/cbank_0/v 1.30fF
C2022 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/nand_0/z1 0.01fF
C2023 divbuf_3/OUT2 divbuf_3/OUT5 0.02fF
C2024 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/a0 0.09fF
C2025 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT3 1.37fF
C2026 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C2027 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/a_630_n680# 0.01fF
C2028 divbuf_6/IN divbuf_6/OUT5 0.00fF
C2029 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_2/Q 0.01fF
C2030 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/a_630_n680# 0.35fF
C2031 pll_full_0/ro_complete_0/a1 pll_full_0/divider_0/clk 0.11fF
C2032 divider_1/nor_0/Z1 divider_1/and_0/B 0.18fF
C2033 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Q 0.15fF
C2034 divider_1/prescaler_0/tspc_0/Z2 divider_1/and_0/OUT 0.06fF
C2035 divbuf_11/a_492_n240# divbuf_11/IN 0.13fF
C2036 pd_1/R pd_1/tspc_r_0/Z3 0.27fF
C2037 divbuf_23/OUT4 divbuf_23/OUT 1.11fF
C2038 pll_full_1/ro_complete_0/cbank_0/switch_5/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
Xpd_0 vdda1 vssa1 pd_0/REF pd_0/DIV pd_0/UP pd_0/DOWN pd_0/R pd
Xpd_1 vdda1 vssa1 pd_1/REF pd_1/DIV pd_1/UP pd_1/DOWN pd_1/R pd
Xcp_0 cp_0/vbias vdda1 gnd cp_0/out cp_0/down cp_0/upbar cp
Xfilter_0 vssa1 filter_0/v filter
Xro_complete_0 divbuf_7/OUT divbuf_6/OUT divbuf_2/OUT divbuf_4/OUT divbuf_3/OUT divbuf_5/OUT
+ ro_complete
Xdivbuf_0 vdda1 divbuf_0/IN divbuf_0/OUT divbuf_0/OUT2 divbuf_0/OUT3 divbuf_0/OUT4
+ divbuf_0/OUT5 gnd divbuf
Xro_complete_1 ro_complete_1/a0 ro_complete_1/a1 ro_complete_1/a5 ro_complete_1/a4
+ ro_complete_1/a3 ro_complete_1/a2 ro_complete
Xdivbuf_1 vdda1 divbuf_1/IN divbuf_1/OUT divbuf_1/OUT2 divbuf_1/OUT3 divbuf_1/OUT4
+ divbuf_1/OUT5 gnd divbuf
Xdivbuf_2 vdda1 divbuf_2/IN divbuf_2/OUT divbuf_2/OUT2 divbuf_2/OUT3 divbuf_2/OUT4
+ divbuf_2/OUT5 gnd divbuf
Xdivbuf_3 vdda1 divbuf_3/IN divbuf_3/OUT divbuf_3/OUT2 divbuf_3/OUT3 divbuf_3/OUT4
+ divbuf_3/OUT5 gnd divbuf
Xdivbuf_4 vdda1 divbuf_4/IN divbuf_4/OUT divbuf_4/OUT2 divbuf_4/OUT3 divbuf_4/OUT4
+ divbuf_4/OUT5 gnd divbuf
Xdivbuf_5 vdda1 divbuf_5/IN divbuf_5/OUT divbuf_5/OUT2 divbuf_5/OUT3 divbuf_5/OUT4
+ divbuf_5/OUT5 gnd divbuf
Xdivbuf_6 vdda1 divbuf_6/IN divbuf_6/OUT divbuf_6/OUT2 divbuf_6/OUT3 divbuf_6/OUT4
+ divbuf_6/OUT5 gnd divbuf
Xdivbuf_10 vdda1 divbuf_10/IN divbuf_10/OUT divbuf_10/OUT2 divbuf_10/OUT3 divbuf_10/OUT4
+ divbuf_10/OUT5 gnd divbuf
Xdivbuf_20 vdda1 divbuf_20/IN divbuf_20/OUT divbuf_20/OUT2 divbuf_20/OUT3 divbuf_20/OUT4
+ divbuf_20/OUT5 vssa1 divbuf
Xdivbuf_21 vdda1 divbuf_21/IN divbuf_21/OUT divbuf_21/OUT2 divbuf_21/OUT3 divbuf_21/OUT4
+ divbuf_21/OUT5 vssa1 divbuf
Xdivbuf_7 vdda1 divbuf_7/IN divbuf_7/OUT divbuf_7/OUT2 divbuf_7/OUT3 divbuf_7/OUT4
+ divbuf_7/OUT5 gnd divbuf
Xdivbuf_11 vdda1 divbuf_11/IN divbuf_11/OUT divbuf_11/OUT2 divbuf_11/OUT3 divbuf_11/OUT4
+ divbuf_11/OUT5 gnd divbuf
Xdivbuf_22 vdda1 divbuf_22/IN divbuf_22/OUT divbuf_22/OUT2 divbuf_22/OUT3 divbuf_22/OUT4
+ divbuf_22/OUT5 vssa1 divbuf
Xdivbuf_8 vdda1 divbuf_8/IN divbuf_8/OUT divbuf_8/OUT2 divbuf_8/OUT3 divbuf_8/OUT4
+ divbuf_8/OUT5 gnd divbuf
Xdivbuf_12 vdda1 divbuf_12/IN divbuf_12/OUT divbuf_12/OUT2 divbuf_12/OUT3 divbuf_12/OUT4
+ divbuf_12/OUT5 gnd divbuf
Xdivbuf_23 vdda1 divbuf_23/IN divbuf_23/OUT divbuf_23/OUT2 divbuf_23/OUT3 divbuf_23/OUT4
+ divbuf_23/OUT5 vssa1 divbuf
Xdivbuf_9 vdda1 divbuf_9/IN divbuf_9/OUT divbuf_9/OUT2 divbuf_9/OUT3 divbuf_9/OUT4
+ divbuf_9/OUT5 gnd divbuf
Xdivbuf_13 vdda1 divbuf_13/IN divbuf_13/OUT divbuf_13/OUT2 divbuf_13/OUT3 divbuf_13/OUT4
+ divbuf_13/OUT5 gnd divbuf
Xdivbuf_24 vdda1 divbuf_24/IN divbuf_24/OUT divbuf_24/OUT2 divbuf_24/OUT3 divbuf_24/OUT4
+ divbuf_24/OUT5 vssa1 divbuf
Xdivider_0 gnd vdd divider_0/Out divider_0/clk divider_0/mc2 divider
Xdivbuf_14 vdda1 divbuf_14/IN divbuf_14/OUT divbuf_14/OUT2 divbuf_14/OUT3 divbuf_14/OUT4
+ divbuf_14/OUT5 gnd divbuf
Xdivbuf_25 vdda1 divbuf_25/IN filter_0/v divbuf_25/OUT2 divbuf_25/OUT3 divbuf_25/OUT4
+ divbuf_25/OUT5 vssa1 divbuf
Xdivbuf_15 vdda1 divbuf_15/IN divbuf_15/OUT divbuf_15/OUT2 divbuf_15/OUT3 divbuf_15/OUT4
+ divbuf_15/OUT5 gnd divbuf
Xdivider_1 vssa1 vdda1 divider_1/Out divider_1/clk divider_1/mc2 divider
Xdivbuf_16 vdda1 divbuf_16/IN divbuf_16/OUT divbuf_16/OUT2 divbuf_16/OUT3 divbuf_16/OUT4
+ divbuf_16/OUT5 vssa1 divbuf
Xdivider_2 vssa1 vdda1 divider_2/Out divider_2/clk divider_2/mc2 divider
Xdivbuf_17 vdda1 divbuf_17/IN divbuf_17/OUT divbuf_17/OUT2 divbuf_17/OUT3 divbuf_17/OUT4
+ divbuf_17/OUT5 vssa1 divbuf
Xdivbuf_18 vdda1 divbuf_18/IN divbuf_18/OUT divbuf_18/OUT2 divbuf_18/OUT3 divbuf_18/OUT4
+ divbuf_18/OUT5 vssa1 divbuf
Xdivbuf_19 vdda1 divbuf_19/IN divbuf_19/OUT divbuf_19/OUT2 divbuf_19/OUT3 divbuf_19/OUT4
+ divbuf_19/OUT5 vssa1 divbuf
Xpll_full_0 vdda1 pll_full
Xpll_full_1 vdda1 pll_full
C2039 io_analog[4] vssa1 43.96fF
C2040 io_analog[5] vssa1 44.13fF
C2041 io_analog[6] vssa1 43.46fF
C2042 io_in_3v3[0] vssa1 0.61fF
C2043 io_oeb[26] vssa1 0.61fF
C2044 io_in[0] vssa1 0.61fF
C2045 io_out[26] vssa1 0.61fF
C2046 io_out[0] vssa1 0.61fF
C2047 io_in[26] vssa1 0.61fF
C2048 io_oeb[0] vssa1 0.61fF
C2049 io_in_3v3[26] vssa1 0.61fF
C2050 io_in_3v3[1] vssa1 0.61fF
C2051 io_oeb[25] vssa1 0.61fF
C2052 io_in[1] vssa1 0.61fF
C2053 io_out[25] vssa1 0.61fF
C2054 io_out[1] vssa1 0.61fF
C2055 io_in[25] vssa1 0.61fF
C2056 io_oeb[1] vssa1 0.61fF
C2057 io_in_3v3[25] vssa1 0.61fF
C2058 io_in_3v3[2] vssa1 0.61fF
C2059 io_oeb[24] vssa1 0.61fF
C2060 io_in[2] vssa1 0.61fF
C2061 io_out[24] vssa1 0.61fF
C2062 io_out[2] vssa1 0.61fF
C2063 io_in[24] vssa1 0.61fF
C2064 io_oeb[2] vssa1 0.61fF
C2065 io_in_3v3[24] vssa1 0.61fF
C2066 io_in_3v3[3] vssa1 0.61fF
C2067 io_in[3] vssa1 0.61fF
C2068 gpio_noesd[17] vssa1 2.32fF
C2069 gpio_analog[17] vssa1 2.30fF
C2070 io_out[3] vssa1 0.61fF
C2071 io_oeb[3] vssa1 0.61fF
C2072 io_in_3v3[4] vssa1 0.61fF
C2073 io_in[4] vssa1 0.61fF
C2074 io_out[4] vssa1 0.61fF
C2075 io_oeb[4] vssa1 0.61fF
C2076 io_oeb[23] vssa1 0.61fF
C2077 io_out[23] vssa1 0.61fF
C2078 io_in[23] vssa1 0.61fF
C2079 io_in_3v3[23] vssa1 0.61fF
C2080 gpio_noesd[16] vssa1 2.30fF
C2081 gpio_analog[16] vssa1 2.30fF
C2082 io_in_3v3[5] vssa1 0.61fF
C2083 io_in[5] vssa1 0.61fF
C2084 io_out[5] vssa1 0.61fF
C2085 io_oeb[5] vssa1 0.61fF
C2086 io_oeb[22] vssa1 0.61fF
C2087 io_out[22] vssa1 0.61fF
C2088 io_in[22] vssa1 0.61fF
C2089 io_in_3v3[22] vssa1 0.61fF
C2090 gpio_noesd[15] vssa1 2.31fF
C2091 gpio_analog[15] vssa1 2.30fF
C2092 io_in_3v3[6] vssa1 0.61fF
C2093 io_in[6] vssa1 0.61fF
C2094 io_out[6] vssa1 0.61fF
C2095 io_oeb[6] vssa1 0.61fF
C2096 io_oeb[21] vssa1 0.61fF
C2097 io_out[21] vssa1 0.61fF
C2098 io_in[21] vssa1 0.61fF
C2099 io_in_3v3[21] vssa1 0.61fF
C2100 gpio_noesd[14] vssa1 2.30fF
C2101 gpio_analog[14] vssa1 2.29fF
C2102 vssd2 vssa1 38.54fF
C2103 vssd1 vssa1 13.04fF
C2104 vdda2 vssa1 38.30fF
C2105 io_oeb[20] vssa1 0.61fF
C2106 io_out[20] vssa1 0.61fF
C2107 io_in[20] vssa1 0.61fF
C2108 io_in_3v3[20] vssa1 0.61fF
C2109 gpio_noesd[13] vssa1 2.31fF
C2110 gpio_analog[13] vssa1 2.30fF
C2111 gpio_analog[0] vssa1 0.61fF
C2112 gpio_noesd[0] vssa1 0.61fF
C2113 io_in_3v3[7] vssa1 0.61fF
C2114 io_in[7] vssa1 0.61fF
C2115 io_out[7] vssa1 0.61fF
C2116 io_oeb[7] vssa1 0.61fF
C2117 io_oeb[19] vssa1 0.61fF
C2118 io_out[19] vssa1 0.61fF
C2119 io_in[19] vssa1 0.61fF
C2120 io_in_3v3[19] vssa1 0.61fF
C2121 gpio_noesd[12] vssa1 2.32fF
C2122 gpio_analog[12] vssa1 2.30fF
C2123 gpio_analog[1] vssa1 0.61fF
C2124 gpio_noesd[1] vssa1 0.61fF
C2125 io_in_3v3[8] vssa1 0.61fF
C2126 io_in[8] vssa1 0.61fF
C2127 io_out[8] vssa1 0.61fF
C2128 io_oeb[8] vssa1 0.61fF
C2129 io_oeb[18] vssa1 0.61fF
C2130 io_out[18] vssa1 0.61fF
C2131 io_in[18] vssa1 0.61fF
C2132 io_in_3v3[18] vssa1 0.61fF
C2133 gpio_noesd[11] vssa1 2.30fF
C2134 gpio_analog[11] vssa1 2.29fF
C2135 gpio_analog[2] vssa1 0.61fF
C2136 gpio_noesd[2] vssa1 0.61fF
C2137 io_in_3v3[9] vssa1 0.61fF
C2138 io_in[9] vssa1 0.61fF
C2139 io_out[9] vssa1 0.61fF
C2140 io_oeb[9] vssa1 0.61fF
C2141 io_oeb[17] vssa1 0.61fF
C2142 io_out[17] vssa1 0.61fF
C2143 io_in[17] vssa1 0.61fF
C2144 io_in_3v3[17] vssa1 0.61fF
C2145 gpio_noesd[10] vssa1 2.31fF
C2146 gpio_analog[10] vssa1 2.29fF
C2147 gpio_analog[3] vssa1 0.61fF
C2148 gpio_noesd[3] vssa1 0.61fF
C2149 io_in_3v3[10] vssa1 0.61fF
C2150 io_in[10] vssa1 0.61fF
C2151 io_out[10] vssa1 0.61fF
C2152 io_oeb[10] vssa1 0.61fF
C2153 io_oeb[16] vssa1 0.61fF
C2154 io_out[16] vssa1 0.61fF
C2155 io_in[16] vssa1 0.61fF
C2156 io_in_3v3[16] vssa1 0.61fF
C2157 gpio_noesd[9] vssa1 2.28fF
C2158 gpio_analog[9] vssa1 2.28fF
C2159 gpio_analog[4] vssa1 0.61fF
C2160 gpio_noesd[4] vssa1 0.61fF
C2161 io_in_3v3[11] vssa1 0.61fF
C2162 io_in[11] vssa1 0.61fF
C2163 io_out[11] vssa1 0.61fF
C2164 io_oeb[11] vssa1 0.61fF
C2165 io_oeb[15] vssa1 0.61fF
C2166 io_out[15] vssa1 0.61fF
C2167 io_in[15] vssa1 0.61fF
C2168 io_in_3v3[15] vssa1 0.61fF
C2169 gpio_noesd[8] vssa1 2.28fF
C2170 gpio_analog[8] vssa1 2.26fF
C2171 gpio_analog[5] vssa1 0.61fF
C2172 gpio_noesd[5] vssa1 0.61fF
C2173 io_in_3v3[12] vssa1 0.61fF
C2174 io_in[12] vssa1 0.61fF
C2175 io_out[12] vssa1 0.61fF
C2176 io_oeb[12] vssa1 0.61fF
C2177 io_oeb[14] vssa1 0.61fF
C2178 io_out[14] vssa1 0.61fF
C2179 io_in[14] vssa1 0.61fF
C2180 io_in_3v3[14] vssa1 0.61fF
C2181 gpio_noesd[7] vssa1 2.30fF
C2182 gpio_analog[7] vssa1 2.28fF
C2183 vssa2 vssa1 38.35fF
C2184 gpio_analog[6] vssa1 5.71fF
C2185 gpio_noesd[6] vssa1 5.70fF
C2186 io_in_3v3[13] vssa1 0.61fF
C2187 io_in[13] vssa1 0.61fF
C2188 io_out[13] vssa1 0.61fF
C2189 io_oeb[13] vssa1 0.61fF
C2190 vccd1 vssa1 39.84fF
C2191 vccd2 vssa1 38.46fF
C2192 io_analog[0] vssa1 19.99fF
C2193 io_analog[10] vssa1 19.36fF
C2194 io_analog[1] vssa1 13.17fF
C2195 io_analog[2] vssa1 12.57fF
C2196 io_analog[3] vssa1 12.83fF
C2197 io_clamp_high[0] vssa1 3.58fF
C2198 io_clamp_low[0] vssa1 3.58fF
C2199 io_clamp_high[1] vssa1 3.58fF
C2200 io_clamp_low[1] vssa1 3.58fF
C2201 io_clamp_high[2] vssa1 3.58fF
C2202 io_clamp_low[2] vssa1 3.58fF
C2203 io_analog[7] vssa1 12.74fF
C2204 io_analog[8] vssa1 13.08fF
C2205 io_analog[9] vssa1 13.08fF
C2206 user_irq[2] vssa1 0.63fF
C2207 user_irq[1] vssa1 0.63fF
C2208 user_irq[0] vssa1 0.63fF
C2209 user_clock2 vssa1 0.63fF
C2210 la_oenb[127] vssa1 0.63fF
C2211 la_data_out[127] vssa1 0.63fF
C2212 la_data_in[127] vssa1 0.63fF
C2213 la_oenb[126] vssa1 0.63fF
C2214 la_data_out[126] vssa1 0.63fF
C2215 la_data_in[126] vssa1 0.63fF
C2216 la_oenb[125] vssa1 0.63fF
C2217 la_data_out[125] vssa1 0.63fF
C2218 la_data_in[125] vssa1 0.63fF
C2219 la_oenb[124] vssa1 0.63fF
C2220 la_data_out[124] vssa1 0.63fF
C2221 la_data_in[124] vssa1 0.63fF
C2222 la_oenb[123] vssa1 0.63fF
C2223 la_data_out[123] vssa1 0.63fF
C2224 la_data_in[123] vssa1 0.63fF
C2225 la_oenb[122] vssa1 0.63fF
C2226 la_data_out[122] vssa1 0.63fF
C2227 la_data_in[122] vssa1 0.63fF
C2228 la_oenb[121] vssa1 0.63fF
C2229 la_data_out[121] vssa1 0.63fF
C2230 la_data_in[121] vssa1 0.63fF
C2231 la_oenb[120] vssa1 0.63fF
C2232 la_data_out[120] vssa1 0.63fF
C2233 la_data_in[120] vssa1 0.63fF
C2234 la_oenb[119] vssa1 0.63fF
C2235 la_data_out[119] vssa1 0.63fF
C2236 la_data_in[119] vssa1 0.63fF
C2237 la_oenb[118] vssa1 0.63fF
C2238 la_data_out[118] vssa1 0.63fF
C2239 la_data_in[118] vssa1 0.63fF
C2240 la_oenb[117] vssa1 0.63fF
C2241 la_data_out[117] vssa1 0.63fF
C2242 la_data_in[117] vssa1 0.63fF
C2243 la_oenb[116] vssa1 0.63fF
C2244 la_data_out[116] vssa1 0.63fF
C2245 la_data_in[116] vssa1 0.63fF
C2246 la_oenb[115] vssa1 0.63fF
C2247 la_data_out[115] vssa1 0.63fF
C2248 la_data_in[115] vssa1 0.63fF
C2249 la_oenb[114] vssa1 0.63fF
C2250 la_data_out[114] vssa1 0.63fF
C2251 la_data_in[114] vssa1 0.63fF
C2252 la_oenb[113] vssa1 0.63fF
C2253 la_data_out[113] vssa1 0.63fF
C2254 la_data_in[113] vssa1 0.63fF
C2255 la_oenb[112] vssa1 0.63fF
C2256 la_data_out[112] vssa1 0.63fF
C2257 la_data_in[112] vssa1 0.63fF
C2258 la_oenb[111] vssa1 0.63fF
C2259 la_data_out[111] vssa1 0.63fF
C2260 la_data_in[111] vssa1 0.63fF
C2261 la_oenb[110] vssa1 0.63fF
C2262 la_data_out[110] vssa1 0.63fF
C2263 la_data_in[110] vssa1 0.63fF
C2264 la_oenb[109] vssa1 0.63fF
C2265 la_data_out[109] vssa1 0.63fF
C2266 la_data_in[109] vssa1 0.63fF
C2267 la_oenb[108] vssa1 0.63fF
C2268 la_data_out[108] vssa1 0.63fF
C2269 la_data_in[108] vssa1 0.63fF
C2270 la_oenb[107] vssa1 0.63fF
C2271 la_data_out[107] vssa1 0.63fF
C2272 la_data_in[107] vssa1 0.63fF
C2273 la_oenb[106] vssa1 0.63fF
C2274 la_data_out[106] vssa1 0.63fF
C2275 la_data_in[106] vssa1 0.63fF
C2276 la_oenb[105] vssa1 0.63fF
C2277 la_data_out[105] vssa1 0.63fF
C2278 la_data_in[105] vssa1 0.63fF
C2279 la_oenb[104] vssa1 0.63fF
C2280 la_data_out[104] vssa1 0.63fF
C2281 la_data_in[104] vssa1 0.63fF
C2282 la_oenb[103] vssa1 0.63fF
C2283 la_data_out[103] vssa1 0.63fF
C2284 la_data_in[103] vssa1 0.63fF
C2285 la_oenb[102] vssa1 0.63fF
C2286 la_data_out[102] vssa1 0.63fF
C2287 la_data_in[102] vssa1 0.63fF
C2288 la_oenb[101] vssa1 0.63fF
C2289 la_data_out[101] vssa1 0.63fF
C2290 la_data_in[101] vssa1 0.63fF
C2291 la_oenb[100] vssa1 0.63fF
C2292 la_data_out[100] vssa1 0.63fF
C2293 la_data_in[100] vssa1 0.63fF
C2294 la_oenb[99] vssa1 0.63fF
C2295 la_data_out[99] vssa1 0.63fF
C2296 la_data_in[99] vssa1 0.63fF
C2297 la_oenb[98] vssa1 0.63fF
C2298 la_data_out[98] vssa1 0.63fF
C2299 la_data_in[98] vssa1 0.63fF
C2300 la_oenb[97] vssa1 0.63fF
C2301 la_data_out[97] vssa1 0.63fF
C2302 la_data_in[97] vssa1 0.63fF
C2303 la_oenb[96] vssa1 0.63fF
C2304 la_data_out[96] vssa1 0.63fF
C2305 la_data_in[96] vssa1 0.63fF
C2306 la_oenb[95] vssa1 0.63fF
C2307 la_data_out[95] vssa1 0.63fF
C2308 la_data_in[95] vssa1 0.63fF
C2309 la_oenb[94] vssa1 0.63fF
C2310 la_data_out[94] vssa1 0.63fF
C2311 la_data_in[94] vssa1 0.63fF
C2312 la_oenb[93] vssa1 0.63fF
C2313 la_data_out[93] vssa1 0.63fF
C2314 la_data_in[93] vssa1 0.63fF
C2315 la_oenb[92] vssa1 0.63fF
C2316 la_data_out[92] vssa1 0.63fF
C2317 la_data_in[92] vssa1 0.63fF
C2318 la_oenb[91] vssa1 0.63fF
C2319 la_data_out[91] vssa1 0.63fF
C2320 la_data_in[91] vssa1 0.63fF
C2321 la_oenb[90] vssa1 0.63fF
C2322 la_data_out[90] vssa1 0.63fF
C2323 la_data_in[90] vssa1 0.63fF
C2324 la_oenb[89] vssa1 0.63fF
C2325 la_data_out[89] vssa1 0.63fF
C2326 la_data_in[89] vssa1 0.63fF
C2327 la_oenb[88] vssa1 0.63fF
C2328 la_data_out[88] vssa1 0.63fF
C2329 la_data_in[88] vssa1 0.63fF
C2330 la_oenb[87] vssa1 0.63fF
C2331 la_data_out[87] vssa1 0.63fF
C2332 la_data_in[87] vssa1 0.63fF
C2333 la_oenb[86] vssa1 0.63fF
C2334 la_data_out[86] vssa1 0.63fF
C2335 la_data_in[86] vssa1 0.63fF
C2336 la_oenb[85] vssa1 0.63fF
C2337 la_data_out[85] vssa1 0.63fF
C2338 la_data_in[85] vssa1 0.63fF
C2339 la_oenb[84] vssa1 0.63fF
C2340 la_data_out[84] vssa1 0.63fF
C2341 la_data_in[84] vssa1 0.63fF
C2342 la_oenb[83] vssa1 0.63fF
C2343 la_data_out[83] vssa1 0.63fF
C2344 la_data_in[83] vssa1 0.63fF
C2345 la_oenb[82] vssa1 0.63fF
C2346 la_data_out[82] vssa1 0.63fF
C2347 la_data_in[82] vssa1 0.63fF
C2348 la_oenb[81] vssa1 0.63fF
C2349 la_data_out[81] vssa1 0.63fF
C2350 la_data_in[81] vssa1 0.63fF
C2351 la_oenb[80] vssa1 0.63fF
C2352 la_data_out[80] vssa1 0.63fF
C2353 la_data_in[80] vssa1 0.63fF
C2354 la_oenb[79] vssa1 0.63fF
C2355 la_data_out[79] vssa1 0.63fF
C2356 la_data_in[79] vssa1 0.63fF
C2357 la_oenb[78] vssa1 0.63fF
C2358 la_data_out[78] vssa1 0.63fF
C2359 la_data_in[78] vssa1 0.63fF
C2360 la_oenb[77] vssa1 0.63fF
C2361 la_data_out[77] vssa1 0.63fF
C2362 la_data_in[77] vssa1 0.63fF
C2363 la_oenb[76] vssa1 0.63fF
C2364 la_data_out[76] vssa1 0.63fF
C2365 la_data_in[76] vssa1 0.63fF
C2366 la_oenb[75] vssa1 0.63fF
C2367 la_data_out[75] vssa1 0.63fF
C2368 la_data_in[75] vssa1 0.63fF
C2369 la_oenb[74] vssa1 0.63fF
C2370 la_data_out[74] vssa1 0.63fF
C2371 la_data_in[74] vssa1 0.63fF
C2372 la_oenb[73] vssa1 0.63fF
C2373 la_data_out[73] vssa1 0.63fF
C2374 la_data_in[73] vssa1 0.63fF
C2375 la_oenb[72] vssa1 0.63fF
C2376 la_data_out[72] vssa1 0.63fF
C2377 la_data_in[72] vssa1 0.63fF
C2378 la_oenb[71] vssa1 0.63fF
C2379 la_data_out[71] vssa1 0.63fF
C2380 la_data_in[71] vssa1 0.63fF
C2381 la_oenb[70] vssa1 0.63fF
C2382 la_data_out[70] vssa1 0.63fF
C2383 la_data_in[70] vssa1 0.63fF
C2384 la_oenb[69] vssa1 0.63fF
C2385 la_data_out[69] vssa1 0.63fF
C2386 la_data_in[69] vssa1 0.63fF
C2387 la_oenb[68] vssa1 0.63fF
C2388 la_data_out[68] vssa1 0.63fF
C2389 la_data_in[68] vssa1 0.63fF
C2390 la_oenb[67] vssa1 0.63fF
C2391 la_data_out[67] vssa1 0.63fF
C2392 la_data_in[67] vssa1 0.63fF
C2393 la_oenb[66] vssa1 0.63fF
C2394 la_data_out[66] vssa1 0.63fF
C2395 la_data_in[66] vssa1 0.63fF
C2396 la_oenb[65] vssa1 0.63fF
C2397 la_data_out[65] vssa1 0.63fF
C2398 la_data_in[65] vssa1 0.63fF
C2399 la_oenb[64] vssa1 0.63fF
C2400 la_data_out[64] vssa1 0.63fF
C2401 la_data_in[64] vssa1 0.63fF
C2402 la_oenb[63] vssa1 0.63fF
C2403 la_data_out[63] vssa1 0.63fF
C2404 la_data_in[63] vssa1 0.63fF
C2405 la_oenb[62] vssa1 0.63fF
C2406 la_data_out[62] vssa1 0.63fF
C2407 la_data_in[62] vssa1 0.63fF
C2408 la_oenb[61] vssa1 0.63fF
C2409 la_data_out[61] vssa1 0.63fF
C2410 la_data_in[61] vssa1 0.63fF
C2411 la_oenb[60] vssa1 0.63fF
C2412 la_data_out[60] vssa1 0.63fF
C2413 la_data_in[60] vssa1 0.63fF
C2414 la_oenb[59] vssa1 0.63fF
C2415 la_data_out[59] vssa1 0.63fF
C2416 la_data_in[59] vssa1 0.63fF
C2417 la_oenb[58] vssa1 0.63fF
C2418 la_data_out[58] vssa1 0.63fF
C2419 la_data_in[58] vssa1 0.63fF
C2420 la_oenb[57] vssa1 0.63fF
C2421 la_data_out[57] vssa1 0.63fF
C2422 la_data_in[57] vssa1 0.63fF
C2423 la_oenb[56] vssa1 0.63fF
C2424 la_data_out[56] vssa1 0.63fF
C2425 la_data_in[56] vssa1 0.63fF
C2426 la_oenb[55] vssa1 0.63fF
C2427 la_data_out[55] vssa1 0.63fF
C2428 la_data_in[55] vssa1 0.63fF
C2429 la_oenb[54] vssa1 0.63fF
C2430 la_data_out[54] vssa1 0.63fF
C2431 la_data_in[54] vssa1 0.63fF
C2432 la_oenb[53] vssa1 0.63fF
C2433 la_data_out[53] vssa1 0.63fF
C2434 la_data_in[53] vssa1 0.63fF
C2435 la_oenb[52] vssa1 0.63fF
C2436 la_data_out[52] vssa1 0.63fF
C2437 la_data_in[52] vssa1 0.63fF
C2438 la_oenb[51] vssa1 0.63fF
C2439 la_data_out[51] vssa1 0.63fF
C2440 la_data_in[51] vssa1 0.63fF
C2441 la_oenb[50] vssa1 0.63fF
C2442 la_data_out[50] vssa1 0.63fF
C2443 la_data_in[50] vssa1 0.63fF
C2444 la_oenb[49] vssa1 0.63fF
C2445 la_data_out[49] vssa1 0.63fF
C2446 la_data_in[49] vssa1 0.63fF
C2447 la_oenb[48] vssa1 0.63fF
C2448 la_data_out[48] vssa1 0.63fF
C2449 la_data_in[48] vssa1 0.63fF
C2450 la_oenb[47] vssa1 0.63fF
C2451 la_data_out[47] vssa1 0.63fF
C2452 la_data_in[47] vssa1 0.63fF
C2453 la_oenb[46] vssa1 0.63fF
C2454 la_data_out[46] vssa1 0.63fF
C2455 la_data_in[46] vssa1 0.63fF
C2456 la_oenb[45] vssa1 0.63fF
C2457 la_data_out[45] vssa1 0.63fF
C2458 la_data_in[45] vssa1 0.63fF
C2459 la_oenb[44] vssa1 0.63fF
C2460 la_data_out[44] vssa1 0.63fF
C2461 la_data_in[44] vssa1 0.63fF
C2462 la_oenb[43] vssa1 0.63fF
C2463 la_data_out[43] vssa1 0.63fF
C2464 la_data_in[43] vssa1 0.63fF
C2465 la_oenb[42] vssa1 0.63fF
C2466 la_data_out[42] vssa1 0.63fF
C2467 la_data_in[42] vssa1 0.63fF
C2468 la_oenb[41] vssa1 0.63fF
C2469 la_data_out[41] vssa1 0.63fF
C2470 la_data_in[41] vssa1 0.63fF
C2471 la_oenb[40] vssa1 0.63fF
C2472 la_data_out[40] vssa1 0.63fF
C2473 la_data_in[40] vssa1 0.63fF
C2474 la_oenb[39] vssa1 0.63fF
C2475 la_data_out[39] vssa1 0.63fF
C2476 la_data_in[39] vssa1 0.63fF
C2477 la_oenb[38] vssa1 0.63fF
C2478 la_data_out[38] vssa1 0.63fF
C2479 la_data_in[38] vssa1 0.63fF
C2480 la_oenb[37] vssa1 0.63fF
C2481 la_data_out[37] vssa1 0.63fF
C2482 la_data_in[37] vssa1 0.63fF
C2483 la_oenb[36] vssa1 0.63fF
C2484 la_data_out[36] vssa1 0.63fF
C2485 la_data_in[36] vssa1 0.63fF
C2486 la_oenb[35] vssa1 0.63fF
C2487 la_data_out[35] vssa1 0.63fF
C2488 la_data_in[35] vssa1 0.63fF
C2489 la_oenb[34] vssa1 0.63fF
C2490 la_data_out[34] vssa1 0.63fF
C2491 la_data_in[34] vssa1 0.63fF
C2492 la_oenb[33] vssa1 0.63fF
C2493 la_data_out[33] vssa1 0.63fF
C2494 la_data_in[33] vssa1 0.63fF
C2495 la_oenb[32] vssa1 0.63fF
C2496 la_data_out[32] vssa1 0.63fF
C2497 la_data_in[32] vssa1 0.63fF
C2498 la_oenb[31] vssa1 0.63fF
C2499 la_data_out[31] vssa1 0.63fF
C2500 la_data_in[31] vssa1 0.63fF
C2501 la_oenb[30] vssa1 0.63fF
C2502 la_data_out[30] vssa1 0.63fF
C2503 la_data_in[30] vssa1 0.63fF
C2504 la_oenb[29] vssa1 0.63fF
C2505 la_data_out[29] vssa1 0.63fF
C2506 la_data_in[29] vssa1 0.63fF
C2507 la_oenb[28] vssa1 0.63fF
C2508 la_data_out[28] vssa1 0.63fF
C2509 la_data_in[28] vssa1 0.63fF
C2510 la_oenb[27] vssa1 0.63fF
C2511 la_data_out[27] vssa1 0.63fF
C2512 la_data_in[27] vssa1 0.63fF
C2513 la_oenb[26] vssa1 0.63fF
C2514 la_data_out[26] vssa1 0.63fF
C2515 la_data_in[26] vssa1 0.63fF
C2516 la_oenb[25] vssa1 0.63fF
C2517 la_data_out[25] vssa1 0.63fF
C2518 la_data_in[25] vssa1 0.63fF
C2519 la_oenb[24] vssa1 0.63fF
C2520 la_data_out[24] vssa1 0.63fF
C2521 la_data_in[24] vssa1 0.63fF
C2522 la_oenb[23] vssa1 0.63fF
C2523 la_data_out[23] vssa1 0.63fF
C2524 la_data_in[23] vssa1 0.63fF
C2525 la_oenb[22] vssa1 0.63fF
C2526 la_data_out[22] vssa1 0.63fF
C2527 la_data_in[22] vssa1 0.63fF
C2528 la_oenb[21] vssa1 0.63fF
C2529 la_data_out[21] vssa1 0.63fF
C2530 la_data_in[21] vssa1 0.63fF
C2531 la_oenb[20] vssa1 0.63fF
C2532 la_data_out[20] vssa1 0.63fF
C2533 la_data_in[20] vssa1 0.63fF
C2534 la_oenb[19] vssa1 0.63fF
C2535 la_data_out[19] vssa1 0.63fF
C2536 la_data_in[19] vssa1 0.63fF
C2537 la_oenb[18] vssa1 0.63fF
C2538 la_data_out[18] vssa1 0.63fF
C2539 la_data_in[18] vssa1 0.63fF
C2540 la_oenb[17] vssa1 0.63fF
C2541 la_data_out[17] vssa1 0.63fF
C2542 la_data_in[17] vssa1 0.63fF
C2543 la_oenb[16] vssa1 0.63fF
C2544 la_data_out[16] vssa1 0.63fF
C2545 la_data_in[16] vssa1 0.63fF
C2546 la_oenb[15] vssa1 0.63fF
C2547 la_data_out[15] vssa1 0.63fF
C2548 la_data_in[15] vssa1 0.63fF
C2549 la_oenb[14] vssa1 0.63fF
C2550 la_data_out[14] vssa1 0.63fF
C2551 la_data_in[14] vssa1 0.63fF
C2552 la_oenb[13] vssa1 0.63fF
C2553 la_data_out[13] vssa1 0.63fF
C2554 la_data_in[13] vssa1 0.63fF
C2555 la_oenb[12] vssa1 0.63fF
C2556 la_data_out[12] vssa1 0.63fF
C2557 la_data_in[12] vssa1 0.63fF
C2558 la_oenb[11] vssa1 0.63fF
C2559 la_data_out[11] vssa1 0.63fF
C2560 la_data_in[11] vssa1 0.63fF
C2561 la_oenb[10] vssa1 0.63fF
C2562 la_data_out[10] vssa1 0.63fF
C2563 la_data_in[10] vssa1 0.63fF
C2564 la_oenb[9] vssa1 0.63fF
C2565 la_data_out[9] vssa1 0.63fF
C2566 la_data_in[9] vssa1 0.63fF
C2567 la_oenb[8] vssa1 0.63fF
C2568 la_data_out[8] vssa1 0.63fF
C2569 la_data_in[8] vssa1 0.63fF
C2570 la_oenb[7] vssa1 0.63fF
C2571 la_data_out[7] vssa1 0.63fF
C2572 la_data_in[7] vssa1 0.63fF
C2573 la_oenb[6] vssa1 0.63fF
C2574 la_data_out[6] vssa1 0.63fF
C2575 la_data_in[6] vssa1 0.63fF
C2576 la_oenb[5] vssa1 0.63fF
C2577 la_data_out[5] vssa1 0.63fF
C2578 la_data_in[5] vssa1 0.63fF
C2579 la_oenb[4] vssa1 0.63fF
C2580 la_data_out[4] vssa1 0.63fF
C2581 la_data_in[4] vssa1 0.63fF
C2582 la_oenb[3] vssa1 0.63fF
C2583 la_data_out[3] vssa1 0.63fF
C2584 la_data_in[3] vssa1 0.63fF
C2585 la_oenb[2] vssa1 0.63fF
C2586 la_data_out[2] vssa1 0.63fF
C2587 la_data_in[2] vssa1 0.63fF
C2588 la_oenb[1] vssa1 0.63fF
C2589 la_data_out[1] vssa1 0.63fF
C2590 la_data_in[1] vssa1 0.63fF
C2591 la_oenb[0] vssa1 0.63fF
C2592 la_data_out[0] vssa1 0.63fF
C2593 la_data_in[0] vssa1 0.63fF
C2594 wbs_dat_o[31] vssa1 0.63fF
C2595 wbs_dat_i[31] vssa1 0.63fF
C2596 wbs_adr_i[31] vssa1 0.63fF
C2597 wbs_dat_o[30] vssa1 0.63fF
C2598 wbs_dat_i[30] vssa1 0.63fF
C2599 wbs_adr_i[30] vssa1 0.63fF
C2600 wbs_dat_o[29] vssa1 0.63fF
C2601 wbs_dat_i[29] vssa1 0.63fF
C2602 wbs_adr_i[29] vssa1 0.63fF
C2603 wbs_dat_o[28] vssa1 0.63fF
C2604 wbs_dat_i[28] vssa1 0.63fF
C2605 wbs_adr_i[28] vssa1 0.63fF
C2606 wbs_dat_o[27] vssa1 0.63fF
C2607 wbs_dat_i[27] vssa1 0.63fF
C2608 wbs_adr_i[27] vssa1 0.63fF
C2609 wbs_dat_o[26] vssa1 0.63fF
C2610 wbs_dat_i[26] vssa1 0.63fF
C2611 wbs_adr_i[26] vssa1 0.63fF
C2612 wbs_dat_o[25] vssa1 0.63fF
C2613 wbs_dat_i[25] vssa1 0.63fF
C2614 wbs_adr_i[25] vssa1 0.63fF
C2615 wbs_dat_o[24] vssa1 0.63fF
C2616 wbs_dat_i[24] vssa1 0.63fF
C2617 wbs_adr_i[24] vssa1 0.63fF
C2618 wbs_dat_o[23] vssa1 0.63fF
C2619 wbs_dat_i[23] vssa1 0.63fF
C2620 wbs_adr_i[23] vssa1 0.63fF
C2621 wbs_dat_o[22] vssa1 0.63fF
C2622 wbs_dat_i[22] vssa1 0.63fF
C2623 wbs_adr_i[22] vssa1 0.63fF
C2624 wbs_dat_o[21] vssa1 0.63fF
C2625 wbs_dat_i[21] vssa1 0.63fF
C2626 wbs_adr_i[21] vssa1 0.63fF
C2627 wbs_dat_o[20] vssa1 0.63fF
C2628 wbs_dat_i[20] vssa1 0.63fF
C2629 wbs_adr_i[20] vssa1 0.63fF
C2630 wbs_dat_o[19] vssa1 0.63fF
C2631 wbs_dat_i[19] vssa1 0.63fF
C2632 wbs_adr_i[19] vssa1 0.63fF
C2633 wbs_dat_o[18] vssa1 0.63fF
C2634 wbs_dat_i[18] vssa1 0.63fF
C2635 wbs_adr_i[18] vssa1 0.63fF
C2636 wbs_dat_o[17] vssa1 0.63fF
C2637 wbs_dat_i[17] vssa1 0.63fF
C2638 wbs_adr_i[17] vssa1 0.63fF
C2639 wbs_dat_o[16] vssa1 0.63fF
C2640 wbs_dat_i[16] vssa1 0.63fF
C2641 wbs_adr_i[16] vssa1 0.63fF
C2642 wbs_dat_o[15] vssa1 0.63fF
C2643 wbs_dat_i[15] vssa1 0.63fF
C2644 wbs_adr_i[15] vssa1 0.63fF
C2645 wbs_dat_o[14] vssa1 0.63fF
C2646 wbs_dat_i[14] vssa1 0.63fF
C2647 wbs_adr_i[14] vssa1 0.63fF
C2648 wbs_dat_o[13] vssa1 0.63fF
C2649 wbs_dat_i[13] vssa1 0.63fF
C2650 wbs_adr_i[13] vssa1 0.63fF
C2651 wbs_dat_o[12] vssa1 0.63fF
C2652 wbs_dat_i[12] vssa1 0.63fF
C2653 wbs_adr_i[12] vssa1 0.63fF
C2654 wbs_dat_o[11] vssa1 0.63fF
C2655 wbs_dat_i[11] vssa1 0.63fF
C2656 wbs_adr_i[11] vssa1 0.63fF
C2657 wbs_dat_o[10] vssa1 0.63fF
C2658 wbs_dat_i[10] vssa1 0.63fF
C2659 wbs_adr_i[10] vssa1 0.63fF
C2660 wbs_dat_o[9] vssa1 0.63fF
C2661 wbs_dat_i[9] vssa1 0.63fF
C2662 wbs_adr_i[9] vssa1 0.63fF
C2663 wbs_dat_o[8] vssa1 0.63fF
C2664 wbs_dat_i[8] vssa1 0.63fF
C2665 wbs_adr_i[8] vssa1 0.63fF
C2666 wbs_dat_o[7] vssa1 0.63fF
C2667 wbs_dat_i[7] vssa1 0.63fF
C2668 wbs_adr_i[7] vssa1 0.63fF
C2669 wbs_dat_o[6] vssa1 0.63fF
C2670 wbs_dat_i[6] vssa1 0.63fF
C2671 wbs_adr_i[6] vssa1 0.63fF
C2672 wbs_dat_o[5] vssa1 0.63fF
C2673 wbs_dat_i[5] vssa1 0.63fF
C2674 wbs_adr_i[5] vssa1 0.63fF
C2675 wbs_dat_o[4] vssa1 0.63fF
C2676 wbs_dat_i[4] vssa1 0.63fF
C2677 wbs_adr_i[4] vssa1 0.63fF
C2678 wbs_sel_i[3] vssa1 0.63fF
C2679 wbs_dat_o[3] vssa1 0.63fF
C2680 wbs_dat_i[3] vssa1 0.63fF
C2681 wbs_adr_i[3] vssa1 0.63fF
C2682 wbs_sel_i[2] vssa1 0.63fF
C2683 wbs_dat_o[2] vssa1 0.63fF
C2684 wbs_dat_i[2] vssa1 0.63fF
C2685 wbs_adr_i[2] vssa1 0.63fF
C2686 wbs_sel_i[1] vssa1 0.63fF
C2687 wbs_dat_o[1] vssa1 0.63fF
C2688 wbs_dat_i[1] vssa1 0.63fF
C2689 wbs_adr_i[1] vssa1 0.63fF
C2690 wbs_sel_i[0] vssa1 0.63fF
C2691 wbs_dat_o[0] vssa1 0.63fF
C2692 wbs_dat_i[0] vssa1 0.63fF
C2693 wbs_adr_i[0] vssa1 0.63fF
C2694 wbs_we_i vssa1 0.63fF
C2695 wbs_stb_i vssa1 0.63fF
C2696 wbs_cyc_i vssa1 0.63fF
C2697 wbs_ack_o vssa1 0.63fF
C2698 wb_rst_i vssa1 0.63fF
C2699 wb_clk_i vssa1 0.63fF
C2700 m2_494098_659718# vssa1 0.80fF **FLOATING
C2701 li_200624_47978# vssa1 61.68fF **FLOATING
C2702 li_534900_144658# vssa1 71.26fF **FLOATING
C2703 li_464674_144658# vssa1 72.10fF **FLOATING
C2704 li_379946_144658# vssa1 71.49fF **FLOATING
C2705 pll_full_1/divider_0/and_0/Z1 vssa1 0.65fF
C2706 pll_full_1/divider_0/and_0/B vssa1 2.45fF
C2707 pll_full_1/divider_0/and_0/A vssa1 2.35fF
C2708 pll_full_1/divider_0/and_0/out1 vssa1 2.99fF
C2709 pll_full_1/divider_0/tspc_2/Z4 vssa1 0.86fF
C2710 pll_full_1/divider_0/tspc_2/Z3 vssa1 2.26fF
C2711 pll_full_1/divider_0/tspc_2/Z2 vssa1 1.46fF
C2712 pll_full_1/divider_0/tspc_2/Z1 vssa1 0.99fF
C2713 pll_full_1/divider_0/nor_0/A vssa1 7.08fF
C2714 pll_full_1/divider_0/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C2715 pll_full_1/divider_0/tspc_1/Z4 vssa1 0.86fF
C2716 pll_full_1/divider_0/tspc_1/Z3 vssa1 2.26fF
C2717 pll_full_1/divider_0/tspc_1/Z2 vssa1 1.46fF
C2718 pll_full_1/divider_0/tspc_1/Z1 vssa1 0.99fF
C2719 pll_full_1/divider_0/nor_0/B vssa1 7.12fF
C2720 pll_full_1/divider_0/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C2721 pll_full_1/divider_0/tspc_2/Q vssa1 3.14fF
C2722 pll_full_1/divider_0/tspc_0/Z4 vssa1 0.86fF
C2723 pll_full_1/divbuf_0/IN vssa1 9.89fF
C2724 pll_full_1/divider_0/tspc_0/Z3 vssa1 2.26fF
C2725 pll_full_1/divider_0/tspc_0/Z2 vssa1 1.46fF
C2726 pll_full_1/divider_0/tspc_0/Z1 vssa1 0.99fF
C2727 pll_full_1/divider_0/nor_1/B vssa1 6.48fF
C2728 pll_full_1/divider_0/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C2729 pll_full_1/divider_0/tspc_1/Q vssa1 3.12fF
C2730 pll_full_1/divider_0/clk vssa1 33.42fF
C2731 pll_full_1/divider_0/prescaler_0/nand_1/z1 vssa1 0.36fF
C2732 pll_full_1/divider_0/prescaler_0/tspc_0/D vssa1 2.64fF
C2733 pll_full_1/divider_0/prescaler_0/tspc_2/Q vssa1 3.72fF
C2734 pll_full_1/divider_0/prescaler_0/tspc_1/Q vssa1 3.61fF
C2735 pll_full_1/divider_0/prescaler_0/nand_0/z1 vssa1 0.36fF
C2736 pll_full_1/divider_0/prescaler_0/tspc_2/D vssa1 3.12fF
C2737 pll_full_1/divider_0/and_0/OUT vssa1 5.67fF
C2738 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C2739 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C2740 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 vssa1 1.19fF
C2741 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C2742 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# vssa1 1.47fF **FLOATING
C2743 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C2744 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C2745 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C2746 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C2747 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C2748 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C2749 pll_full_1/divider_0/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C2750 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C2751 pll_full_1/divider_0/prescaler_0/Out vssa1 4.59fF
C2752 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C2753 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C2754 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C2755 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C2756 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C2757 pll_full_1/divider_0/nor_1/Z1 vssa1 1.34fF
C2758 pll_full_1/divider_0/nor_0/Z1 vssa1 1.34fF
C2759 pll_full_1/divbuf_1/OUT vssa1 363.82fF
C2760 pll_full_1/divbuf_1/OUT5 vssa1 350.37fF
C2761 pll_full_1/divbuf_1/OUT4 vssa1 133.72fF
C2762 pll_full_1/divbuf_1/OUT3 vssa1 34.03fF
C2763 pll_full_1/divbuf_1/OUT2 vssa1 8.71fF
C2764 pll_full_1/divbuf_1/a_492_n240# vssa1 2.46fF **FLOATING
C2765 pll_full_1/divbuf_0/OUT5 vssa1 350.37fF
C2766 pll_full_1/divbuf_0/OUT4 vssa1 133.72fF
C2767 pll_full_1/divbuf_0/OUT3 vssa1 34.03fF
C2768 pll_full_1/divbuf_0/OUT2 vssa1 8.71fF
C2769 pll_full_1/divbuf_0/a_492_n240# vssa1 2.46fF **FLOATING
C2770 pll_full_1/ro_complete_0/cbank_2/v vssa1 16.43fF
C2771 pll_full_1/ro_complete_0/cbank_2/switch_5/vin vssa1 0.78fF
C2772 pll_full_1/ro_complete_0/cbank_2/switch_4/vin vssa1 1.50fF
C2773 pll_full_1/ro_complete_0/cbank_2/switch_2/vin vssa1 1.30fF
C2774 pll_full_1/ro_complete_0/cbank_2/switch_3/vin vssa1 0.56fF
C2775 pll_full_1/ro_complete_0/cbank_2/switch_1/vin vssa1 1.14fF
C2776 pll_full_1/ro_complete_0/cbank_2/switch_0/vin vssa1 1.02fF
C2777 pll_full_1/ro_complete_0/cbank_1/switch_5/vin vssa1 0.78fF
C2778 pll_full_1/ro_complete_0/a0 vssa1 5.35fF
C2779 pll_full_1/ro_complete_0/cbank_1/switch_4/vin vssa1 1.50fF
C2780 pll_full_1/ro_complete_0/a1 vssa1 6.54fF
C2781 pll_full_1/ro_complete_0/cbank_1/switch_2/vin vssa1 1.30fF
C2782 pll_full_1/ro_complete_0/a3 vssa1 5.96fF
C2783 pll_full_1/ro_complete_0/cbank_1/switch_3/vin vssa1 0.56fF
C2784 pll_full_1/ro_complete_0/a2 vssa1 5.21fF
C2785 pll_full_1/ro_complete_0/cbank_1/switch_1/vin vssa1 1.14fF
C2786 pll_full_1/ro_complete_0/a4 vssa1 5.81fF
C2787 pll_full_1/ro_complete_0/cbank_1/switch_0/vin vssa1 1.02fF
C2788 pll_full_1/ro_complete_0/a5 vssa1 6.74fF
C2789 pll_full_1/ro_complete_0/cbank_0/v vssa1 15.12fF
C2790 pll_full_1/ro_complete_0/cbank_0/switch_5/vin vssa1 0.78fF
C2791 pll_full_1/ro_complete_0/cbank_0/switch_4/vin vssa1 1.50fF
C2792 pll_full_1/ro_complete_0/cbank_0/switch_2/vin vssa1 1.30fF
C2793 pll_full_1/ro_complete_0/cbank_0/switch_3/vin vssa1 0.56fF
C2794 pll_full_1/ro_complete_0/cbank_0/switch_1/vin vssa1 1.14fF
C2795 pll_full_1/ro_complete_0/cbank_0/switch_0/vin vssa1 1.02fF
C2796 pll_full_1/ro_complete_0/ro_var_extend_0/vcont vssa1 0.27fF
C2797 pll_full_1/filter_0/a_4216_n5230# vssa1 418.90fF **FLOATING
C2798 pll_full_1/filter_0/a_4216_n2998# vssa1 1.39fF **FLOATING
C2799 pll_full_1/cp_0/down vssa1 1.54fF
C2800 pll_full_1/cp_0/upbar vssa1 1.79fF
C2801 pll_full_1/cp_0/a_7110_n2840# vssa1 0.17fF **FLOATING
C2802 pll_full_1/cp_0/a_3060_n2840# vssa1 1.71fF **FLOATING
C2803 pll_full_1/cp_0/a_7110_0# vssa1 0.17fF **FLOATING
C2804 pll_full_1/cp_0/a_6370_0# vssa1 0.40fF **FLOATING
C2805 pll_full_1/cp_0/a_3060_0# vssa1 2.49fF **FLOATING
C2806 pll_full_1/cp_0/a_1710_0# vssa1 7.47fF **FLOATING
C2807 pll_full_1/pd_0/and_pd_0/Z1 vssa1 0.39fF
C2808 pll_full_1/pd_0/and_pd_0/Out1 vssa1 2.22fF
C2809 pll_full_1/pd_0/tspc_r_1/z5 vssa1 1.10fF
C2810 pll_full_1/pd_0/tspc_r_1/Z4 vssa1 1.07fF
C2811 pll_full_1/pd_0/tspc_r_1/Qbar vssa1 0.88fF
C2812 pll_full_1/pd_0/tspc_r_1/Z2 vssa1 1.22fF
C2813 pll_full_1/pd_0/tspc_r_1/Z1 vssa1 0.67fF
C2814 pll_full_1/pd_0/UP vssa1 6.41fF
C2815 pll_full_1/pd_0/tspc_r_1/Qbar1 vssa1 1.34fF
C2816 pll_full_1/pd_0/tspc_r_1/Z3 vssa1 2.12fF
C2817 pll_full_1/pd_0/REF vssa1 6.48fF
C2818 pll_full_1/pd_0/tspc_r_0/z5 vssa1 1.10fF
C2819 pll_full_1/pd_0/tspc_r_0/Z4 vssa1 1.07fF
C2820 pll_full_1/pd_0/R vssa1 3.05fF
C2821 pll_full_1/pd_0/tspc_r_0/Qbar vssa1 0.79fF
C2822 pll_full_1/pd_0/tspc_r_0/Z2 vssa1 1.22fF
C2823 pll_full_1/pd_0/tspc_r_0/Z1 vssa1 0.67fF
C2824 pll_full_1/pd_0/DOWN vssa1 7.34fF
C2825 pll_full_1/pd_0/tspc_r_0/Qbar1 vssa1 1.34fF
C2826 pll_full_1/pd_0/tspc_r_0/Z3 vssa1 2.12fF
C2827 pll_full_1/pd_0/DIV vssa1 372.69fF
C2828 pll_full_0/divider_0/and_0/Z1 vssa1 0.65fF
C2829 pll_full_0/divider_0/and_0/B vssa1 2.45fF
C2830 pll_full_0/divider_0/and_0/A vssa1 2.35fF
C2831 pll_full_0/divider_0/and_0/out1 vssa1 2.99fF
C2832 pll_full_0/divider_0/tspc_2/Z4 vssa1 0.86fF
C2833 pll_full_0/divider_0/tspc_2/Z3 vssa1 2.26fF
C2834 pll_full_0/divider_0/tspc_2/Z2 vssa1 1.46fF
C2835 pll_full_0/divider_0/tspc_2/Z1 vssa1 0.99fF
C2836 pll_full_0/divider_0/nor_0/A vssa1 7.08fF
C2837 pll_full_0/divider_0/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C2838 pll_full_0/divider_0/tspc_1/Z4 vssa1 0.86fF
C2839 pll_full_0/divider_0/tspc_1/Z3 vssa1 2.26fF
C2840 pll_full_0/divider_0/tspc_1/Z2 vssa1 1.46fF
C2841 pll_full_0/divider_0/tspc_1/Z1 vssa1 0.99fF
C2842 pll_full_0/divider_0/nor_0/B vssa1 7.12fF
C2843 pll_full_0/divider_0/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C2844 pll_full_0/divider_0/tspc_2/Q vssa1 3.14fF
C2845 pll_full_0/divider_0/tspc_0/Z4 vssa1 0.86fF
C2846 pll_full_0/divbuf_0/IN vssa1 9.89fF
C2847 pll_full_0/divider_0/tspc_0/Z3 vssa1 2.26fF
C2848 pll_full_0/divider_0/tspc_0/Z2 vssa1 1.46fF
C2849 pll_full_0/divider_0/tspc_0/Z1 vssa1 0.99fF
C2850 pll_full_0/divider_0/nor_1/B vssa1 6.48fF
C2851 pll_full_0/divider_0/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C2852 pll_full_0/divider_0/tspc_1/Q vssa1 3.12fF
C2853 pll_full_0/divider_0/clk vssa1 33.42fF
C2854 pll_full_0/divider_0/prescaler_0/nand_1/z1 vssa1 0.36fF
C2855 pll_full_0/divider_0/prescaler_0/tspc_0/D vssa1 2.64fF
C2856 pll_full_0/divider_0/prescaler_0/tspc_2/Q vssa1 3.72fF
C2857 pll_full_0/divider_0/prescaler_0/tspc_1/Q vssa1 3.61fF
C2858 pll_full_0/divider_0/prescaler_0/nand_0/z1 vssa1 0.36fF
C2859 pll_full_0/divider_0/prescaler_0/tspc_2/D vssa1 3.12fF
C2860 pll_full_0/divider_0/and_0/OUT vssa1 5.67fF
C2861 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C2862 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C2863 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 vssa1 1.19fF
C2864 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C2865 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# vssa1 1.47fF **FLOATING
C2866 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C2867 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C2868 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C2869 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C2870 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C2871 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C2872 pll_full_0/divider_0/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C2873 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C2874 pll_full_0/divider_0/prescaler_0/Out vssa1 4.59fF
C2875 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C2876 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C2877 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C2878 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C2879 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C2880 pll_full_0/divider_0/nor_1/Z1 vssa1 1.34fF
C2881 pll_full_0/divider_0/nor_0/Z1 vssa1 1.34fF
C2882 pll_full_0/divbuf_1/OUT vssa1 363.82fF
C2883 pll_full_0/divbuf_1/OUT5 vssa1 350.37fF
C2884 pll_full_0/divbuf_1/OUT4 vssa1 133.72fF
C2885 pll_full_0/divbuf_1/OUT3 vssa1 34.03fF
C2886 pll_full_0/divbuf_1/OUT2 vssa1 8.71fF
C2887 pll_full_0/divbuf_1/a_492_n240# vssa1 2.46fF **FLOATING
C2888 pll_full_0/divbuf_0/OUT5 vssa1 350.37fF
C2889 pll_full_0/divbuf_0/OUT4 vssa1 133.72fF
C2890 pll_full_0/divbuf_0/OUT3 vssa1 34.03fF
C2891 pll_full_0/divbuf_0/OUT2 vssa1 8.71fF
C2892 pll_full_0/divbuf_0/a_492_n240# vssa1 2.46fF **FLOATING
C2893 pll_full_0/ro_complete_0/cbank_2/v vssa1 16.43fF
C2894 pll_full_0/ro_complete_0/cbank_2/switch_5/vin vssa1 0.78fF
C2895 pll_full_0/ro_complete_0/cbank_2/switch_4/vin vssa1 1.50fF
C2896 pll_full_0/ro_complete_0/cbank_2/switch_2/vin vssa1 1.30fF
C2897 pll_full_0/ro_complete_0/cbank_2/switch_3/vin vssa1 0.56fF
C2898 pll_full_0/ro_complete_0/cbank_2/switch_1/vin vssa1 1.14fF
C2899 pll_full_0/ro_complete_0/cbank_2/switch_0/vin vssa1 1.02fF
C2900 pll_full_0/ro_complete_0/cbank_1/switch_5/vin vssa1 0.78fF
C2901 pll_full_0/ro_complete_0/a0 vssa1 5.35fF
C2902 pll_full_0/ro_complete_0/cbank_1/switch_4/vin vssa1 1.50fF
C2903 pll_full_0/ro_complete_0/a1 vssa1 6.54fF
C2904 pll_full_0/ro_complete_0/cbank_1/switch_2/vin vssa1 1.30fF
C2905 pll_full_0/ro_complete_0/a3 vssa1 5.96fF
C2906 pll_full_0/ro_complete_0/cbank_1/switch_3/vin vssa1 0.56fF
C2907 pll_full_0/ro_complete_0/a2 vssa1 5.21fF
C2908 pll_full_0/ro_complete_0/cbank_1/switch_1/vin vssa1 1.14fF
C2909 pll_full_0/ro_complete_0/a4 vssa1 5.81fF
C2910 pll_full_0/ro_complete_0/cbank_1/switch_0/vin vssa1 1.02fF
C2911 pll_full_0/ro_complete_0/a5 vssa1 6.74fF
C2912 pll_full_0/ro_complete_0/cbank_0/v vssa1 15.12fF
C2913 pll_full_0/ro_complete_0/cbank_0/switch_5/vin vssa1 0.78fF
C2914 pll_full_0/ro_complete_0/cbank_0/switch_4/vin vssa1 1.50fF
C2915 pll_full_0/ro_complete_0/cbank_0/switch_2/vin vssa1 1.30fF
C2916 pll_full_0/ro_complete_0/cbank_0/switch_3/vin vssa1 0.56fF
C2917 pll_full_0/ro_complete_0/cbank_0/switch_1/vin vssa1 1.14fF
C2918 pll_full_0/ro_complete_0/cbank_0/switch_0/vin vssa1 1.02fF
C2919 pll_full_0/ro_complete_0/ro_var_extend_0/vcont vssa1 0.27fF
C2920 pll_full_0/filter_0/a_4216_n5230# vssa1 418.90fF **FLOATING
C2921 pll_full_0/filter_0/a_4216_n2998# vssa1 1.39fF **FLOATING
C2922 pll_full_0/cp_0/down vssa1 1.54fF
C2923 pll_full_0/cp_0/upbar vssa1 1.79fF
C2924 pll_full_0/cp_0/a_7110_n2840# vssa1 0.17fF **FLOATING
C2925 pll_full_0/cp_0/a_3060_n2840# vssa1 1.71fF **FLOATING
C2926 pll_full_0/cp_0/a_7110_0# vssa1 0.17fF **FLOATING
C2927 pll_full_0/cp_0/a_6370_0# vssa1 0.40fF **FLOATING
C2928 pll_full_0/cp_0/a_3060_0# vssa1 2.49fF **FLOATING
C2929 pll_full_0/cp_0/a_1710_0# vssa1 7.47fF **FLOATING
C2930 pll_full_0/pd_0/and_pd_0/Z1 vssa1 0.39fF
C2931 pll_full_0/pd_0/and_pd_0/Out1 vssa1 2.22fF
C2932 pll_full_0/pd_0/tspc_r_1/z5 vssa1 1.10fF
C2933 pll_full_0/pd_0/tspc_r_1/Z4 vssa1 1.07fF
C2934 pll_full_0/pd_0/tspc_r_1/Qbar vssa1 0.88fF
C2935 pll_full_0/pd_0/tspc_r_1/Z2 vssa1 1.22fF
C2936 pll_full_0/pd_0/tspc_r_1/Z1 vssa1 0.67fF
C2937 pll_full_0/pd_0/UP vssa1 6.41fF
C2938 pll_full_0/pd_0/tspc_r_1/Qbar1 vssa1 1.34fF
C2939 pll_full_0/pd_0/tspc_r_1/Z3 vssa1 2.12fF
C2940 pll_full_0/pd_0/REF vssa1 6.48fF
C2941 pll_full_0/pd_0/tspc_r_0/z5 vssa1 1.10fF
C2942 pll_full_0/pd_0/tspc_r_0/Z4 vssa1 1.07fF
C2943 pll_full_0/pd_0/R vssa1 3.05fF
C2944 pll_full_0/pd_0/tspc_r_0/Qbar vssa1 0.79fF
C2945 pll_full_0/pd_0/tspc_r_0/Z2 vssa1 1.22fF
C2946 pll_full_0/pd_0/tspc_r_0/Z1 vssa1 0.67fF
C2947 pll_full_0/pd_0/DOWN vssa1 7.34fF
C2948 pll_full_0/pd_0/tspc_r_0/Qbar1 vssa1 1.34fF
C2949 pll_full_0/pd_0/tspc_r_0/Z3 vssa1 2.12fF
C2950 pll_full_0/pd_0/DIV vssa1 372.69fF
C2951 divbuf_19/OUT vssa1 363.82fF
C2952 divbuf_19/OUT5 vssa1 350.37fF
C2953 divbuf_19/OUT4 vssa1 133.72fF
C2954 divbuf_19/OUT3 vssa1 34.03fF
C2955 divbuf_19/OUT2 vssa1 8.71fF
C2956 divbuf_19/IN vssa1 0.89fF
C2957 divbuf_19/a_492_n240# vssa1 2.46fF **FLOATING
C2958 divbuf_18/OUT vssa1 363.82fF
C2959 divbuf_18/OUT5 vssa1 350.37fF
C2960 divbuf_18/OUT4 vssa1 133.72fF
C2961 divbuf_18/OUT3 vssa1 34.03fF
C2962 divbuf_18/OUT2 vssa1 8.71fF
C2963 divbuf_18/IN vssa1 0.89fF
C2964 divbuf_18/a_492_n240# vssa1 2.46fF **FLOATING
C2965 divbuf_17/OUT vssa1 363.82fF
C2966 divbuf_17/OUT5 vssa1 350.37fF
C2967 divbuf_17/OUT4 vssa1 133.72fF
C2968 divbuf_17/OUT3 vssa1 34.03fF
C2969 divbuf_17/OUT2 vssa1 8.71fF
C2970 divbuf_17/IN vssa1 0.89fF
C2971 divbuf_17/a_492_n240# vssa1 2.46fF **FLOATING
C2972 divider_2/and_0/Z1 vssa1 0.74fF
C2973 divider_2/and_0/B vssa1 2.25fF
C2974 divider_2/and_0/A vssa1 2.19fF
C2975 divider_2/and_0/out1 vssa1 2.93fF
C2976 divider_2/tspc_2/Z4 vssa1 0.86fF
C2977 divider_2/tspc_2/Z3 vssa1 2.26fF
C2978 divider_2/tspc_2/Z2 vssa1 1.46fF
C2979 divider_2/tspc_2/Z1 vssa1 0.99fF
C2980 divider_2/nor_0/A vssa1 7.04fF
C2981 divider_2/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C2982 divider_2/tspc_1/Z4 vssa1 0.86fF
C2983 divider_2/tspc_1/Z3 vssa1 2.26fF
C2984 divider_2/tspc_1/Z2 vssa1 1.46fF
C2985 divider_2/tspc_1/Z1 vssa1 0.99fF
C2986 divider_2/nor_0/B vssa1 7.05fF
C2987 divider_2/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C2988 divider_2/tspc_2/Q vssa1 3.14fF
C2989 divider_2/tspc_0/Z4 vssa1 0.86fF
C2990 divider_2/Out vssa1 1.60fF
C2991 divider_2/tspc_0/Z3 vssa1 2.26fF
C2992 divider_2/tspc_0/Z2 vssa1 1.46fF
C2993 divider_2/tspc_0/Z1 vssa1 0.99fF
C2994 divider_2/nor_1/B vssa1 6.44fF
C2995 divider_2/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C2996 divider_2/tspc_1/Q vssa1 3.12fF
C2997 divider_2/clk vssa1 5.63fF
C2998 divider_2/prescaler_0/nand_1/z1 vssa1 0.36fF
C2999 divider_2/prescaler_0/tspc_0/D vssa1 2.64fF
C3000 divider_2/prescaler_0/tspc_2/Q vssa1 3.74fF
C3001 divider_2/prescaler_0/tspc_1/Q vssa1 3.61fF
C3002 divider_2/prescaler_0/nand_0/z1 vssa1 0.36fF
C3003 divider_2/prescaler_0/tspc_2/D vssa1 3.12fF
C3004 divider_2/and_0/OUT vssa1 5.62fF
C3005 divider_2/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C3006 divider_2/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C3007 divider_2/prescaler_0/tspc_2/Z2 vssa1 1.46fF
C3008 divider_2/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C3009 divider_2/prescaler_0/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C3010 divider_2/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C3011 divider_2/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C3012 divider_2/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C3013 divider_2/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C3014 divider_2/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C3015 divider_2/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C3016 divider_2/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C3017 divider_2/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C3018 divider_2/prescaler_0/Out vssa1 4.59fF
C3019 divider_2/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C3020 divider_2/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C3021 divider_2/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C3022 divider_2/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C3023 divider_2/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C3024 divider_2/nor_1/Z1 vssa1 1.34fF
C3025 divider_2/mc2 vssa1 5.29fF
C3026 divider_2/nor_0/Z1 vssa1 1.34fF
C3027 divbuf_16/OUT vssa1 363.82fF
C3028 divbuf_16/OUT5 vssa1 350.37fF
C3029 divbuf_16/OUT4 vssa1 133.72fF
C3030 divbuf_16/OUT3 vssa1 34.03fF
C3031 divbuf_16/OUT2 vssa1 8.71fF
C3032 divbuf_16/IN vssa1 0.89fF
C3033 divbuf_16/a_492_n240# vssa1 2.46fF **FLOATING
C3034 divider_1/and_0/Z1 vssa1 0.74fF
C3035 divider_1/and_0/B vssa1 2.25fF
C3036 divider_1/and_0/A vssa1 2.19fF
C3037 divider_1/and_0/out1 vssa1 2.93fF
C3038 divider_1/tspc_2/Z4 vssa1 0.86fF
C3039 divider_1/tspc_2/Z3 vssa1 2.26fF
C3040 divider_1/tspc_2/Z2 vssa1 1.46fF
C3041 divider_1/tspc_2/Z1 vssa1 0.99fF
C3042 divider_1/nor_0/A vssa1 7.04fF
C3043 divider_1/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C3044 divider_1/tspc_1/Z4 vssa1 0.86fF
C3045 divider_1/tspc_1/Z3 vssa1 2.26fF
C3046 divider_1/tspc_1/Z2 vssa1 1.46fF
C3047 divider_1/tspc_1/Z1 vssa1 0.99fF
C3048 divider_1/nor_0/B vssa1 7.05fF
C3049 divider_1/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C3050 divider_1/tspc_2/Q vssa1 3.14fF
C3051 divider_1/tspc_0/Z4 vssa1 0.86fF
C3052 divider_1/Out vssa1 1.60fF
C3053 divider_1/tspc_0/Z3 vssa1 2.26fF
C3054 divider_1/tspc_0/Z2 vssa1 1.46fF
C3055 divider_1/tspc_0/Z1 vssa1 0.99fF
C3056 divider_1/nor_1/B vssa1 6.33fF
C3057 divider_1/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C3058 divider_1/tspc_1/Q vssa1 3.12fF
C3059 divider_1/clk vssa1 5.63fF
C3060 divider_1/prescaler_0/nand_1/z1 vssa1 0.36fF
C3061 divider_1/prescaler_0/tspc_0/D vssa1 2.64fF
C3062 divider_1/prescaler_0/tspc_2/Q vssa1 3.74fF
C3063 divider_1/prescaler_0/tspc_1/Q vssa1 3.61fF
C3064 divider_1/prescaler_0/nand_0/z1 vssa1 0.36fF
C3065 divider_1/prescaler_0/tspc_2/D vssa1 3.12fF
C3066 divider_1/and_0/OUT vssa1 5.62fF
C3067 divider_1/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C3068 divider_1/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C3069 divider_1/prescaler_0/tspc_2/Z2 vssa1 1.46fF
C3070 divider_1/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C3071 divider_1/prescaler_0/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C3072 divider_1/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C3073 divider_1/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C3074 divider_1/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C3075 divider_1/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C3076 divider_1/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C3077 divider_1/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C3078 divider_1/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C3079 divider_1/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C3080 divider_1/prescaler_0/Out vssa1 4.59fF
C3081 divider_1/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C3082 divider_1/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C3083 divider_1/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C3084 divider_1/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C3085 divider_1/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C3086 divider_1/nor_1/Z1 vssa1 1.34fF
C3087 divider_1/mc2 vssa1 5.29fF
C3088 divider_1/nor_0/Z1 vssa1 1.34fF
C3089 divbuf_15/OUT vssa1 363.82fF
C3090 divbuf_15/OUT5 vssa1 350.37fF
C3091 divbuf_15/OUT4 vssa1 133.72fF
C3092 divbuf_15/OUT3 vssa1 34.03fF
C3093 divbuf_15/OUT2 vssa1 8.71fF
C3094 divbuf_15/IN vssa1 0.89fF
C3095 divbuf_15/a_492_n240# vssa1 2.46fF **FLOATING
C3096 divbuf_25/OUT5 vssa1 350.37fF
C3097 divbuf_25/OUT4 vssa1 133.72fF
C3098 divbuf_25/OUT3 vssa1 34.03fF
C3099 divbuf_25/OUT2 vssa1 8.71fF
C3100 divbuf_25/IN vssa1 0.89fF
C3101 divbuf_25/a_492_n240# vssa1 2.46fF **FLOATING
C3102 divbuf_14/OUT vssa1 363.82fF
C3103 divbuf_14/OUT5 vssa1 350.37fF
C3104 divbuf_14/OUT4 vssa1 133.72fF
C3105 divbuf_14/OUT3 vssa1 34.03fF
C3106 divbuf_14/OUT2 vssa1 8.71fF
C3107 divbuf_14/IN vssa1 0.89fF
C3108 divbuf_14/a_492_n240# vssa1 2.46fF **FLOATING
C3109 divider_0/and_0/Z1 vssa1 0.74fF
C3110 divider_0/and_0/B vssa1 2.25fF
C3111 divider_0/and_0/A vssa1 2.19fF
C3112 divider_0/and_0/out1 vssa1 2.93fF
C3113 divider_0/tspc_2/Z4 vssa1 0.86fF
C3114 divider_0/tspc_2/Z3 vssa1 2.26fF
C3115 divider_0/tspc_2/Z2 vssa1 1.46fF
C3116 divider_0/tspc_2/Z1 vssa1 0.99fF
C3117 divider_0/nor_0/A vssa1 7.04fF
C3118 divider_0/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C3119 divider_0/tspc_1/Z4 vssa1 0.86fF
C3120 divider_0/tspc_1/Z3 vssa1 2.26fF
C3121 divider_0/tspc_1/Z2 vssa1 1.46fF
C3122 divider_0/tspc_1/Z1 vssa1 0.99fF
C3123 divider_0/nor_0/B vssa1 7.05fF
C3124 divider_0/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C3125 divider_0/tspc_2/Q vssa1 3.14fF
C3126 divider_0/tspc_0/Z4 vssa1 0.86fF
C3127 divider_0/Out vssa1 1.60fF
C3128 divider_0/tspc_0/Z3 vssa1 2.26fF
C3129 divider_0/tspc_0/Z2 vssa1 1.46fF
C3130 divider_0/tspc_0/Z1 vssa1 0.99fF
C3131 divider_0/nor_1/B vssa1 6.33fF
C3132 divider_0/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C3133 divider_0/tspc_1/Q vssa1 3.12fF
C3134 divider_0/clk vssa1 5.63fF
C3135 divider_0/prescaler_0/nand_1/z1 vssa1 0.36fF
C3136 divider_0/prescaler_0/tspc_0/D vssa1 2.64fF
C3137 divider_0/prescaler_0/tspc_2/Q vssa1 3.64fF
C3138 divider_0/prescaler_0/tspc_1/Q vssa1 3.61fF
C3139 divider_0/prescaler_0/nand_0/z1 vssa1 0.36fF
C3140 divider_0/prescaler_0/tspc_2/D vssa1 3.12fF
C3141 divider_0/and_0/OUT vssa1 5.62fF
C3142 divider_0/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C3143 divider_0/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C3144 divider_0/prescaler_0/tspc_2/Z2 vssa1 1.46fF
C3145 divider_0/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C3146 divider_0/prescaler_0/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C3147 divider_0/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C3148 divider_0/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C3149 divider_0/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C3150 divider_0/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C3151 divider_0/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C3152 divider_0/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C3153 divider_0/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C3154 divider_0/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C3155 divider_0/prescaler_0/Out vssa1 4.59fF
C3156 divider_0/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C3157 divider_0/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C3158 divider_0/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C3159 divider_0/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C3160 divider_0/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C3161 divider_0/nor_1/Z1 vssa1 1.34fF
C3162 divider_0/mc2 vssa1 5.29fF
C3163 divider_0/nor_0/Z1 vssa1 1.34fF
C3164 divbuf_24/OUT vssa1 363.82fF
C3165 divbuf_24/OUT5 vssa1 350.37fF
C3166 divbuf_24/OUT4 vssa1 133.72fF
C3167 divbuf_24/OUT3 vssa1 34.03fF
C3168 divbuf_24/OUT2 vssa1 8.71fF
C3169 divbuf_24/IN vssa1 0.89fF
C3170 divbuf_24/a_492_n240# vssa1 2.46fF **FLOATING
C3171 divbuf_13/OUT vssa1 363.82fF
C3172 divbuf_13/OUT5 vssa1 350.37fF
C3173 divbuf_13/OUT4 vssa1 133.72fF
C3174 divbuf_13/OUT3 vssa1 34.03fF
C3175 divbuf_13/OUT2 vssa1 8.71fF
C3176 divbuf_13/IN vssa1 0.89fF
C3177 divbuf_13/a_492_n240# vssa1 2.46fF **FLOATING
C3178 divbuf_9/OUT vssa1 363.82fF
C3179 divbuf_9/OUT5 vssa1 350.37fF
C3180 divbuf_9/OUT4 vssa1 133.72fF
C3181 divbuf_9/OUT3 vssa1 34.03fF
C3182 divbuf_9/OUT2 vssa1 8.71fF
C3183 divbuf_9/IN vssa1 0.89fF
C3184 divbuf_9/a_492_n240# vssa1 2.46fF **FLOATING
C3185 divbuf_23/OUT vssa1 363.82fF
C3186 divbuf_23/OUT5 vssa1 350.37fF
C3187 divbuf_23/OUT4 vssa1 133.72fF
C3188 divbuf_23/OUT3 vssa1 34.03fF
C3189 divbuf_23/OUT2 vssa1 8.71fF
C3190 divbuf_23/IN vssa1 0.89fF
C3191 divbuf_23/a_492_n240# vssa1 2.46fF **FLOATING
C3192 divbuf_12/OUT vssa1 363.82fF
C3193 divbuf_12/OUT5 vssa1 350.37fF
C3194 divbuf_12/OUT4 vssa1 133.72fF
C3195 divbuf_12/OUT3 vssa1 34.03fF
C3196 divbuf_12/OUT2 vssa1 8.71fF
C3197 divbuf_12/IN vssa1 0.89fF
C3198 divbuf_12/a_492_n240# vssa1 2.46fF **FLOATING
C3199 divbuf_8/OUT vssa1 363.82fF
C3200 divbuf_8/OUT5 vssa1 350.37fF
C3201 divbuf_8/OUT4 vssa1 133.72fF
C3202 divbuf_8/OUT3 vssa1 34.03fF
C3203 divbuf_8/OUT2 vssa1 8.71fF
C3204 divbuf_8/IN vssa1 0.89fF
C3205 divbuf_8/a_492_n240# vssa1 2.46fF **FLOATING
C3206 divbuf_22/OUT vssa1 363.82fF
C3207 divbuf_22/OUT5 vssa1 350.37fF
C3208 divbuf_22/OUT4 vssa1 133.72fF
C3209 divbuf_22/OUT3 vssa1 34.03fF
C3210 divbuf_22/OUT2 vssa1 8.71fF
C3211 divbuf_22/IN vssa1 0.89fF
C3212 divbuf_22/a_492_n240# vssa1 2.46fF **FLOATING
C3213 divbuf_11/OUT vssa1 363.82fF
C3214 divbuf_11/OUT5 vssa1 350.37fF
C3215 divbuf_11/OUT4 vssa1 133.72fF
C3216 divbuf_11/OUT3 vssa1 34.03fF
C3217 divbuf_11/OUT2 vssa1 8.71fF
C3218 divbuf_11/IN vssa1 0.89fF
C3219 divbuf_11/a_492_n240# vssa1 2.46fF **FLOATING
C3220 divbuf_7/OUT5 vssa1 350.37fF
C3221 divbuf_7/OUT4 vssa1 133.72fF
C3222 divbuf_7/OUT3 vssa1 34.03fF
C3223 divbuf_7/OUT2 vssa1 8.71fF
C3224 divbuf_7/IN vssa1 0.89fF
C3225 divbuf_7/a_492_n240# vssa1 2.46fF **FLOATING
C3226 divbuf_21/OUT vssa1 363.82fF
C3227 divbuf_21/OUT5 vssa1 350.37fF
C3228 divbuf_21/OUT4 vssa1 133.72fF
C3229 divbuf_21/OUT3 vssa1 34.03fF
C3230 divbuf_21/OUT2 vssa1 8.71fF
C3231 divbuf_21/IN vssa1 0.89fF
C3232 divbuf_21/a_492_n240# vssa1 2.46fF **FLOATING
C3233 divbuf_20/OUT vssa1 363.82fF
C3234 divbuf_20/OUT5 vssa1 350.37fF
C3235 divbuf_20/OUT4 vssa1 133.72fF
C3236 divbuf_20/OUT3 vssa1 34.03fF
C3237 divbuf_20/OUT2 vssa1 8.71fF
C3238 divbuf_20/IN vssa1 0.89fF
C3239 divbuf_20/a_492_n240# vssa1 2.46fF **FLOATING
C3240 divbuf_10/OUT vssa1 363.82fF
C3241 divbuf_10/OUT5 vssa1 350.37fF
C3242 divbuf_10/OUT4 vssa1 133.72fF
C3243 divbuf_10/OUT3 vssa1 34.03fF
C3244 divbuf_10/OUT2 vssa1 8.71fF
C3245 divbuf_10/IN vssa1 0.89fF
C3246 divbuf_10/a_492_n240# vssa1 2.46fF **FLOATING
C3247 divbuf_6/OUT5 vssa1 350.37fF
C3248 divbuf_6/OUT4 vssa1 133.72fF
C3249 divbuf_6/OUT3 vssa1 34.03fF
C3250 divbuf_6/OUT2 vssa1 8.71fF
C3251 divbuf_6/IN vssa1 0.89fF
C3252 divbuf_6/a_492_n240# vssa1 2.46fF **FLOATING
C3253 divbuf_5/OUT5 vssa1 350.37fF
C3254 divbuf_5/OUT4 vssa1 133.72fF
C3255 divbuf_5/OUT3 vssa1 34.03fF
C3256 divbuf_5/OUT2 vssa1 8.71fF
C3257 divbuf_5/IN vssa1 0.89fF
C3258 divbuf_5/a_492_n240# vssa1 2.46fF **FLOATING
C3259 divbuf_4/OUT5 vssa1 350.37fF
C3260 divbuf_4/OUT4 vssa1 133.72fF
C3261 divbuf_4/OUT3 vssa1 34.03fF
C3262 divbuf_4/OUT2 vssa1 8.71fF
C3263 divbuf_4/IN vssa1 0.89fF
C3264 divbuf_4/a_492_n240# vssa1 2.46fF **FLOATING
C3265 divbuf_3/OUT5 vssa1 350.37fF
C3266 divbuf_3/OUT4 vssa1 133.72fF
C3267 divbuf_3/OUT3 vssa1 34.03fF
C3268 divbuf_3/OUT2 vssa1 8.71fF
C3269 divbuf_3/IN vssa1 0.89fF
C3270 divbuf_3/a_492_n240# vssa1 2.46fF **FLOATING
C3271 divbuf_2/OUT5 vssa1 350.37fF
C3272 divbuf_2/OUT4 vssa1 133.72fF
C3273 divbuf_2/OUT3 vssa1 34.03fF
C3274 divbuf_2/OUT2 vssa1 8.71fF
C3275 divbuf_2/IN vssa1 0.89fF
C3276 divbuf_2/a_492_n240# vssa1 2.46fF **FLOATING
C3277 divbuf_1/OUT vssa1 363.82fF
C3278 divbuf_1/OUT5 vssa1 350.37fF
C3279 divbuf_1/OUT4 vssa1 133.72fF
C3280 divbuf_1/OUT3 vssa1 34.03fF
C3281 divbuf_1/OUT2 vssa1 8.71fF
C3282 divbuf_1/IN vssa1 0.89fF
C3283 divbuf_1/a_492_n240# vssa1 2.46fF **FLOATING
C3284 ro_complete_1/cbank_2/v vssa1 16.43fF
C3285 ro_complete_1/cbank_2/switch_5/vin vssa1 0.78fF
C3286 ro_complete_1/cbank_2/switch_4/vin vssa1 1.50fF
C3287 ro_complete_1/cbank_2/switch_2/vin vssa1 1.30fF
C3288 ro_complete_1/cbank_2/switch_3/vin vssa1 0.56fF
C3289 ro_complete_1/cbank_2/switch_1/vin vssa1 1.14fF
C3290 ro_complete_1/cbank_2/switch_0/vin vssa1 1.02fF
C3291 ro_complete_1/cbank_1/v vssa1 16.43fF
C3292 ro_complete_1/cbank_1/switch_5/vin vssa1 0.78fF
C3293 ro_complete_1/a0 vssa1 5.35fF
C3294 ro_complete_1/cbank_1/switch_4/vin vssa1 1.50fF
C3295 ro_complete_1/a1 vssa1 6.54fF
C3296 ro_complete_1/cbank_1/switch_2/vin vssa1 1.30fF
C3297 ro_complete_1/a3 vssa1 5.96fF
C3298 ro_complete_1/cbank_1/switch_3/vin vssa1 0.56fF
C3299 ro_complete_1/a2 vssa1 5.21fF
C3300 ro_complete_1/cbank_1/switch_1/vin vssa1 1.14fF
C3301 ro_complete_1/a4 vssa1 5.81fF
C3302 ro_complete_1/cbank_1/switch_0/vin vssa1 1.02fF
C3303 ro_complete_1/a5 vssa1 6.74fF
C3304 ro_complete_1/cbank_0/v vssa1 15.12fF
C3305 ro_complete_1/cbank_0/switch_5/vin vssa1 0.78fF
C3306 ro_complete_1/cbank_0/switch_4/vin vssa1 1.50fF
C3307 ro_complete_1/cbank_0/switch_2/vin vssa1 1.30fF
C3308 ro_complete_1/cbank_0/switch_3/vin vssa1 0.56fF
C3309 ro_complete_1/cbank_0/switch_1/vin vssa1 1.14fF
C3310 ro_complete_1/cbank_0/switch_0/vin vssa1 1.02fF
C3311 ro_complete_1/ro_var_extend_0/vcont vssa1 0.27fF
C3312 divbuf_0/OUT vssa1 363.82fF
C3313 divbuf_0/OUT5 vssa1 350.37fF
C3314 divbuf_0/OUT4 vssa1 133.72fF
C3315 divbuf_0/OUT3 vssa1 34.03fF
C3316 divbuf_0/OUT2 vssa1 8.71fF
C3317 divbuf_0/IN vssa1 0.89fF
C3318 divbuf_0/a_492_n240# vssa1 2.46fF **FLOATING
C3319 ro_complete_0/cbank_2/v vssa1 16.43fF
C3320 ro_complete_0/cbank_2/switch_5/vin vssa1 0.78fF
C3321 ro_complete_0/cbank_2/switch_4/vin vssa1 1.50fF
C3322 ro_complete_0/cbank_2/switch_2/vin vssa1 1.30fF
C3323 ro_complete_0/cbank_2/switch_3/vin vssa1 0.56fF
C3324 ro_complete_0/cbank_2/switch_1/vin vssa1 1.14fF
C3325 ro_complete_0/cbank_2/switch_0/vin vssa1 1.02fF
C3326 ro_complete_0/cbank_1/v vssa1 16.46fF
C3327 ro_complete_0/cbank_1/switch_5/vin vssa1 0.78fF
C3328 divbuf_7/OUT vssa1 405.76fF
C3329 ro_complete_0/cbank_1/switch_4/vin vssa1 1.50fF
C3330 divbuf_6/OUT vssa1 402.77fF
C3331 ro_complete_0/cbank_1/switch_2/vin vssa1 1.30fF
C3332 divbuf_3/OUT vssa1 394.74fF
C3333 ro_complete_0/cbank_1/switch_3/vin vssa1 0.56fF
C3334 divbuf_5/OUT vssa1 397.92fF
C3335 ro_complete_0/cbank_1/switch_1/vin vssa1 1.14fF
C3336 divbuf_4/OUT vssa1 391.26fF
C3337 ro_complete_0/cbank_1/switch_0/vin vssa1 1.02fF
C3338 divbuf_2/OUT vssa1 387.66fF
C3339 ro_complete_0/cbank_0/v vssa1 15.12fF
C3340 ro_complete_0/cbank_0/switch_5/vin vssa1 0.78fF
C3341 ro_complete_0/cbank_0/switch_4/vin vssa1 1.50fF
C3342 ro_complete_0/cbank_0/switch_2/vin vssa1 1.30fF
C3343 ro_complete_0/cbank_0/switch_3/vin vssa1 0.56fF
C3344 ro_complete_0/cbank_0/switch_1/vin vssa1 1.14fF
C3345 ro_complete_0/cbank_0/switch_0/vin vssa1 1.02fF
C3346 ro_complete_0/ro_var_extend_0/vcont vssa1 0.27fF
C3347 filter_0/v vssa1 477.90fF
C3348 filter_0/a_4216_n5230# vssa1 418.47fF **FLOATING
C3349 filter_0/a_4216_n2998# vssa1 1.03fF **FLOATING
C3350 cp_0/down vssa1 1.54fF
C3351 cp_0/vbias vssa1 2.41fF
C3352 cp_0/out vssa1 5.34fF
C3353 cp_0/upbar vssa1 1.50fF
C3354 cp_0/a_7110_n2840# vssa1 0.17fF **FLOATING
C3355 cp_0/a_3060_n2840# vssa1 1.71fF **FLOATING
C3356 cp_0/a_7110_0# vssa1 0.17fF **FLOATING
C3357 cp_0/a_6370_0# vssa1 0.40fF **FLOATING
C3358 cp_0/a_3060_0# vssa1 1.66fF **FLOATING
C3359 cp_0/a_1710_0# vssa1 5.89fF **FLOATING
C3360 cp_0/a_1710_n2840# vssa1 4.91fF **FLOATING
C3361 cp_0/a_10_n50# vssa1 2.96fF **FLOATING
C3362 pd_1/and_pd_0/Z1 vssa1 0.39fF
C3363 pd_1/and_pd_0/Out1 vssa1 2.22fF
C3364 pd_1/tspc_r_1/z5 vssa1 1.10fF
C3365 pd_1/tspc_r_1/Z4 vssa1 1.07fF
C3366 pd_1/tspc_r_1/Qbar vssa1 0.88fF
C3367 pd_1/tspc_r_1/Z2 vssa1 1.22fF
C3368 pd_1/tspc_r_1/Z1 vssa1 0.67fF
C3369 pd_1/UP vssa1 2.21fF
C3370 pd_1/tspc_r_1/Qbar1 vssa1 1.34fF
C3371 pd_1/tspc_r_1/Z3 vssa1 2.12fF
C3372 pd_1/REF vssa1 1.80fF
C3373 pd_1/tspc_r_0/z5 vssa1 1.10fF
C3374 pd_1/tspc_r_0/Z4 vssa1 1.07fF
C3375 pd_1/R vssa1 3.05fF
C3376 pd_1/tspc_r_0/Qbar vssa1 0.79fF
C3377 pd_1/tspc_r_0/Z2 vssa1 1.22fF
C3378 pd_1/tspc_r_0/Z1 vssa1 0.67fF
C3379 pd_1/DOWN vssa1 3.08fF
C3380 pd_1/tspc_r_0/Qbar1 vssa1 1.34fF
C3381 pd_1/tspc_r_0/Z3 vssa1 2.12fF
C3382 pd_1/DIV vssa1 1.82fF
C3383 pd_0/and_pd_0/Z1 vssa1 0.39fF
C3384 pd_0/and_pd_0/Out1 vssa1 2.22fF
C3385 pd_0/tspc_r_1/z5 vssa1 1.10fF
C3386 pd_0/tspc_r_1/Z4 vssa1 1.07fF
C3387 pd_0/tspc_r_1/Qbar vssa1 0.88fF
C3388 pd_0/tspc_r_1/Z2 vssa1 1.22fF
C3389 pd_0/tspc_r_1/Z1 vssa1 0.67fF
C3390 pd_0/UP vssa1 2.21fF
C3391 pd_0/tspc_r_1/Qbar1 vssa1 1.34fF
C3392 pd_0/tspc_r_1/Z3 vssa1 2.12fF
C3393 pd_0/REF vssa1 1.80fF
C3394 pd_0/tspc_r_0/z5 vssa1 1.10fF
C3395 pd_0/tspc_r_0/Z4 vssa1 1.07fF
C3396 pd_0/R vssa1 3.05fF
C3397 pd_0/tspc_r_0/Qbar vssa1 0.79fF
C3398 pd_0/tspc_r_0/Z2 vssa1 1.22fF
C3399 pd_0/tspc_r_0/Z1 vssa1 0.67fF
C3400 pd_0/DOWN vssa1 3.08fF
C3401 pd_0/tspc_r_0/Qbar1 vssa1 1.34fF
C3402 pd_0/tspc_r_0/Z3 vssa1 2.12fF
C3403 pd_0/DIV vssa1 1.82fF
.ends
