* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[5] io_analog[6] io_analog[7]
+ io_analog[8] io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
C0 cp_buffered_0/cp_0/upbar cp_buffered_0/cp_0/down 0.02fF
C1 divider_1/tspc_0/Z4 divider_1/tspc_0/Z2 0.36fF
C2 divider_0/nor_0/B divider_0/tspc_2/Z1 0.03fF
C3 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z3 0.05fF
C4 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/ref 0.65fF
C5 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C6 divider_1/prescaler_0/tspc_2/D divider_1/prescaler_0/nand_0/z1 0.24fF
C7 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/and_0/OUT 0.06fF
C8 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.38fF
C9 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.11fF
C10 pll_full_1/ro_complete_0/cbank_1/switch_4/vin pll_full_1/vco 1.46fF
C11 div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 div_pd_buffered_0/pd_0/tspc_r_0/z5 0.20fF
C12 ro_complete_0/a0 ro_complete_0/cbank_2/v 0.05fF
C13 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/A 0.01fF
C14 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_0/Q 0.05fF
C15 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C16 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C17 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_1/Z4 0.02fF
C18 div_pd_buffered_0/divider_0/tspc_0/Z4 div_pd_buffered_0/divider_0/nor_1/A 0.21fF
C19 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C20 ro_complete_buffered_0/ro_complete_0/a1 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_4/vin 0.09fF
C21 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/tspc_r_1/z5 0.20fF
C22 div_pd_buffered_0/divider_0/tspc_0/Z2 div_pd_buffered_0/divider_0/tspc_0/Z3 0.16fF
C23 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 div_pd_buffered_0/divider_0/clk 0.12fF
C24 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C25 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/and_0/A 0.01fF
C26 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/nand_0/z1 0.07fF
C27 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/D 0.05fF
C28 div_pd_buffered_0/tapered_buf_2/a_160_n140# div_pd_buffered_0/tapered_buf_2/a_160_230# 0.17fF
C29 divider_1/tspc_0/a_630_n680# divider_1/nor_1/A 0.35fF
C30 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z4 0.20fF
C31 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C32 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_2/v 0.08fF
C33 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C34 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Z4 0.20fF
C35 divider_1/prescaler_0/tspc_2/D divider_1/clk 0.26fF
C36 ro_complete_buffered_0/tapered_buf_3/a_160_n140# ro_complete_buffered_0/tapered_buf_3/a_210_n610# 0.22fF
C37 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/vco 0.01fF
C38 div_pd_buffered_0/pd_0/tspc_r_0/z5 div_pd_buffered_0/pd_0/tspc_r_1/z5 0.02fF
C39 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/tspc_r_1/Z2 0.25fF
C40 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/Z4 0.21fF
C41 ro_complete_buffered_0/ro_complete_0/a0 ro_complete_buffered_0/tapered_buf_1/in 0.05fF
C42 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z3 0.45fF
C43 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Q 0.04fF
C44 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/A 0.26fF
C45 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C46 divider_1/mc2 divider_1/and_0/A 0.16fF
C47 divider_0/tspc_1/Z2 divider_0/tspc_0/Q 0.14fF
C48 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/D 0.03fF
C49 divider_0/prescaler_0/m1_2700_2190# divider_0/clk 0.01fF
C50 filter_buffered_0/tapered_buf_0/a_580_0# filter_buffered_0/tapered_buf_0/a_1650_0# 1.27fF
C51 divider_1/tspc_0/Q divider_1/nor_1/B 0.22fF
C52 pll_full_1/ro_complete_0/cbank_2/switch_4/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C53 div_pd_buffered_0/tapered_buf_4/a_n10_230# div_pd_buffered_0/pd_0/DOWN 0.02fF
C54 ro_complete_0/a4 ro_complete_0/cbank_2/switch_0/vin 0.12fF
C55 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/prescaler_0/Out 0.05fF
C56 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/pd_0/UP 2.89fF
C57 ro_complete_buffered_0/tapered_buf_6/a_160_n140# ro_complete_buffered_0/tapered_buf_6/a_580_0# 0.35fF
C58 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C59 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_1/Z4 0.02fF
C60 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C61 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_1/Qbar1 0.11fF
C62 div_pd_buffered_0/divider_0/tspc_0/Z4 div_pd_buffered_0/divider_0/tspc_0/Z3 0.65fF
C63 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C64 divider_1/prescaler_0/Out divider_1/nor_1/A 0.15fF
C65 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/a_630_n680# 0.12fF
C66 divider_0/tspc_1/Z1 divider_0/tspc_1/Z2 1.07fF
C67 divider_0/prescaler_0/Out divider_0/prescaler_0/m1_2700_2190# 0.11fF
C68 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_0/vin ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.45fF
C69 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z4 0.22fF
C70 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z3 0.16fF
C71 cp_buffered_0/tapered_buf_1/a_1650_0# cp_buffered_0/tapered_buf_1/a_210_n610# 2.89fF
C72 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/D 0.05fF
C73 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/Z4 0.36fF
C74 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_1/Q 0.05fF
C75 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 0.12fF
C76 ro_complete_0/a3 ro_complete_0/cbank_2/v 0.05fF
C77 div_pd_buffered_0/tapered_buf_0/a_160_n140# div_pd_buffered_0/pd_0/UP 0.19fF
C78 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.33fF
C79 ro_complete_buffered_0/tapered_buf_7/a_160_n140# ro_complete_buffered_0/tapered_buf_7/a_580_0# 0.35fF
C80 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_0/vin 0.12fF
C81 ro_complete_buffered_0/tapered_buf_0/a_580_0# ro_complete_buffered_0/tapered_buf_0/a_210_n610# 0.84fF
C82 ro_complete_buffered_0/tapered_buf_0/a_160_n140# ro_complete_buffered_0/tapered_buf_0/a_n10_n140# 0.05fF
C83 ro_complete_buffered_0/tapered_buf_1/a_210_n610# ro_complete_buffered_0/tapered_buf_1/a_580_0# 0.84fF
C84 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C85 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_2/vin ro_complete_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C86 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Z4 0.21fF
C87 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C88 pll_full_0/ro_complete_0/a0 pll_full_0/vco 0.11fF
C89 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/R 0.01fF
C90 div_pd_buffered_0/divider_0/tspc_1/Q div_pd_buffered_0/divider_0/tspc_2/a_630_n680# 0.01fF
C91 divider_0/tspc_0/Z4 divider_0/tspc_0/a_630_n680# 0.12fF
C92 divider_0/prescaler_0/tspc_0/Z2 divider_0/and_0/OUT 0.06fF
C93 divider_0/prescaler_0/tspc_1/Z4 divider_0/clk 0.12fF
C94 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z3 0.16fF
C95 cp_buffered_0/tapered_buf_2/a_160_n140# cp_buffered_0/tapered_buf_2/a_580_0# 0.35fF
C96 pll_full_0/divider_0/and_0/A pll_full_0/divider_0/and_0/B 0.18fF
C97 cp_buffered_0/tapered_buf_0/a_1650_0# cp_buffered_0/tapered_buf_0/a_210_n610# 2.89fF
C98 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C99 divider_1/tspc_0/Z2 divider_1/tspc_0/a_630_n680# 0.01fF
C100 ro_complete_buffered_0/tapered_buf_3/a_1650_0# ro_complete_buffered_0/tapered_buf_3/a_210_n610# 2.89fF
C101 divider_1/tspc_1/Q divider_1/tspc_2/Z4 0.15fF
C102 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/UP 0.03fF
C103 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/divider_0/tspc_2/a_630_n680# 0.04fF
C104 div_pd_buffered_0/divider_0/tspc_0/Z4 div_pd_buffered_0/divider_0/tspc_0/Z2 0.36fF
C105 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C106 divider_0/nor_1/A divider_0/tspc_1/Z2 0.15fF
C107 ro_complete_buffered_0/tapered_buf_5/a_210_n610# ro_complete_buffered_0/ro_complete_0/a3 26.29fF
C108 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/Z1 0.00fF
C109 divider_0/prescaler_0/tspc_1/Z4 divider_0/prescaler_0/Out 0.28fF
C110 ro_complete_buffered_0/ro_complete_0/a3 ro_complete_buffered_0/tapered_buf_1/in 0.05fF
C111 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C112 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/and_0/Z1 0.04fF
C113 div_pd_buffered_0/divider_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/tspc_2/Z2 0.01fF
C114 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q div_pd_buffered_0/divider_0/clk 0.05fF
C115 pll_full_1/ro_complete_0/cbank_0/v pll_full_1/ro_complete_0/cbank_2/v 0.04fF
C116 divider_1/prescaler_0/tspc_0/Z2 divider_1/clk 0.11fF
C117 ro_complete_0/a3 ro_complete_0/cbank_1/switch_2/vin 0.09fF
C118 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_0/Q 0.01fF
C119 divider_1/tspc_2/Z2 divider_1/tspc_2/Z4 0.36fF
C120 divider_1/tspc_2/Z3 divider_1/Out 0.05fF
C121 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/pd_0/and_pd_0/Out1 0.12fF
C122 div_pd_buffered_0/pd_0/tspc_r_0/Qbar div_pd_buffered_0/pd_0/UP 0.21fF
C123 ro_complete_buffered_0/tapered_buf_5/a_n10_230# ro_complete_buffered_0/tapered_buf_5/in 0.02fF
C124 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/UP 0.03fF
C125 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C126 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C127 divider_1/prescaler_0/Out divider_1/tspc_0/Z2 0.11fF
C128 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/vco 0.26fF
C129 div_pd_buffered_0/divider_0/and_0/out1 div_pd_buffered_0/divider_0/and_0/B 0.18fF
C130 divider_0/tspc_1/Q divider_0/tspc_2/Z1 0.01fF
C131 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C132 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/nor_1/B 0.38fF
C133 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/tspc_0/Z1 0.00fF
C134 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C135 pll_full_1/ro_complete_0/a2 pll_full_1/vco 0.11fF
C136 divider_1/nor_1/A divider_1/prescaler_0/tspc_1/Q 0.03fF
C137 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z3 0.06fF
C138 ro_complete_buffered_0/tapered_buf_4/a_1650_0# ro_complete_buffered_0/tapered_buf_4/a_210_n610# 2.89fF
C139 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_5/vin 0.20fF
C140 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_2/Z1 0.03fF
C141 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z3 0.05fF
C142 ro_complete_buffered_0/tapered_buf_6/a_n10_230# ro_complete_buffered_0/tapered_buf_6/in 0.02fF
C143 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C144 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C145 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/nor_0/B 0.00fF
C146 div_pd_buffered_0/divider_0/tspc_1/Z2 div_pd_buffered_0/divider_0/tspc_0/Q 0.14fF
C147 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C148 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/clk 0.01fF
C149 div_pd_buffered_0/tapered_buf_2/in div_pd_buffered_0/tapered_buf_2/a_160_n140# 0.19fF
C150 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/a1 3.18fF
C151 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_0/Z3 0.45fF
C152 pll_full_0/ro_complete_0/a3 pll_full_0/vco 0.11fF
C153 divider_0/prescaler_0/Out divider_0/tspc_0/a_630_n680# 0.01fF
C154 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_5/vin ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C155 divider_1/tspc_0/Z4 divider_1/tspc_0/a_630_n680# 0.12fF
C156 divider_0/nor_0/B divider_0/tspc_2/Z3 0.38fF
C157 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z4 0.12fF
C158 divider_0/tspc_2/Z1 divider_0/tspc_2/Z2 1.07fF
C159 filter_buffered_0/filter_0/v filter_buffered_0/tapered_buf_1/a_210_n610# 26.29fF
C160 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# 0.01fF
C161 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.04fF
C162 pll_full_1/ro_complete_0/cbank_1/switch_0/vin pll_full_1/vco 1.58fF
C163 divider_1/nor_1/B divider_1/nor_0/B 0.47fF
C164 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/Q 0.04fF
C165 divider_1/prescaler_0/tspc_1/Z3 divider_1/clk 0.45fF
C166 ro_complete_buffered_0/tapered_buf_4/a_n10_230# ro_complete_buffered_0/tapered_buf_4/a_160_230# 0.09fF
C167 ro_complete_buffered_0/tapered_buf_4/a_4670_0# ro_complete_buffered_0/tapered_buf_4/a_210_n610# 29.21fF
C168 pll_full_1/pd_0/tspc_r_0/Qbar pll_full_1/pd_0/UP 0.21fF
C169 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/tapered_buf_1/in 0.02fF
C170 div_pd_buffered_0/tapered_buf_0/a_4670_0# div_pd_buffered_0/tapered_buf_0/a_1650_0# 4.78fF
C171 div_pd_buffered_0/tapered_buf_1/a_160_n140# div_pd_buffered_0/tapered_buf_1/a_210_n610# 0.22fF
C172 div_pd_buffered_0/divider_0/tspc_1/Z1 div_pd_buffered_0/divider_0/tspc_1/Z3 0.06fF
C173 ro_complete_buffered_0/tapered_buf_7/a_n10_230# ro_complete_buffered_0/tapered_buf_7/in 0.02fF
C174 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C175 ro_complete_buffered_0/tapered_buf_1/a_160_n140# ro_complete_buffered_0/tapered_buf_1/a_580_0# 0.35fF
C176 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C177 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z2 0.01fF
C178 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Q 0.38fF
C179 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_0/D 0.11fF
C180 cp_buffered_0/tapered_buf_2/a_n10_230# cp_buffered_0/tapered_buf_2/in 0.02fF
C181 div_pd_buffered_0/tapered_buf_2/a_160_n140# div_pd_buffered_0/tapered_buf_2/a_n10_n140# 0.05fF
C182 divider_0/and_0/out1 divider_0/and_0/Z1 0.36fF
C183 ro_complete_buffered_0/tapered_buf_2/a_160_n140# ro_complete_buffered_0/tapered_buf_2/a_160_230# 0.17fF
C184 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/a1 0.14fF
C185 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/v 1.30fF
C186 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/a3 0.09fF
C187 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/tspc_0/Z3 0.65fF
C188 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/tspc_2/D 0.03fF
C189 div_pd_buffered_0/tapered_buf_3/a_1650_0# div_pd_buffered_0/tapered_buf_3/a_4670_0# 4.78fF
C190 ro_complete_buffered_0/tapered_buf_5/a_580_0# ro_complete_buffered_0/tapered_buf_5/a_160_230# 0.02fF
C191 ro_complete_buffered_0/tapered_buf_5/a_160_n140# ro_complete_buffered_0/tapered_buf_5/a_210_n610# 0.22fF
C192 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C193 div_pd_buffered_0/pd_0/tspc_r_0/Qbar div_pd_buffered_0/pd_0/and_pd_0/Out1 0.05fF
C194 div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 div_pd_buffered_0/pd_0/tspc_r_1/Qbar 0.01fF
C195 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/R 0.27fF
C196 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/nor_1/B 1.21fF
C197 divider_0/nor_1/A divider_0/tspc_0/Z1 0.03fF
C198 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z3 0.33fF
C199 divider_0/nor_1/Z1 divider_0/nor_1/B 0.06fF
C200 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z3 0.06fF
C201 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_0/Z2 0.11fF
C202 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C203 divider_1/prescaler_0/Out divider_1/tspc_0/Z4 0.12fF
C204 divider_0/prescaler_0/tspc_1/Z4 divider_0/prescaler_0/tspc_1/Z1 0.00fF
C205 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z4 0.15fF
C206 io_clamp_low[2] io_clamp_high[2] 0.53fF
C207 divider_0/and_0/OUT divider_0/prescaler_0/nand_0/z1 0.01fF
C208 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/clk 0.01fF
C209 divider_1/tspc_1/Z1 divider_1/nor_1/B 0.03fF
C210 filter_buffered_0/tapered_buf_0/a_160_n140# filter_buffered_0/tapered_buf_0/a_160_230# 0.17fF
C211 filter_buffered_0/tapered_buf_0/a_1650_0# filter_buffered_0/tapered_buf_0/a_4670_0# 4.78fF
C212 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/pd_0/tspc_r_1/Z2 0.71fF
C213 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_1/z5 0.03fF
C214 pll_full_1/ro_complete_0/cbank_2/switch_0/vin pll_full_1/ro_complete_0/cbank_2/v 1.45fF
C215 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/v 1.30fF
C216 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/cbank_0/v 1.30fF
C217 io_clamp_high[1] io_analog[5] 0.53fF
C218 ro_complete_buffered_0/tapered_buf_6/a_580_0# ro_complete_buffered_0/tapered_buf_6/a_1650_0# 1.27fF
C219 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/tspc_r_1/Z3 0.25fF
C220 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C221 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/a_630_n680# 0.12fF
C222 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/a_630_n680# 0.19fF
C223 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z3 0.11fF
C224 divider_0/tspc_1/Z2 divider_0/tspc_1/Z3 0.16fF
C225 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z4 0.36fF
C226 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/div 0.05fF
C227 pll_full_1/ref pll_full_1/pd_0/tspc_r_0/Z1 0.17fF
C228 divider_0/and_0/OUT divider_0/clk 0.04fF
C229 cp_buffered_0/tapered_buf_1/a_160_n140# cp_buffered_0/tapered_buf_1/in 0.19fF
C230 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C231 pll_full_1/ro_complete_0/cbank_0/switch_2/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C232 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/div 0.65fF
C233 div_pd_buffered_0/tapered_buf_4/a_n10_230# div_pd_buffered_0/tapered_buf_4/a_160_230# 0.09fF
C234 div_pd_buffered_0/tapered_buf_2/a_n10_230# div_pd_buffered_0/tapered_buf_2/a_160_230# 0.09fF
C235 divider_1/prescaler_0/tspc_2/Z4 divider_1/prescaler_0/tspc_2/D 0.11fF
C236 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.03fF
C237 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/tspc_0/Z2 0.36fF
C238 pll_full_1/div pll_full_1/vco 2.26fF
C239 ro_complete_buffered_0/tapered_buf_7/a_580_0# ro_complete_buffered_0/tapered_buf_7/a_1650_0# 1.27fF
C240 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.33fF
C241 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C242 pll_full_1/pd_0/tspc_r_0/Qbar pll_full_1/pd_0/and_pd_0/Out1 0.05fF
C243 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C244 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/and_0/B 0.08fF
C245 div_pd_buffered_0/divider_0/tspc_1/Q div_pd_buffered_0/divider_0/nor_0/B 0.22fF
C246 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C247 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# div_pd_buffered_0/divider_0/clk 0.01fF
C248 divider_0/nor_1/A divider_0/and_0/B 0.08fF
C249 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_4/vin ro_complete_buffered_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C250 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C251 cp_buffered_0/tapered_buf_2/a_580_0# cp_buffered_0/tapered_buf_2/a_1650_0# 1.27fF
C252 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/clk 0.14fF
C253 divider_0/tspc_1/Z2 divider_0/tspc_1/Z4 0.36fF
C254 divider_0/tspc_1/Z3 divider_0/tspc_1/Q 0.05fF
C255 divider_1/nor_0/Z1 divider_1/nor_1/B 0.18fF
C256 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C257 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z3 0.16fF
C258 filter_buffered_0/filter_0/v filter_buffered_0/tapered_buf_0/a_n10_n140# 0.04fF
C259 filter_buffered_0/tapered_buf_1/a_580_0# filter_buffered_0/tapered_buf_1/a_160_230# 0.02fF
C260 filter_buffered_0/tapered_buf_1/a_160_n140# filter_buffered_0/tapered_buf_1/a_210_n610# 0.22fF
C261 cp_buffered_0/cp_0/out cp_buffered_0/cp_0/down 0.79fF
C262 cp_buffered_0/tapered_buf_0/a_160_n140# cp_buffered_0/tapered_buf_0/in 0.19fF
C263 divider_1/prescaler_0/tspc_2/Z3 divider_1/clk 0.45fF
C264 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/Qbar 0.01fF
C265 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/tspc_0/Q 0.55fF
C266 pll_full_1/ro_complete_0/cbank_1/switch_5/vin pll_full_1/vco 1.46fF
C267 divider_0/nor_1/A divider_0/prescaler_0/m1_2700_2190# 0.01fF
C268 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C269 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/divider_0/nor_0/B 0.42fF
C270 div_pd_buffered_0/divider_0/tspc_1/Z1 div_pd_buffered_0/divider_0/nor_1/B 0.03fF
C271 div_pd_buffered_0/divider_0/tspc_1/Z3 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# 0.05fF
C272 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/nor_1/A 0.35fF
C273 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C274 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C275 div_pd_buffered_0/divider_0/nor_0/B div_pd_buffered_0/divider_0/tspc_2/Z2 0.40fF
C276 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D div_pd_buffered_0/divider_0/clk 0.29fF
C277 ro_complete_buffered_0/tapered_buf_1/a_210_n610# ro_complete_buffered_0/tapered_buf_1/a_1650_0# 2.89fF
C278 ro_complete_buffered_0/tapered_buf_1/a_160_n140# ro_complete_buffered_0/tapered_buf_1/in 0.19fF
C279 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C280 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C281 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_2/Z4 0.02fF
C282 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C283 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/vco 0.45fF
C284 cp_buffered_0/cp_0/a_1710_n2840# cp_buffered_0/cp_0/a_1710_0# 0.83fF
C285 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z2 0.25fF
C286 divider_1/prescaler_0/Out divider_1/clk 0.51fF
C287 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/D 0.15fF
C288 divider_1/nor_1/A divider_1/tspc_1/Z2 0.15fF
C289 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Z4 0.65fF
C290 ro_complete_0/a3 ro_complete_0/cbank_2/switch_1/vin 0.13fF
C291 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C292 pll_full_0/cp_0/down pll_full_0/cp_0/a_1710_0# 0.32fF
C293 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_2/Z1 0.01fF
C294 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_0/Q 0.22fF
C295 ro_complete_buffered_0/tapered_buf_2/a_210_n610# ro_complete_buffered_0/ro_complete_0/a0 26.29fF
C296 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C297 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C298 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/tspc_1/Q 0.04fF
C299 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 div_pd_buffered_0/divider_0/and_0/OUT 0.06fF
C300 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C301 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C302 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C303 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/clk 0.11fF
C304 div_pd_buffered_0/tapered_buf_2/in div_pd_buffered_0/tapered_buf_2/a_n10_n140# 0.04fF
C305 divider_1/prescaler_0/Out divider_1/tspc_0/a_630_n680# 0.01fF
C306 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z3 0.06fF
C307 cp_buffered_0/cp_0/a_1710_0# cp_buffered_0/cp_0/out 0.84fF
C308 pll_full_1/ref pll_full_1/pd_0/tspc_r_0/Z4 0.02fF
C309 divider_0/tspc_1/Q divider_0/tspc_2/Z3 0.45fF
C310 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Q 0.04fF
C311 divider_1/nor_1/B divider_1/tspc_1/Q 0.51fF
C312 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z4 0.00fF
C313 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Q 0.21fF
C314 divider_1/prescaler_0/tspc_1/Z2 divider_1/clk 0.11fF
C315 pll_full_0/pd_0/DOWN pll_full_0/ref 1.48fF
C316 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C317 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/and_0/A 0.80fF
C318 pll_full_1/ro_complete_0/cbank_2/switch_5/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C319 div_pd_buffered_0/tapered_buf_4/a_1650_0# div_pd_buffered_0/tapered_buf_4/a_4670_0# 4.78fF
C320 divider_1/and_0/B divider_1/and_0/Z1 0.07fF
C321 ro_complete_buffered_0/tapered_buf_4/a_160_n140# ro_complete_buffered_0/tapered_buf_4/in 0.19fF
C322 ro_complete_0/a4 ro_complete_0/cbank_2/v 0.05fF
C323 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/v 1.30fF
C324 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_2/Z3 0.38fF
C325 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z4 0.12fF
C326 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z2 1.07fF
C327 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/Out 0.21fF
C328 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C329 ro_complete_buffered_0/tapered_buf_0/a_1650_0# ro_complete_buffered_0/tapered_buf_0/a_210_n610# 2.89fF
C330 ro_complete_buffered_0/tapered_buf_1/a_160_230# ro_complete_buffered_0/tapered_buf_1/a_160_n140# 0.17fF
C331 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C332 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/nor_0/B 0.47fF
C333 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/tspc_0/Z3 0.05fF
C334 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/clk 0.01fF
C335 divider_1/mc2 divider_1/prescaler_0/tspc_2/a_630_n680# 0.33fF
C336 divider_0/tspc_1/a_630_n680# divider_0/nor_0/B 0.00fF
C337 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z3 0.33fF
C338 filter_buffered_0/tapered_buf_1/a_1650_0# filter_buffered_0/tapered_buf_1/a_210_n610# 2.89fF
C339 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# 0.04fF
C340 div_pd_buffered_0/tapered_buf_4/a_210_n610# div_pd_buffered_0/tapered_buf_4/a_160_n140# 0.22fF
C341 divider_0/nor_0/B divider_0/tspc_2/Z4 0.22fF
C342 divider_0/tspc_2/Z2 divider_0/tspc_2/Z3 0.16fF
C343 ro_complete_buffered_0/tapered_buf_2/a_160_n140# ro_complete_buffered_0/tapered_buf_2/in 0.19fF
C344 divider_1/nor_1/B divider_1/tspc_2/Z2 0.20fF
C345 divider_1/prescaler_0/tspc_1/Z4 divider_1/clk 0.12fF
C346 divider_1/nor_1/A divider_1/and_0/A 0.01fF
C347 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_1/Z4 0.12fF
C348 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C349 ro_complete_buffered_0/tapered_buf_4/a_n10_230# ro_complete_buffered_0/tapered_buf_4/a_n10_n140# 0.01fF
C350 ro_complete_0/cbank_2/switch_2/vin ro_complete_0/cbank_2/v 1.30fF
C351 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/Z1 0.36fF
C352 div_pd_buffered_0/tapered_buf_1/a_4670_0# div_pd_buffered_0/tapered_buf_1/a_210_n610# 29.21fF
C353 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C354 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/Z3 0.65fF
C355 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/tapered_buf_1/in 0.05fF
C356 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_0/Q 0.01fF
C357 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C358 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/and_0/out1 0.31fF
C359 div_pd_buffered_0/divider_0/tspc_1/Z4 div_pd_buffered_0/divider_0/tspc_0/Q 0.15fF
C360 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Q 0.04fF
C361 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z1 0.09fF
C362 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C363 divider_0/and_0/A divider_0/and_0/B 0.18fF
C364 ro_complete_buffered_0/tapered_buf_3/a_n10_230# ro_complete_buffered_0/tapered_buf_3/in 0.02fF
C365 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/a1 0.14fF
C366 divider_1/tspc_2/a_630_n680# divider_1/nor_0/B 0.35fF
C367 divider_1/prescaler_0/tspc_1/Q divider_1/clk 0.60fF
C368 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/nand_0/z1 0.01fF
C369 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/vco 0.11fF
C370 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/pd_0/R 0.36fF
C371 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/tspc_r_1/Z4 0.20fF
C372 div_pd_buffered_0/pd_0/tspc_r_1/Z1 div_pd_buffered_0/pd_0/tspc_r_1/Z2 0.71fF
C373 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/tspc_r_1/z5 0.04fF
C374 ro_complete_buffered_0/tapered_buf_5/a_1650_0# ro_complete_buffered_0/tapered_buf_5/a_4670_0# 4.78fF
C375 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a4 0.12fF
C376 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C377 divider_0/nor_1/A divider_0/tspc_0/a_630_n680# 0.35fF
C378 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z4 0.08fF
C379 ro_complete_buffered_0/tapered_buf_1/a_n10_n140# ro_complete_buffered_0/tapered_buf_1/a_n10_230# 0.01fF
C380 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/and_0/out1 0.06fF
C381 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/nor_1/B 0.35fF
C382 div_pd_buffered_0/divider_0/tspc_1/Z2 div_pd_buffered_0/divider_0/tspc_1/Z4 0.36fF
C383 div_pd_buffered_0/divider_0/tspc_1/Z3 div_pd_buffered_0/divider_0/tspc_1/Q 0.05fF
C384 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/tspc_0/Z2 0.01fF
C385 div_pd_buffered_0/tapered_buf_2/in div_pd_buffered_0/tapered_buf_2/a_n10_230# 0.02fF
C386 divider_1/tspc_0/Z3 divider_1/tspc_0/Q 0.05fF
C387 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z4 0.01fF
C388 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z2 0.19fF
C389 divider_0/prescaler_0/tspc_1/Z4 divider_0/prescaler_0/tspc_1/Z3 0.65fF
C390 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/vco 0.45fF
C391 div_pd_buffered_0/divider_0/nor_0/B div_pd_buffered_0/divider_0/and_0/B 0.29fF
C392 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C393 divider_0/prescaler_0/tspc_2/D divider_0/prescaler_0/nand_0/z1 0.24fF
C394 filter_buffered_0/tapered_buf_0/a_580_0# filter_buffered_0/tapered_buf_0/a_210_n610# 0.84fF
C395 filter_buffered_0/tapered_buf_0/a_160_n140# filter_buffered_0/tapered_buf_0/a_n10_n140# 0.05fF
C396 pll_full_1/filter_0/a_4216_n5230# pll_full_1/vco 1.58fF
C397 div_pd_buffered_0/tapered_buf_3/a_210_n610# div_pd_buffered_0/tapered_buf_3/a_1650_0# 2.89fF
C398 divider_1/nor_1/A divider_1/tspc_1/Z4 0.02fF
C399 divider_1/tspc_1/Z3 divider_1/nor_1/B 0.38fF
C400 ro_complete_buffered_0/tapered_buf_2/a_160_n140# ro_complete_buffered_0/tapered_buf_2/a_n10_n140# 0.05fF
C401 ro_complete_0/a5 ro_complete_0/cbank_2/switch_0/vin 0.09fF
C402 io_clamp_low[0] io_analog[4] 0.53fF
C403 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/div 0.03fF
C404 pll_full_1/divider_0/and_0/OUT pll_full_1/vco 0.06fF
C405 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/tspc_r_1/Qbar1 0.01fF
C406 ro_complete_buffered_0/tapered_buf_6/a_160_n140# ro_complete_buffered_0/tapered_buf_6/a_160_230# 0.17fF
C407 ro_complete_buffered_0/tapered_buf_6/a_1650_0# ro_complete_buffered_0/tapered_buf_6/a_4670_0# 4.78fF
C408 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C409 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C410 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C411 pll_full_0/ro_complete_0/a4 pll_full_0/vco 0.01fF
C412 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 div_pd_buffered_0/divider_0/and_0/OUT 0.05fF
C413 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Q 0.15fF
C414 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z4 0.28fF
C415 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_0/Qbar1 0.30fF
C416 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C417 divider_0/prescaler_0/tspc_2/D divider_0/clk 0.26fF
C418 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/vco 0.64fF
C419 div_pd_buffered_0/tapered_buf_2/a_n10_230# div_pd_buffered_0/tapered_buf_2/a_n10_n140# 0.01fF
C420 ro_complete_0/a1 ro_complete_0/cbank_2/v 0.05fF
C421 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/tspc_r_0/Z1 0.09fF
C422 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/tspc_r_0/Z2 0.19fF
C423 div_pd_buffered_0/tapered_buf_0/a_n10_230# div_pd_buffered_0/tapered_buf_0/a_n10_n140# 0.01fF
C424 div_pd_buffered_0/divider_0/tspc_0/Z4 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# 0.12fF
C425 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C426 ro_complete_buffered_0/tapered_buf_7/a_160_n140# ro_complete_buffered_0/tapered_buf_7/a_160_230# 0.17fF
C427 ro_complete_buffered_0/tapered_buf_7/a_1650_0# ro_complete_buffered_0/tapered_buf_7/a_4670_0# 4.78fF
C428 ro_complete_buffered_0/tapered_buf_3/a_210_n610# ro_complete_buffered_0/ro_complete_0/a1 26.29fF
C429 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/nor_1/A 0.15fF
C430 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/a0 0.09fF
C431 ro_complete_buffered_0/ro_complete_0/a5 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C432 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_4/vin ro_complete_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C433 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C434 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C435 div_pd_buffered_0/divider_0/tspc_1/Q div_pd_buffered_0/divider_0/tspc_2/Z2 0.14fF
C436 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C437 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/clk 0.01fF
C438 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Q 0.91fF
C439 cp_buffered_0/tapered_buf_2/a_160_n140# cp_buffered_0/tapered_buf_2/a_160_230# 0.17fF
C440 cp_buffered_0/tapered_buf_2/a_1650_0# cp_buffered_0/tapered_buf_2/a_4670_0# 4.78fF
C441 pll_full_0/divider_0/and_0/B pll_full_0/divider_0/and_0/Z1 0.07fF
C442 ro_complete_buffered_0/tapered_buf_2/a_1650_0# ro_complete_buffered_0/tapered_buf_2/a_210_n610# 2.89fF
C443 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C444 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C445 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C446 pll_full_1/pd_0/tspc_r_1/z5 pll_full_1/div 0.04fF
C447 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z4 0.36fF
C448 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.15fF
C449 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/and_0/A 0.01fF
C450 divider_1/nor_1/B divider_1/and_0/B 0.31fF
C451 divider_1/prescaler_0/tspc_2/Z4 divider_1/clk 0.12fF
C452 div_pd_buffered_0/pd_0/tspc_r_0/Qbar div_pd_buffered_0/pd_0/R 0.03fF
C453 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_0/Qbar1 0.20fF
C454 div_pd_buffered_0/divider_0/tspc_1/Z3 div_pd_buffered_0/divider_0/nor_1/B 0.38fF
C455 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C456 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C457 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C458 divider_0/nor_0/Z1 divider_0/nor_1/B 0.18fF
C459 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z2 0.01fF
C460 ro_complete_buffered_0/ro_complete_0/a1 ro_complete_buffered_0/tapered_buf_1/in 0.05fF
C461 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z3 0.06fF
C462 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/vco 0.12fF
C463 pll_full_1/pd_0/DOWN pll_full_1/pd_0/UP 4.58fF
C464 div_pd_buffered_0/divider_0/tspc_2/Z1 div_pd_buffered_0/divider_0/tspc_2/Z3 0.06fF
C465 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/D 0.05fF
C466 divider_0/prescaler_0/tspc_0/Z2 divider_0/clk 0.11fF
C467 filter_buffered_0/filter_0/a_4216_n5230# filter_buffered_0/filter_0/v 0.19fF
C468 divider_1/tspc_0/Q divider_1/tspc_1/Z1 0.01fF
C469 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C470 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C471 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/tspc_0/Z4 0.21fF
C472 divider_0/mc2 divider_0/nor_1/A 0.04fF
C473 ro_complete_0/a2 ro_complete_0/cbank_1/v 0.05fF
C474 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/a0 0.13fF
C475 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_2/Z3 0.45fF
C476 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Q 0.04fF
C477 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/and_0/A 0.26fF
C478 div_pd_buffered_0/pd_0/tspc_r_0/z5 div_pd_buffered_0/pd_0/UP 0.03fF
C479 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a3 0.13fF
C480 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/tspc_1/Q 0.51fF
C481 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C482 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C483 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/clk 0.51fF
C484 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C485 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C486 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C487 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C488 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C489 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C490 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Q 0.04fF
C491 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z4 0.00fF
C492 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/nor_0/B 0.35fF
C493 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/vco 0.60fF
C494 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/R 0.29fF
C495 pll_full_1/pd_0/R pll_full_1/pd_0/UP 0.46fF
C496 divider_0/tspc_1/Q divider_0/tspc_2/Z4 0.15fF
C497 cp_buffered_0/tapered_buf_1/a_160_n140# cp_buffered_0/tapered_buf_1/a_580_0# 0.35fF
C498 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C499 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Z4 0.65fF
C500 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/tspc_1/Z4 0.02fF
C501 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C502 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/v 1.43fF
C503 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_2/Z4 0.22fF
C504 pll_full_1/divider_0/tspc_2/Z2 pll_full_1/divider_0/tspc_2/Z3 0.16fF
C505 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/R 0.21fF
C506 pll_full_1/pd_0/tspc_r_0/Qbar pll_full_1/pd_0/tspc_r_0/Qbar1 0.01fF
C507 div_pd_buffered_0/tapered_buf_1/a_n10_n140# div_pd_buffered_0/tapered_buf_1/in 0.04fF
C508 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/nor_1/A 0.04fF
C509 div_pd_buffered_0/pd_0/and_pd_0/Z1 div_pd_buffered_0/pd_0/UP 0.06fF
C510 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/tspc_2/Z2 0.20fF
C511 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/a3 2.04fF
C512 ro_complete_buffered_0/tapered_buf_1/a_n10_n140# ro_complete_buffered_0/tapered_buf_1/in 0.04fF
C513 ro_complete_buffered_0/tapered_buf_1/a_210_n610# ro_complete_buffered_0/tapered_buf_1/a_160_n140# 0.22fF
C514 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z2 1.07fF
C515 pll_full_0/ro_complete_0/a1 pll_full_0/vco 0.11fF
C516 divider_1/mc2 divider_1/nor_1/B 0.06fF
C517 divider_0/nor_1/B divider_0/nor_0/B 0.47fF
C518 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z3 0.05fF
C519 divider_0/tspc_2/Z2 divider_0/tspc_2/Z4 0.36fF
C520 divider_0/tspc_2/Z3 divider_0/Out 0.05fF
C521 ro_complete_buffered_0/tapered_buf_2/a_1650_0# ro_complete_buffered_0/tapered_buf_2/a_4670_0# 4.78fF
C522 cp_buffered_0/tapered_buf_0/a_160_n140# cp_buffered_0/tapered_buf_0/a_580_0# 0.35fF
C523 pll_full_1/pd_0/R pll_full_1/div 0.51fF
C524 divider_1/tspc_1/Q divider_1/tspc_2/a_630_n680# 0.01fF
C525 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_1/Z4 0.21fF
C526 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.06fF
C527 pll_full_1/ro_complete_0/a0 pll_full_1/vco 0.11fF
C528 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/switch_5/vin 0.20fF
C529 pll_full_1/divider_0/and_0/A pll_full_1/divider_0/and_0/B 0.18fF
C530 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/divider_0/mc2 0.34fF
C531 div_pd_buffered_0/tapered_buf_0/a_n10_230# div_pd_buffered_0/pd_0/UP 0.02fF
C532 div_pd_buffered_0/tapered_buf_0/a_160_230# div_pd_buffered_0/tapered_buf_0/a_160_n140# 0.17fF
C533 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C534 pll_full_1/pd_0/DOWN pll_full_1/pd_0/and_pd_0/Out1 0.12fF
C535 ro_complete_buffered_0/ro_complete_0/a1 ro_complete_buffered_0/ro_complete_0/a0 3.46fF
C536 ro_complete_buffered_0/ro_complete_0/a3 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C537 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_0/Q 0.45fF
C538 div_pd_buffered_0/tapered_buf_3/a_160_n140# div_pd_buffered_0/tapered_buf_3/a_160_230# 0.17fF
C539 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z3 0.06fF
C540 divider_1/and_0/OUT divider_1/and_0/Z1 0.04fF
C541 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z2 0.01fF
C542 divider_1/prescaler_0/tspc_2/Q divider_1/clk 0.05fF
C543 ro_complete_buffered_0/tapered_buf_3/a_n10_230# ro_complete_buffered_0/tapered_buf_3/a_160_230# 0.09fF
C544 ro_complete_buffered_0/tapered_buf_3/a_4670_0# ro_complete_buffered_0/tapered_buf_3/a_210_n610# 29.21fF
C545 ro_complete_0/a4 ro_complete_0/cbank_2/switch_1/vin 0.09fF
C546 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/v 1.30fF
C547 pll_full_1/divider_0/prescaler_0/tspc_2/D pll_full_1/divider_0/prescaler_0/nand_0/z1 0.24fF
C548 ro_complete_buffered_0/tapered_buf_5/a_160_n140# ro_complete_buffered_0/tapered_buf_5/in 0.19fF
C549 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C550 div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 div_pd_buffered_0/pd_0/tspc_r_1/z5 0.20fF
C551 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C552 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/div 0.19fF
C553 pll_full_1/pd_0/R pll_full_1/pd_0/and_pd_0/Out1 0.33fF
C554 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C555 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z3 0.16fF
C556 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/vco 0.12fF
C557 io_clamp_low[1] io_clamp_high[1] 0.53fF
C558 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/Q 0.04fF
C559 ro_complete_buffered_0/tapered_buf_2/a_4670_0# ro_complete_buffered_0/tapered_buf_2/a_210_n610# 29.21fF
C560 filter_buffered_0/tapered_buf_0/a_n10_230# filter_buffered_0/tapered_buf_0/a_160_230# 0.09fF
C561 filter_buffered_0/tapered_buf_0/a_4670_0# filter_buffered_0/tapered_buf_0/a_210_n610# 29.21fF
C562 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.13fF
C563 divider_1/and_0/out1 divider_1/and_0/B 0.18fF
C564 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C565 pll_full_1/divider_0/prescaler_0/tspc_2/D pll_full_1/vco 0.26fF
C566 ro_complete_buffered_0/tapered_buf_6/a_580_0# ro_complete_buffered_0/tapered_buf_6/a_210_n610# 0.84fF
C567 ro_complete_buffered_0/tapered_buf_6/a_160_n140# ro_complete_buffered_0/tapered_buf_6/a_n10_n140# 0.05fF
C568 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C569 div_pd_buffered_0/pd_0/and_pd_0/Out1 div_pd_buffered_0/pd_0/and_pd_0/Z1 0.18fF
C570 divider_0/mc2 divider_0/and_0/A 0.16fF
C571 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C572 div_pd_buffered_0/tapered_buf_0/a_580_0# div_pd_buffered_0/tapered_buf_0/a_1650_0# 1.27fF
C573 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C574 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C575 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z4 0.00fF
C576 divider_0/prescaler_0/Out divider_0/tspc_0/Z4 0.12fF
C577 cp_buffered_0/tapered_buf_1/a_n10_230# cp_buffered_0/tapered_buf_1/in 0.02fF
C578 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C579 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C580 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Q 0.05fF
C581 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_0/Z3 0.45fF
C582 pll_full_1/ro_complete_0/a3 pll_full_1/vco 0.11fF
C583 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/a_740_n680# 0.19fF
C584 ro_complete_0/cbank_1/switch_5/vin ro_complete_0/cbank_1/v 1.30fF
C585 ro_complete_buffered_0/tapered_buf_7/a_580_0# ro_complete_buffered_0/tapered_buf_7/a_210_n610# 0.84fF
C586 ro_complete_buffered_0/tapered_buf_7/a_160_n140# ro_complete_buffered_0/tapered_buf_7/a_n10_n140# 0.05fF
C587 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C588 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C589 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C590 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/and_0/B 0.31fF
C591 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q div_pd_buffered_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C592 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C593 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C594 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/vco 0.14fF
C595 cp_buffered_0/tapered_buf_2/a_580_0# cp_buffered_0/tapered_buf_2/a_210_n610# 0.84fF
C596 cp_buffered_0/tapered_buf_2/a_160_n140# cp_buffered_0/tapered_buf_2/a_n10_n140# 0.05fF
C597 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C598 filter_buffered_0/filter_0/v filter_buffered_0/v 0.54fF
C599 cp_buffered_0/tapered_buf_0/a_n10_230# cp_buffered_0/tapered_buf_0/in 0.02fF
C600 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C601 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/D 0.09fF
C602 ro_complete_buffered_0/tapered_buf_2/a_160_n140# ro_complete_buffered_0/tapered_buf_2/a_580_0# 0.35fF
C603 ro_complete_0/a4 ro_complete_0/cbank_1/switch_1/vin 0.09fF
C604 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.05fF
C605 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 0.12fF
C606 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C607 ro_complete_buffered_0/tapered_buf_0/a_1650_0# ro_complete_buffered_0/tapered_buf_0/a_4670_0# 4.78fF
C608 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_1/Z2 0.15fF
C609 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C610 div_pd_buffered_0/tapered_buf_1/a_160_n140# div_pd_buffered_0/tapered_buf_1/in 0.19fF
C611 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/nor_1/B 0.01fF
C612 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C613 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C614 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/nor_0/B 0.15fF
C615 divider_0/nor_1/B divider_0/tspc_1/Z2 0.30fF
C616 ro_complete_buffered_0/tapered_buf_1/a_4670_0# ro_complete_buffered_0/tapered_buf_1/a_1650_0# 4.78fF
C617 div_pd_buffered_0/divider_0/tspc_2/Z1 div_pd_buffered_0/divider_0/tspc_2/Z4 0.00fF
C618 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C619 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C620 divider_1/mc2 divider_1/and_0/out1 0.06fF
C621 divider_0/prescaler_0/tspc_2/Z4 divider_0/prescaler_0/tspc_2/D 0.11fF
C622 divider_0/prescaler_0/Out divider_0/clk 0.51fF
C623 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z2 0.21fF
C624 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z3 0.06fF
C625 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_0/Z2 0.11fF
C626 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C627 divider_1/tspc_0/Q divider_1/tspc_1/Z3 0.45fF
C628 divider_1/nor_0/Z1 divider_1/nor_0/B 0.06fF
C629 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/pd_0/tspc_r_1/Z2 0.71fF
C630 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C631 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_2/Z4 0.15fF
C632 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_0/vin ro_complete_buffered_0/ro_complete_0/a4 0.12fF
C633 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C634 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_1/B 0.30fF
C635 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C636 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C637 divider_0/nor_1/B divider_0/tspc_1/Q 0.51fF
C638 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/Z4 0.65fF
C639 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/div 0.17fF
C640 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/Z1 0.04fF
C641 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z2 0.01fF
C642 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/vco 0.05fF
C643 cp_buffered_0/tapered_buf_1/a_580_0# cp_buffered_0/tapered_buf_1/a_1650_0# 1.27fF
C644 divider_0/prescaler_0/tspc_2/Z3 divider_0/clk 0.45fF
C645 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/Qbar 0.02fF
C646 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/tspc_0/a_630_n680# 0.12fF
C647 ro_complete_0/a5 ro_complete_0/cbank_2/v 0.08fF
C648 ro_complete_0/a0 ro_complete_0/cbank_1/switch_5/vin 0.09fF
C649 pll_full_1/divider_0/tspc_2/Z2 pll_full_1/divider_0/tspc_2/Z4 0.36fF
C650 pll_full_1/divider_0/tspc_2/Z3 pll_full_1/div 0.05fF
C651 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/tspc_r_1/Z4 0.14fF
C652 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/UP 0.03fF
C653 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C654 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C655 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 div_pd_buffered_0/divider_0/clk 0.11fF
C656 divider_0/nor_1/B divider_0/tspc_2/Z2 0.20fF
C657 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/B 0.18fF
C658 filter_buffered_0/filter_0/v filter_buffered_0/tapered_buf_0/a_160_n140# 0.19fF
C659 cp_buffered_0/tapered_buf_0/a_580_0# cp_buffered_0/tapered_buf_0/a_1650_0# 1.27fF
C660 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# 0.33fF
C661 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C662 pll_full_1/pd_0/tspc_r_1/Z4 pll_full_1/div 0.02fF
C663 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C664 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C665 divider_1/tspc_1/Q divider_1/nor_0/B 0.22fF
C666 divider_1/tspc_1/Z2 divider_1/tspc_1/a_630_n680# 0.01fF
C667 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_2/Q 0.19fF
C668 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/clk 0.01fF
C669 div_pd_buffered_0/pd_0/tspc_r_0/Z4 div_pd_buffered_0/pd_0/tspc_r_0/z5 0.04fF
C670 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/v 1.30fF
C671 pll_full_0/filter_0/a_4216_n5230# pll_full_0/vco 1.58fF
C672 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C673 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C674 ro_complete_buffered_0/ro_complete_0/a5 ro_complete_buffered_0/tapered_buf_1/in 0.10fF
C675 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_5/vin ro_complete_buffered_0/ro_complete_0/a0 0.09fF
C676 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_0/B 0.00fF
C677 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C678 divider_1/nor_1/Z1 divider_1/and_0/A 0.80fF
C679 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z4 0.00fF
C680 filter_buffered_0/tapered_buf_1/a_160_n140# filter_buffered_0/v 0.19fF
C681 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C682 div_pd_buffered_0/tapered_buf_4/a_n10_n140# div_pd_buffered_0/pd_0/DOWN 0.04fF
C683 divider_0/and_0/B divider_0/and_0/Z1 0.07fF
C684 ro_complete_buffered_0/tapered_buf_3/a_n10_230# ro_complete_buffered_0/tapered_buf_3/a_n10_n140# 0.01fF
C685 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/UP 0.11fF
C686 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_2/Z4 0.02fF
C687 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.04fF
C688 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/vco 0.45fF
C689 divider_1/nor_0/B divider_1/tspc_2/Z2 0.40fF
C690 divider_1/tspc_2/a_630_n680# divider_1/Out 0.04fF
C691 divider_1/prescaler_0/tspc_0/D divider_1/clk 0.29fF
C692 div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 div_pd_buffered_0/pd_0/UP 0.11fF
C693 ro_complete_buffered_0/tapered_buf_5/a_n10_230# ro_complete_buffered_0/tapered_buf_5/a_160_230# 0.09fF
C694 ro_complete_buffered_0/tapered_buf_5/a_4670_0# ro_complete_buffered_0/tapered_buf_5/a_210_n610# 29.21fF
C695 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C696 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a4 0.09fF
C697 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a5 0.09fF
C698 ro_complete_buffered_0/tapered_buf_7/a_210_n610# ro_complete_buffered_0/ro_complete_0/a5 26.29fF
C699 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/Z1 0.03fF
C700 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C701 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C702 div_pd_buffered_0/tapered_buf_3/a_160_230# div_pd_buffered_0/tapered_buf_3/a_n10_230# 0.09fF
C703 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C704 ro_complete_buffered_0/tapered_buf_3/a_1650_0# ro_complete_buffered_0/tapered_buf_3/a_4670_0# 4.78fF
C705 filter_buffered_0/tapered_buf_0/a_n10_230# filter_buffered_0/tapered_buf_0/a_n10_n140# 0.01fF
C706 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/tspc_r_0/Qbar1 0.20fF
C707 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.03fF
C708 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z3 0.33fF
C709 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.33fF
C710 ro_complete_buffered_0/tapered_buf_6/a_n10_230# ro_complete_buffered_0/tapered_buf_6/a_160_230# 0.09fF
C711 ro_complete_buffered_0/tapered_buf_6/a_4670_0# ro_complete_buffered_0/tapered_buf_6/a_210_n610# 29.21fF
C712 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/Out 0.05fF
C713 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C714 ro_complete_buffered_0/tapered_buf_1/a_210_n610# ro_complete_buffered_0/tapered_buf_1/a_4670_0# 29.21fF
C715 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_1/vin ro_complete_buffered_0/ro_complete_0/a3 0.13fF
C716 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Z4 0.65fF
C717 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C718 pll_full_0/ro_complete_0/a5 pll_full_0/vco 0.15fF
C719 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z1 0.08fF
C720 divider_0/tspc_2/a_630_n680# divider_0/nor_0/B 0.35fF
C721 divider_0/prescaler_0/tspc_1/Q divider_0/clk 0.60fF
C722 ro_complete_0/cbank_0/v ro_complete_0/cbank_2/v 0.04fF
C723 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/tspc_r_0/Z4 0.02fF
C724 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z4 0.01fF
C725 ro_complete_buffered_0/tapered_buf_7/a_n10_230# ro_complete_buffered_0/tapered_buf_7/a_160_230# 0.09fF
C726 ro_complete_buffered_0/tapered_buf_7/a_4670_0# ro_complete_buffered_0/tapered_buf_7/a_210_n610# 29.21fF
C727 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C728 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/DOWN 0.12fF
C729 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q div_pd_buffered_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C730 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 div_pd_buffered_0/divider_0/clk 0.11fF
C731 div_pd_buffered_0/tapered_buf_3/in div_pd_buffered_0/tapered_buf_3/a_160_n140# 0.19fF
C732 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_3/vin ro_complete_buffered_0/tapered_buf_1/in 1.30fF
C733 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/Z3 0.38fF
C734 divider_0/nor_1/B divider_0/and_0/B 0.31fF
C735 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Q 0.91fF
C736 cp_buffered_0/tapered_buf_2/a_n10_230# cp_buffered_0/tapered_buf_2/a_160_230# 0.09fF
C737 cp_buffered_0/tapered_buf_2/a_4670_0# cp_buffered_0/tapered_buf_2/a_210_n610# 29.21fF
C738 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/UP 0.03fF
C739 div_pd_buffered_0/tapered_buf_2/a_1650_0# div_pd_buffered_0/tapered_buf_2/a_4670_0# 4.78fF
C740 ro_complete_buffered_0/tapered_buf_3/a_160_n140# ro_complete_buffered_0/tapered_buf_3/in 0.19fF
C741 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C742 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_0/Q 0.01fF
C743 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.11fF
C744 divider_1/and_0/OUT divider_1/and_0/out1 0.31fF
C745 divider_1/tspc_1/Z4 divider_1/tspc_1/a_630_n680# 0.12fF
C746 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/DOWN 0.03fF
C747 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C748 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C749 divider_0/nor_1/A divider_0/tspc_0/Z4 0.21fF
C750 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.01fF
C751 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C752 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/pd_0/DOWN 0.07fF
C753 pll_full_1/pd_0/R pll_full_1/pd_0/tspc_r_0/Qbar1 0.30fF
C754 div_pd_buffered_0/divider_0/tspc_2/Z3 div_pd_buffered_0/divider_0/tspc_2/Z4 0.65fF
C755 ro_complete_buffered_0/ro_complete_0/a0 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C756 ro_complete_buffered_0/ro_complete_0/cbank_0/v ro_complete_buffered_0/tapered_buf_1/in 1.27fF
C757 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_0/B 0.22fF
C758 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C759 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/vco 0.01fF
C760 div_pd_buffered_0/tapered_buf_2/a_210_n610# div_pd_buffered_0/tapered_buf_2/a_160_n140# 0.22fF
C761 pll_full_0/pd_0/R pll_full_0/pd_0/DOWN 0.36fF
C762 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/z5 0.11fF
C763 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/a4 0.12fF
C764 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C765 divider_1/tspc_1/Z1 divider_1/tspc_1/Z3 0.06fF
C766 divider_1/nor_1/A divider_1/nor_1/B 1.21fF
C767 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/vco 0.45fF
C768 divider_1/nor_0/B divider_1/and_0/B 0.29fF
C769 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C770 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C771 div_pd_buffered_0/pd_0/R div_pd_buffered_0/pd_0/and_pd_0/Z1 0.02fF
C772 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C773 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C774 ro_complete_buffered_0/tapered_buf_1/a_n10_n140# ro_complete_buffered_0/tapered_buf_1/a_160_n140# 0.05fF
C775 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C776 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/Z2 0.23fF
C777 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C778 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/vco 1.46fF
C779 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z2 0.40fF
C780 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/div 0.04fF
C781 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/vco 0.29fF
C782 cp_buffered_0/tapered_buf_1/a_160_n140# cp_buffered_0/tapered_buf_1/a_160_230# 0.17fF
C783 cp_buffered_0/tapered_buf_1/a_1650_0# cp_buffered_0/tapered_buf_1/a_4670_0# 4.78fF
C784 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/a_630_n680# 0.01fF
C785 divider_0/tspc_0/Z2 divider_0/tspc_0/Z3 0.16fF
C786 divider_0/prescaler_0/tspc_2/Z4 divider_0/clk 0.12fF
C787 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C788 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C789 divider_1/prescaler_0/tspc_2/Z2 divider_1/and_0/OUT 0.05fF
C790 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z2 0.25fF
C791 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/ref 0.19fF
C792 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C793 pll_full_1/ro_complete_0/a4 pll_full_1/vco 0.01fF
C794 ro_complete_0/a0 ro_complete_0/cbank_1/v 0.05fF
C795 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.05fF
C796 pll_full_0/pd_0/tspc_r_1/z5 pll_full_0/div 0.04fF
C797 div_pd_buffered_0/tapered_buf_1/a_n10_n140# div_pd_buffered_0/tapered_buf_1/a_n10_230# 0.01fF
C798 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/nor_1/B 0.06fF
C799 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C800 pll_full_1/cp_0/down pll_full_1/cp_0/upbar 0.02fF
C801 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Q 0.04fF
C802 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C803 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/vco 1.27fF
C804 cp_buffered_0/tapered_buf_0/a_160_n140# cp_buffered_0/tapered_buf_0/a_160_230# 0.17fF
C805 cp_buffered_0/tapered_buf_0/a_1650_0# cp_buffered_0/tapered_buf_0/a_4670_0# 4.78fF
C806 div_pd_buffered_0/tapered_buf_4/a_210_n610# div_pd_buffered_0/tapered_buf_4/a_4670_0# 29.21fF
C807 pll_full_0/cp_0/upbar pll_full_0/cp_0/down 0.02fF
C808 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/nor_1/A 0.15fF
C809 pll_full_1/ro_complete_0/cbank_0/switch_5/vin pll_full_1/ro_complete_0/a0 0.09fF
C810 divider_1/tspc_1/Q divider_1/tspc_2/Z2 0.14fF
C811 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_0/D 0.32fF
C812 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/clk 0.01fF
C813 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C814 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.21fF
C815 ro_complete_buffered_0/tapered_buf_4/a_n10_n140# ro_complete_buffered_0/tapered_buf_4/in 0.04fF
C816 ro_complete_0/cbank_2/switch_0/vin ro_complete_0/cbank_2/v 1.45fF
C817 pll_full_1/divider_0/and_0/B pll_full_1/divider_0/and_0/Z1 0.07fF
C818 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/R 0.61fF
C819 divider_0/mc2 divider_0/prescaler_0/tspc_2/a_630_n680# 0.33fF
C820 divider_0/nor_1/A divider_0/prescaler_0/Out 0.15fF
C821 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z3 0.05fF
C822 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_1/z5 0.02fF
C823 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/and_0/B 0.01fF
C824 divider_0/nor_0/Z1 divider_0/nor_0/B 0.06fF
C825 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C826 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/nor_0/B 0.47fF
C827 pll_full_1/cp_0/a_1710_0# pll_full_1/pd_0/DOWN 0.04fF
C828 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z1 1.07fF
C829 divider_1/mc2 divider_1/nor_0/B 0.15fF
C830 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Z4 0.65fF
C831 divider_1/nor_0/B divider_1/Out 0.22fF
C832 divider_1/tspc_2/Z1 divider_1/tspc_2/Z3 0.06fF
C833 ro_complete_0/a2 ro_complete_0/cbank_2/switch_2/vin 0.14fF
C834 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/v 1.30fF
C835 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_0/Z3 0.06fF
C836 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 pll_full_1/vco 0.12fF
C837 ro_complete_buffered_0/tapered_buf_5/a_n10_230# ro_complete_buffered_0/tapered_buf_5/a_n10_n140# 0.01fF
C838 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_0/vin ro_complete_buffered_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C839 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C840 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/and_0/B 0.20fF
C841 divider_1/tspc_0/Z3 divider_1/tspc_0/Z1 0.06fF
C842 divider_0/nor_1/B divider_0/tspc_0/a_630_n680# 0.01fF
C843 divider_0/nor_1/Z1 divider_0/and_0/B 0.18fF
C844 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/out1 0.31fF
C845 pll_full_0/divider_0/tspc_1/Z4 pll_full_0/divider_0/tspc_0/Q 0.15fF
C846 io_clamp_low[0] io_clamp_high[0] 0.53fF
C847 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/a3 0.13fF
C848 div_pd_buffered_0/tapered_buf_3/a_160_n140# div_pd_buffered_0/tapered_buf_3/a_210_n610# 0.22fF
C849 divider_0/tspc_1/Q divider_0/tspc_2/a_630_n680# 0.01fF
C850 divider_0/prescaler_0/tspc_1/Z3 divider_0/clk 0.45fF
C851 divider_1/tspc_1/Z2 divider_1/tspc_1/Z4 0.36fF
C852 divider_1/tspc_1/Z3 divider_1/tspc_1/Q 0.05fF
C853 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z4 0.08fF
C854 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z3 0.05fF
C855 divider_1/nor_0/Z1 divider_1/and_0/B 0.78fF
C856 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/a_630_n680# 0.01fF
C857 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C858 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.05fF
C859 ro_complete_buffered_0/tapered_buf_4/a_160_n140# ro_complete_buffered_0/tapered_buf_4/a_160_230# 0.17fF
C860 ro_complete_buffered_0/tapered_buf_4/a_1650_0# ro_complete_buffered_0/tapered_buf_4/a_4670_0# 4.78fF
C861 ro_complete_buffered_0/tapered_buf_2/in ro_complete_buffered_0/tapered_buf_2/a_n10_n140# 0.04fF
C862 ro_complete_0/a3 ro_complete_0/cbank_1/v 0.05fF
C863 pll_full_0/ref pll_full_0/pd_0/tspc_r_0/Z1 0.17fF
C864 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/nor_0/B 0.35fF
C865 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/vco 0.60fF
C866 ro_complete_buffered_0/tapered_buf_6/a_n10_230# ro_complete_buffered_0/tapered_buf_6/a_n10_n140# 0.01fF
C867 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C868 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.05fF
C869 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_2/vin 0.22fF
C870 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_1/B 0.35fF
C871 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/vco 0.11fF
C872 div_pd_buffered_0/tapered_buf_0/a_160_n140# div_pd_buffered_0/tapered_buf_0/a_210_n610# 0.22fF
C873 div_pd_buffered_0/divider_0/nor_1/Z1 div_pd_buffered_0/divider_0/and_0/A 0.80fF
C874 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z3 0.11fF
C875 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/B 0.29fF
C876 divider_0/and_0/OUT divider_0/and_0/Z1 0.04fF
C877 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z2 0.01fF
C878 divider_0/prescaler_0/tspc_2/Q divider_0/clk 0.05fF
C879 div_pd_buffered_0/tapered_buf_3/a_210_n610# div_pd_buffered_0/tapered_buf_3/a_4670_0# 29.21fF
C880 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/clk 0.01fF
C881 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_0/Z2 1.07fF
C882 pll_full_1/ro_complete_0/a1 pll_full_1/vco 0.11fF
C883 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/tspc_r_0/z5 0.11fF
C884 ro_complete_buffered_0/tapered_buf_7/a_n10_230# ro_complete_buffered_0/tapered_buf_7/a_n10_n140# 0.01fF
C885 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_1/B 0.06fF
C886 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/and_0/OUT 0.05fF
C887 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/z5 0.11fF
C888 div_pd_buffered_0/tapered_buf_1/a_n10_230# div_pd_buffered_0/tapered_buf_1/a_160_230# 0.09fF
C889 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D div_pd_buffered_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C890 divider_1/prescaler_0/m1_2700_2190# divider_1/and_0/OUT 0.14fF
C891 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/D 0.09fF
C892 cp_buffered_0/tapered_buf_2/a_n10_230# cp_buffered_0/tapered_buf_2/a_n10_n140# 0.01fF
C893 filter_buffered_0/tapered_buf_1/a_n10_230# filter_buffered_0/v 0.02fF
C894 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C895 divider_0/and_0/out1 divider_0/and_0/B 0.18fF
C896 ro_complete_buffered_0/tapered_buf_3/a_160_n140# ro_complete_buffered_0/tapered_buf_3/a_160_230# 0.17fF
C897 div_pd_buffered_0/tapered_buf_0/a_n10_230# div_pd_buffered_0/tapered_buf_0/a_160_230# 0.09fF
C898 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_0/Q 0.45fF
C899 pll_full_1/pd_0/tspc_r_0/Qbar pll_full_1/pd_0/DOWN 0.02fF
C900 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/tspc_r_1/Z1 0.09fF
C901 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/tspc_r_1/Z2 0.19fF
C902 ro_complete_buffered_0/tapered_buf_5/a_580_0# ro_complete_buffered_0/tapered_buf_5/a_1650_0# 1.27fF
C903 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/v 1.30fF
C904 div_pd_buffered_0/tapered_buf_2/a_4670_0# div_pd_buffered_0/tapered_buf_2/a_210_n610# 29.21fF
C905 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C906 div_pd_buffered_0/tapered_buf_1/a_580_0# div_pd_buffered_0/tapered_buf_1/a_160_230# 0.02fF
C907 div_pd_buffered_0/tapered_buf_1/a_4670_0# div_pd_buffered_0/tapered_buf_1/a_1650_0# 4.78fF
C908 div_pd_buffered_0/tapered_buf_3/in div_pd_buffered_0/tapered_buf_3/a_n10_230# 0.02fF
C909 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/a_630_n680# 0.19fF
C910 ro_complete_buffered_0/tapered_buf_0/in ro_complete_buffered_0/tapered_buf_0/a_n10_n140# 0.04fF
C911 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z2 0.14fF
C912 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z3 0.05fF
C913 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C914 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/vco 0.01fF
C915 div_pd_buffered_0/tapered_buf_2/a_580_0# div_pd_buffered_0/tapered_buf_2/a_160_230# 0.02fF
C916 divider_0/tspc_1/Z1 divider_0/tspc_0/Q 0.01fF
C917 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Q 0.05fF
C918 cp_buffered_0/cp_0/a_1710_n2840# cp_buffered_0/cp_0/upbar 0.29fF
C919 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C920 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/and_0/OUT 0.06fF
C921 ro_complete_buffered_0/tapered_buf_2/a_580_0# ro_complete_buffered_0/tapered_buf_2/a_160_230# 0.02fF
C922 io_clamp_high[2] io_analog[6] 0.53fF
C923 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/pd_0/tspc_r_1/Z2 0.14fF
C924 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/tspc_0/Z3 0.16fF
C925 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 pll_full_1/vco 0.12fF
C926 pll_full_1/pd_0/tspc_r_0/Qbar pll_full_1/pd_0/R 0.03fF
C927 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Qbar1 0.38fF
C928 div_pd_buffered_0/tapered_buf_1/a_580_0# div_pd_buffered_0/tapered_buf_1/a_160_n140# 0.35fF
C929 divider_0/mc2 divider_0/nor_1/B 0.06fF
C930 divider_0/nor_1/A divider_0/prescaler_0/tspc_1/Q 0.03fF
C931 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C932 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_1/vin ro_complete_buffered_0/ro_complete_0/a4 0.09fF
C933 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_0/vin ro_complete_buffered_0/ro_complete_0/a5 0.09fF
C934 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/B 0.18fF
C935 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C936 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_1/Z3 0.03fF
C937 div_pd_buffered_0/tapered_buf_1/a_210_n610# div_pd_buffered_0/tapered_buf_1/a_1650_0# 2.89fF
C938 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C939 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C940 div_pd_buffered_0/tapered_buf_2/a_580_0# div_pd_buffered_0/tapered_buf_2/a_160_n140# 0.35fF
C941 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_0/a_630_n680# 0.04fF
C942 pll_full_0/divider_0/nor_0/B pll_full_0/div 0.27fF
C943 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z3 0.06fF
C944 div_pd_buffered_0/tapered_buf_4/a_210_n610# div_pd_buffered_0/tapered_buf_4/out 26.29fF
C945 cp_buffered_0/tapered_buf_1/a_580_0# cp_buffered_0/tapered_buf_1/a_210_n610# 0.84fF
C946 cp_buffered_0/tapered_buf_1/a_160_n140# cp_buffered_0/tapered_buf_1/a_n10_n140# 0.05fF
C947 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/DOWN 0.03fF
C948 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C949 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z4 0.00fF
C950 div_pd_buffered_0/tapered_buf_4/a_580_0# div_pd_buffered_0/tapered_buf_4/a_1650_0# 1.27fF
C951 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Q 0.20fF
C952 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/D 0.09fF
C953 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/tspc_r_0/Z3 0.65fF
C954 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/div 0.17fF
C955 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C956 divider_0/nor_1/A divider_0/tspc_0/Q 0.55fF
C957 ro_complete_buffered_0/tapered_buf_0/a_580_0# ro_complete_buffered_0/tapered_buf_0/a_160_230# 0.02fF
C958 ro_complete_buffered_0/tapered_buf_0/a_160_n140# ro_complete_buffered_0/tapered_buf_0/a_210_n610# 0.22fF
C959 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Q 0.51fF
C960 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z2 0.01fF
C961 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C962 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C963 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/R 0.27fF
C964 div_pd_buffered_0/tapered_buf_0/out div_pd_buffered_0/tapered_buf_0/a_210_n610# 26.29fF
C965 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/tspc_0/Q 0.55fF
C966 pll_full_1/cp_0/a_1710_0# pll_full_1/cp_0/down 0.32fF
C967 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z3 0.06fF
C968 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/UP 0.06fF
C969 filter_buffered_0/filter_0/v filter_buffered_0/tapered_buf_0/a_n10_230# 0.02fF
C970 cp_buffered_0/tapered_buf_0/a_580_0# cp_buffered_0/tapered_buf_0/a_210_n610# 0.84fF
C971 cp_buffered_0/tapered_buf_0/a_160_n140# cp_buffered_0/tapered_buf_0/a_n10_n140# 0.05fF
C972 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/DOWN 0.11fF
C973 pll_full_0/pd_0/R pll_full_0/ref 0.61fF
C974 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C975 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C976 ro_complete_buffered_0/tapered_buf_3/a_580_0# ro_complete_buffered_0/tapered_buf_3/a_210_n610# 0.84fF
C977 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C978 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_1/Qbar 0.21fF
C979 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C980 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/vco 0.14fF
C981 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/nand_1/z1 0.22fF
C982 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/tspc_0/D 0.04fF
C983 div_pd_buffered_0/pd_0/tspc_r_0/Qbar div_pd_buffered_0/pd_0/DOWN 0.02fF
C984 div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 div_pd_buffered_0/pd_0/R 0.30fF
C985 div_pd_buffered_0/divider_0/tspc_1/Z2 div_pd_buffered_0/divider_0/nor_1/A 0.15fF
C986 div_pd_buffered_0/divider_0/nor_0/Z1 div_pd_buffered_0/divider_0/nor_0/B 0.06fF
C987 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z4 0.12fF
C988 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C989 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C990 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_2/Z2 0.20fF
C991 pll_full_1/pd_0/R pll_full_1/pd_0/tspc_r_0/Z2 0.21fF
C992 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Q 0.21fF
C993 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C994 div_pd_buffered_0/tapered_buf_4/a_580_0# div_pd_buffered_0/tapered_buf_4/a_160_230# 0.02fF
C995 divider_1/tspc_0/a_630_n680# divider_1/nor_1/B 0.01fF
C996 divider_1/nor_1/A divider_1/tspc_0/Q 0.55fF
C997 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/tspc_1/Z2 0.15fF
C998 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_0/a_630_n680# 0.01fF
C999 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_5/vin 0.20fF
C1000 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_2/a_630_n680# 0.01fF
C1001 divider_1/tspc_2/Z1 divider_1/tspc_2/Z4 0.00fF
C1002 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1003 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/nor_1/B 1.21fF
C1004 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_0/B 0.06fF
C1005 div_pd_buffered_0/divider_0/and_0/out1 div_pd_buffered_0/divider_0/and_0/A 0.01fF
C1006 div_pd_buffered_0/divider_0/tspc_0/Z3 div_pd_buffered_0/divider_0/tspc_0/Q 0.05fF
C1007 ro_complete_buffered_0/ro_complete_0/a0 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C1008 divider_0/tspc_1/Q divider_0/nor_0/B 0.22fF
C1009 divider_0/tspc_0/Z1 divider_0/tspc_0/Z3 0.06fF
C1010 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_2/Q 0.19fF
C1011 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/clk 0.01fF
C1012 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z4 0.12fF
C1013 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z2 1.07fF
C1014 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/nor_1/B 0.30fF
C1015 ro_complete_buffered_0/tapered_buf_4/a_580_0# ro_complete_buffered_0/tapered_buf_4/a_210_n610# 0.84fF
C1016 ro_complete_buffered_0/tapered_buf_4/a_160_n140# ro_complete_buffered_0/tapered_buf_4/a_n10_n140# 0.05fF
C1017 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_0/vin 0.19fF
C1018 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/v 1.30fF
C1019 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/Z1 0.04fF
C1020 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z2 0.01fF
C1021 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/vco 0.05fF
C1022 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C1023 div_pd_buffered_0/pd_0/UP div_pd_buffered_0/tapered_buf_0/a_n10_n140# 0.04fF
C1024 div_pd_buffered_0/divider_0/tspc_1/Z1 div_pd_buffered_0/divider_0/tspc_0/Q 0.01fF
C1025 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/a5 2.39fF
C1026 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_0/vin ro_complete_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C1027 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/and_0/OUT 0.14fF
C1028 pll_full_0/divider_0/prescaler_0/Out pll_full_0/vco 0.51fF
C1029 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/and_pd_0/Z1 0.18fF
C1030 divider_1/prescaler_0/m1_2700_2190# divider_1/nor_1/A 0.01fF
C1031 divider_0/nor_0/B divider_0/tspc_2/Z2 0.40fF
C1032 divider_0/tspc_2/a_630_n680# divider_0/Out 0.04fF
C1033 divider_0/prescaler_0/tspc_0/D divider_0/clk 0.29fF
C1034 pll_full_0/pd_0/DOWN pll_full_0/pd_0/UP 4.58fF
C1035 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/B 0.18fF
C1036 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/and_0/OUT 0.05fF
C1037 div_pd_buffered_0/divider_0/tspc_1/Z1 div_pd_buffered_0/divider_0/tspc_1/Z2 1.07fF
C1038 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C1039 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/and_0/B 0.08fF
C1040 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C1041 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C1042 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/vco 0.12fF
C1043 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z4 0.20fF
C1044 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_2/D 0.16fF
C1045 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z3 0.16fF
C1046 divider_0/tspc_0/Z1 divider_0/tspc_0/Z2 1.07fF
C1047 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1048 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z3 0.05fF
C1049 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/z5 0.11fF
C1050 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1051 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/z5 0.11fF
C1052 ro_complete_buffered_0/tapered_buf_3/a_160_n140# ro_complete_buffered_0/tapered_buf_3/a_n10_n140# 0.05fF
C1053 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_4/vin 0.20fF
C1054 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/nor_0/B 0.00fF
C1055 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.05fF
C1056 ro_complete_buffered_0/tapered_buf_5/a_160_n140# ro_complete_buffered_0/tapered_buf_5/a_160_230# 0.17fF
C1057 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/R 0.51fF
C1058 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z2 1.07fF
C1059 divider_1/tspc_0/Z3 divider_1/nor_1/A 0.38fF
C1060 divider_0/nor_0/Z1 divider_0/and_0/B 0.78fF
C1061 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/B 0.31fF
C1062 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C1063 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C1064 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C1065 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/a4 0.09fF
C1066 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/a5 0.09fF
C1067 divider_1/mc2 divider_1/and_0/B 0.20fF
C1068 divider_0/tspc_1/Z3 divider_0/tspc_0/Q 0.45fF
C1069 ro_complete_buffered_0/tapered_buf_3/a_580_0# ro_complete_buffered_0/tapered_buf_3/a_160_n140# 0.35fF
C1070 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/z5 0.20fF
C1071 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/tspc_0/Z1 0.03fF
C1072 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C1073 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1074 io_clamp_low[1] io_analog[5] 0.53fF
C1075 ro_complete_0/a4 ro_complete_0/cbank_1/v 0.05fF
C1076 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C1077 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1078 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/a3 0.09fF
C1079 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/pd_0/tspc_r_1/Z3 0.09fF
C1080 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/tapered_buf_1/a_210_n610# 26.29fF
C1081 divider_0/mc2 divider_0/and_0/out1 0.06fF
C1082 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# div_pd_buffered_0/divider_0/clk 0.14fF
C1083 divider_1/nor_1/Z1 divider_1/nor_1/B 0.06fF
C1084 divider_0/tspc_1/Z1 divider_0/tspc_1/Z3 0.06fF
C1085 ro_complete_buffered_0/tapered_buf_1/in ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.36fF
C1086 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z4 0.00fF
C1087 cp_buffered_0/tapered_buf_1/a_n10_230# cp_buffered_0/tapered_buf_1/a_160_230# 0.09fF
C1088 cp_buffered_0/tapered_buf_1/a_4670_0# cp_buffered_0/tapered_buf_1/a_210_n610# 29.21fF
C1089 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/Out 0.05fF
C1090 divider_0/and_0/OUT divider_0/and_0/out1 0.31fF
C1091 divider_0/tspc_1/Z4 divider_0/tspc_0/Q 0.15fF
C1092 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Q 0.04fF
C1093 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/clk 0.01fF
C1094 ro_complete_buffered_0/tapered_buf_2/a_210_n610# ro_complete_buffered_0/tapered_buf_2/a_160_n140# 0.22fF
C1095 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_1/Z4 0.65fF
C1096 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.15fF
C1097 pll_full_1/ro_complete_0/a5 pll_full_1/vco 0.15fF
C1098 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 0.38fF
C1099 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1100 div_pd_buffered_0/tapered_buf_1/a_580_0# div_pd_buffered_0/tapered_buf_1/a_210_n610# 0.84fF
C1101 div_pd_buffered_0/divider_0/tspc_0/Z1 div_pd_buffered_0/divider_0/nor_1/A 0.03fF
C1102 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1103 divider_0/nor_1/A divider_0/and_0/A 0.01fF
C1104 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1105 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/Z4 0.20fF
C1106 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_1/z5 0.03fF
C1107 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/tspc_0/Q 0.01fF
C1108 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/and_0/A 0.01fF
C1109 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1110 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1111 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/vco 0.01fF
C1112 divider_0/tspc_1/Z1 divider_0/tspc_1/Z4 0.00fF
C1113 filter_buffered_0/tapered_buf_1/a_160_n140# filter_buffered_0/tapered_buf_1/a_160_230# 0.17fF
C1114 cp_buffered_0/tapered_buf_0/a_n10_230# cp_buffered_0/tapered_buf_0/a_160_230# 0.09fF
C1115 cp_buffered_0/tapered_buf_0/a_4670_0# cp_buffered_0/tapered_buf_0/a_210_n610# 29.21fF
C1116 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1117 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z3 0.06fF
C1118 divider_0/nor_0/B divider_0/and_0/B 0.29fF
C1119 divider_1/nor_1/B divider_1/tspc_1/a_630_n680# 0.35fF
C1120 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/nand_1/z1 0.01fF
C1121 divider_1/prescaler_0/tspc_2/Z2 divider_1/clk 0.11fF
C1122 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z1 0.71fF
C1123 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/tspc_0/Z3 0.38fF
C1124 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C1125 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/nor_1/A 0.01fF
C1126 div_pd_buffered_0/divider_0/tspc_1/Z2 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# 0.01fF
C1127 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1128 divider_1/tspc_0/Z3 divider_1/tspc_0/Z2 0.16fF
C1129 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_2/vin ro_complete_buffered_0/tapered_buf_1/in 1.30fF
C1130 pll_full_0/ro_complete_0/cbank_2/v pll_full_0/vco 1.36fF
C1131 div_pd_buffered_0/divider_0/nor_0/B div_pd_buffered_0/divider_0/tspc_2/Z1 0.03fF
C1132 div_pd_buffered_0/divider_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/tspc_2/Z3 0.05fF
C1133 cp_buffered_0/cp_0/a_10_n50# cp_buffered_0/cp_0/a_1710_0# 0.04fF
C1134 divider_0/prescaler_0/tspc_2/Z2 divider_0/and_0/OUT 0.05fF
C1135 ro_complete_buffered_0/tapered_buf_3/a_580_0# ro_complete_buffered_0/tapered_buf_3/a_1650_0# 1.27fF
C1136 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/prescaler_0/m1_2700_2190# 0.01fF
C1137 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C1138 divider_1/prescaler_0/tspc_0/Z3 divider_1/clk 0.64fF
C1139 divider_1/tspc_2/Z3 divider_1/tspc_2/Z4 0.65fF
C1140 ro_complete_0/a5 ro_complete_0/cbank_1/switch_0/vin 0.09fF
C1141 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/v 1.30fF
C1142 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/nor_0/B 0.22fF
C1143 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.19fF
C1144 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/vco 0.01fF
C1145 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Z2 0.25fF
C1146 div_pd_buffered_0/pd_0/tspc_r_1/Z4 div_pd_buffered_0/pd_0/tspc_r_1/z5 0.04fF
C1147 div_pd_buffered_0/tapered_buf_3/a_n10_n140# div_pd_buffered_0/tapered_buf_3/a_160_n140# 0.05fF
C1148 divider_0/nor_1/A divider_0/tspc_1/Z4 0.02fF
C1149 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/a_630_n680# 0.35fF
C1150 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C1151 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1152 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/tspc_1/Z4 0.02fF
C1153 div_pd_buffered_0/divider_0/tspc_0/Z1 div_pd_buffered_0/divider_0/tspc_0/Z3 0.06fF
C1154 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1155 ro_complete_buffered_0/ro_complete_0/a0 ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C1156 cp_buffered_0/cp_0/a_1710_n2840# cp_buffered_0/cp_0/out 0.61fF
C1157 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1158 divider_0/tspc_1/Q divider_0/tspc_2/Z2 0.14fF
C1159 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z3 0.05fF
C1160 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_0/D 0.32fF
C1161 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/clk 0.01fF
C1162 filter_buffered_0/tapered_buf_0/a_210_n610# filter_buffered_0/v 26.29fF
C1163 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/tspc_r_1/z5 0.02fF
C1164 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/tspc_0/Z2 0.23fF
C1165 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C1166 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/vco 1.46fF
C1167 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z3 0.16fF
C1168 ro_complete_0/a1 ro_complete_0/cbank_1/v 0.05fF
C1169 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_2/Z2 0.40fF
C1170 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/div 0.04fF
C1171 pll_full_1/divider_0/prescaler_0/tspc_0/D pll_full_1/vco 0.29fF
C1172 div_pd_buffered_0/divider_0/nor_0/Z1 div_pd_buffered_0/divider_0/nor_1/B 0.18fF
C1173 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1174 div_pd_buffered_0/pd_0/and_pd_0/Out1 div_pd_buffered_0/pd_0/UP 0.33fF
C1175 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C1176 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1177 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z3 0.33fF
C1178 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_3/vin ro_complete_buffered_0/ro_complete_0/a1 0.14fF
C1179 ro_complete_buffered_0/tapered_buf_0/a_n10_230# ro_complete_buffered_0/tapered_buf_0/in 0.02fF
C1180 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C1181 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1182 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C1183 pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_0/vco 1.46fF
C1184 pll_full_1/pd_0/DOWN pll_full_1/pd_0/R 0.36fF
C1185 div_pd_buffered_0/divider_0/tspc_1/Z3 div_pd_buffered_0/divider_0/tspc_0/Q 0.45fF
C1186 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C1187 div_pd_buffered_0/tapered_buf_3/a_580_0# div_pd_buffered_0/tapered_buf_3/a_1650_0# 1.27fF
C1188 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z3 0.33fF
C1189 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# 0.05fF
C1190 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/a_630_n680# 0.01fF
C1191 divider_0/nor_0/B divider_0/Out 0.22fF
C1192 divider_0/tspc_2/Z1 divider_0/tspc_2/Z3 0.06fF
C1193 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/a4 0.12fF
C1194 ro_complete_0/a2 ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1195 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C1196 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_1/Q 0.04fF
C1197 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1198 pll_full_1/ro_complete_0/cbank_0/v pll_full_1/vco 1.27fF
C1199 pll_full_1/ref pll_full_1/pd_0/tspc_r_0/Qbar1 0.12fF
C1200 div_pd_buffered_0/pd_0/tspc_r_0/Z2 div_pd_buffered_0/pd_0/tspc_r_0/Z4 0.14fF
C1201 div_pd_buffered_0/divider_0/tspc_1/Z2 div_pd_buffered_0/divider_0/tspc_1/Z3 0.16fF
C1202 div_pd_buffered_0/divider_0/tspc_0/Z1 div_pd_buffered_0/divider_0/tspc_0/Z2 1.07fF
C1203 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C1204 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_1/B 0.18fF
C1205 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1206 divider_1/tspc_0/Z3 divider_1/tspc_0/Z4 0.65fF
C1207 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/Z2 0.36fF
C1208 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_0/Z3 0.05fF
C1209 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/clk 0.14fF
C1210 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C1211 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1212 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/nand_0/z1 0.07fF
C1213 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z2 0.01fF
C1214 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1215 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1216 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/pd_0/tspc_r_1/Z3 0.09fF
C1217 divider_1/tspc_0/a_630_n680# divider_1/tspc_0/Q 0.04fF
C1218 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z4 0.12fF
C1219 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/nor_0/B 0.47fF
C1220 divider_1/and_0/OUT divider_1/and_0/B 0.01fF
C1221 div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 div_pd_buffered_0/pd_0/R 0.01fF
C1222 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/pd_0/tspc_r_1/Qbar 0.21fF
C1223 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/tspc_r_1/Z4 0.02fF
C1224 ro_complete_buffered_0/tapered_buf_5/a_580_0# ro_complete_buffered_0/tapered_buf_5/a_210_n610# 0.84fF
C1225 ro_complete_buffered_0/tapered_buf_5/a_160_n140# ro_complete_buffered_0/tapered_buf_5/a_n10_n140# 0.05fF
C1226 div_pd_buffered_0/divider_0/tspc_1/Z1 div_pd_buffered_0/divider_0/tspc_1/Z4 0.00fF
C1227 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C1228 div_pd_buffered_0/divider_0/nor_0/Z1 div_pd_buffered_0/divider_0/and_0/B 0.78fF
C1229 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/Out 0.21fF
C1230 ro_complete_buffered_0/tapered_buf_0/a_1650_0# ro_complete_buffered_0/tapered_buf_0/a_580_0# 1.27fF
C1231 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z3 0.16fF
C1232 pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1233 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z1 0.08fF
C1234 divider_0/prescaler_0/tspc_1/Z4 divider_0/prescaler_0/tspc_1/Z2 0.36fF
C1235 ro_complete_buffered_0/ro_complete_0/a3 ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C1236 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C1237 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/vco 0.11fF
C1238 divider_1/prescaler_0/m1_2700_2190# divider_1/clk 0.01fF
C1239 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_0/Z2 0.21fF
C1240 filter_buffered_0/tapered_buf_0/a_580_0# filter_buffered_0/tapered_buf_0/a_160_230# 0.02fF
C1241 filter_buffered_0/tapered_buf_0/a_160_n140# filter_buffered_0/tapered_buf_0/a_210_n610# 0.22fF
C1242 filter_buffered_0/tapered_buf_1/a_n10_n140# filter_buffered_0/v 0.04fF
C1243 divider_1/tspc_1/Z2 divider_1/nor_1/B 0.30fF
C1244 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1245 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Q 0.04fF
C1246 ro_complete_0/a3 ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1247 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/out1 0.31fF
C1248 pll_full_1/divider_0/tspc_1/Z4 pll_full_1/divider_0/tspc_0/Q 0.15fF
C1249 div_pd_buffered_0/divider_0/tspc_0/Z1 div_pd_buffered_0/divider_0/tspc_0/Z4 0.00fF
C1250 div_pd_buffered_0/tapered_buf_3/a_n10_n140# div_pd_buffered_0/tapered_buf_3/in 0.04fF
C1251 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C1252 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/clk 0.01fF
C1253 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/B 0.78fF
C1254 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divider_0/tspc_2/Z4 0.65fF
C1255 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/tspc_r_0/Qbar 0.05fF
C1256 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z2 1.07fF
C1257 cp_buffered_0/tapered_buf_1/a_n10_230# cp_buffered_0/tapered_buf_1/a_n10_n140# 0.01fF
C1258 cp_buffered_0/cp_0/a_1710_0# cp_buffered_0/cp_0/down 0.32fF
C1259 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1260 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/div 0.12fF
C1261 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/ref 0.04fF
C1262 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/nor_1/B 0.35fF
C1263 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/vco 0.11fF
C1264 div_pd_buffered_0/tapered_buf_2/a_210_n610# div_pd_buffered_0/divider_0/mc2 26.29fF
C1265 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/v 1.30fF
C1266 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/and_0/B 0.29fF
C1267 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/tspc_r_0/Z1 0.17fF
C1268 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1269 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C1270 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.21fF
C1271 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C1272 div_pd_buffered_0/divider_0/tspc_1/Q div_pd_buffered_0/divider_0/tspc_2/Z1 0.01fF
C1273 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/tspc_0/Q 0.22fF
C1274 ro_complete_buffered_0/ro_complete_0/a3 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_2/vin 0.21fF
C1275 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1276 divider_1/mc2 divider_1/and_0/OUT 0.05fF
C1277 divider_0/tspc_1/Z3 divider_0/tspc_1/Z4 0.65fF
C1278 divider_0/tspc_1/a_630_n680# divider_0/tspc_0/Q 0.01fF
C1279 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/pd_0/tspc_r_0/Qbar 0.02fF
C1280 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_1/Q 0.13fF
C1281 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z4 0.00fF
C1282 filter_buffered_0/tapered_buf_1/a_580_0# filter_buffered_0/tapered_buf_1/a_210_n610# 0.84fF
C1283 filter_buffered_0/tapered_buf_1/a_160_n140# filter_buffered_0/tapered_buf_1/a_n10_n140# 0.05fF
C1284 cp_buffered_0/tapered_buf_0/a_n10_230# cp_buffered_0/tapered_buf_0/a_n10_n140# 0.01fF
C1285 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_0/Qbar 0.03fF
C1286 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/nor_1/B 0.06fF
C1287 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1288 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/and_0/OUT 0.05fF
C1289 divider_1/prescaler_0/tspc_0/D divider_1/prescaler_0/nand_1/z1 0.21fF
C1290 divider_1/nor_1/B divider_1/and_0/A 0.26fF
C1291 div_pd_buffered_0/pd_0/tspc_r_0/Z2 div_pd_buffered_0/pd_0/R 0.21fF
C1292 div_pd_buffered_0/divider_0/tspc_1/Z2 div_pd_buffered_0/divider_0/nor_1/B 0.30fF
C1293 div_pd_buffered_0/tapered_buf_2/a_1650_0# div_pd_buffered_0/tapered_buf_2/a_210_n610# 2.89fF
C1294 divider_1/prescaler_0/Out divider_1/prescaler_0/m1_2700_2190# 0.11fF
C1295 ro_complete_buffered_0/tapered_buf_6/a_210_n610# ro_complete_buffered_0/ro_complete_0/a4 26.29fF
C1296 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1297 pll_full_0/ro_complete_0/a1 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1298 pll_full_1/pd_0/tspc_r_1/Z4 pll_full_1/pd_0/tspc_r_1/z5 0.04fF
C1299 div_pd_buffered_0/divider_0/nor_0/B div_pd_buffered_0/divider_0/tspc_2/Z3 0.38fF
C1300 div_pd_buffered_0/divider_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/tspc_2/Z4 0.12fF
C1301 div_pd_buffered_0/divider_0/tspc_2/Z1 div_pd_buffered_0/divider_0/tspc_2/Z2 1.07fF
C1302 divider_1/tspc_0/Z3 divider_1/tspc_0/a_630_n680# 0.05fF
C1303 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_4/vin ro_complete_buffered_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C1304 cp_buffered_0/tapered_buf_2/a_210_n610# cp_buffered_0/cp_0/upbar 26.29fF
C1305 divider_1/prescaler_0/tspc_0/Z4 divider_1/clk 0.12fF
C1306 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Q 0.20fF
C1307 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/D 0.09fF
C1308 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1309 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_2/Z2 0.14fF
C1310 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Z3 0.05fF
C1311 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/tspc_0/D 0.32fF
C1312 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/vco 0.01fF
C1313 ro_complete_buffered_0/tapered_buf_5/a_n10_n140# ro_complete_buffered_0/tapered_buf_5/in 0.04fF
C1314 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/pd_0/and_pd_0/Z1 0.07fF
C1315 divider_0/mc2 divider_0/nor_0/B 0.15fF
C1316 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/tspc_1/Z4 0.12fF
C1317 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C1318 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/clk 0.64fF
C1319 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C1320 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C1321 div_pd_buffered_0/divider_0/and_0/out1 div_pd_buffered_0/divider_0/and_0/Z1 0.36fF
C1322 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1323 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/B 0.01fF
C1324 pll_full_1/ref pll_full_1/pd_0/tspc_r_0/z5 0.04fF
C1325 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/nand_1/z1 0.22fF
C1326 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/tspc_0/D 0.04fF
C1327 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Qbar1 0.38fF
C1328 divider_1/nor_1/B divider_1/tspc_1/Z4 0.21fF
C1329 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z4 0.36fF
C1330 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/and_0/B 0.18fF
C1331 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1332 pll_full_0/pd_0/R pll_full_0/div 0.51fF
C1333 pll_full_1/divider_0/nor_0/B pll_full_1/div 0.27fF
C1334 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z3 0.06fF
C1335 divider_1/tspc_0/Z3 divider_1/prescaler_0/Out 0.45fF
C1336 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z4 0.08fF
C1337 ro_complete_buffered_0/tapered_buf_6/a_n10_n140# ro_complete_buffered_0/tapered_buf_6/in 0.04fF
C1338 ro_complete_buffered_0/tapered_buf_4/a_210_n610# ro_complete_buffered_0/ro_complete_0/a2 26.29fF
C1339 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/a0 0.13fF
C1340 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1341 div_pd_buffered_0/tapered_buf_3/a_n10_n140# div_pd_buffered_0/tapered_buf_3/a_n10_230# 0.01fF
C1342 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Q 0.15fF
C1343 ro_complete_buffered_0/tapered_buf_0/a_n10_230# ro_complete_buffered_0/tapered_buf_0/a_160_230# 0.09fF
C1344 ro_complete_buffered_0/tapered_buf_0/a_4670_0# ro_complete_buffered_0/tapered_buf_0/a_210_n610# 29.21fF
C1345 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_3/vin ro_complete_buffered_0/ro_complete_0/a1 0.14fF
C1346 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C1347 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_2/vin ro_complete_buffered_0/ro_complete_0/a3 0.09fF
C1348 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/tspc_0/Q 0.04fF
C1349 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C1350 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C1351 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1352 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z4 0.08fF
C1353 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1354 filter_buffered_0/tapered_buf_1/a_n10_230# filter_buffered_0/tapered_buf_1/a_160_230# 0.09fF
C1355 filter_buffered_0/tapered_buf_1/a_4670_0# filter_buffered_0/tapered_buf_1/a_210_n610# 29.21fF
C1356 div_pd_buffered_0/tapered_buf_4/a_n10_n140# div_pd_buffered_0/tapered_buf_4/a_160_n140# 0.05fF
C1357 divider_0/tspc_2/Z1 divider_0/tspc_2/Z4 0.00fF
C1358 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C1359 divider_1/nor_1/A divider_1/and_0/B 0.08fF
C1360 divider_1/tspc_0/Q divider_1/tspc_1/a_630_n680# 0.01fF
C1361 ro_complete_0/a2 ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1362 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_1/Q 0.51fF
C1363 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Z2 0.01fF
C1364 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1365 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1366 ro_complete_buffered_0/tapered_buf_7/a_n10_n140# ro_complete_buffered_0/tapered_buf_7/in 0.04fF
C1367 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_0/Z4 0.12fF
C1368 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.19fF
C1369 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_1/vin ro_complete_buffered_0/tapered_buf_1/in 1.30fF
C1370 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_5/vin ro_complete_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C1371 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/clk 0.04fF
C1372 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_0/Q 0.14fF
C1373 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/vco 0.01fF
C1374 cp_buffered_0/tapered_buf_2/a_n10_n140# cp_buffered_0/tapered_buf_2/in 0.04fF
C1375 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Q 0.38fF
C1376 divider_0/prescaler_0/tspc_1/Z2 divider_0/and_0/OUT 0.06fF
C1377 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1378 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1379 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/D 0.03fF
C1380 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C1381 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1382 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1383 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_2/Z2 0.20fF
C1384 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/and_pd_0/Z1 0.18fF
C1385 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/R 0.29fF
C1386 div_pd_buffered_0/tapered_buf_0/a_160_230# div_pd_buffered_0/tapered_buf_0/a_580_0# 0.02fF
C1387 div_pd_buffered_0/pd_0/tspc_r_0/Qbar div_pd_buffered_0/pd_0/and_pd_0/Z1 0.02fF
C1388 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/tspc_r_1/z5 0.11fF
C1389 div_pd_buffered_0/tapered_buf_3/a_210_n610# div_pd_buffered_0/divider_0/clk 26.29fF
C1390 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C1391 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/R 0.33fF
C1392 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/clk 0.04fF
C1393 div_pd_buffered_0/tapered_buf_0/a_4670_0# div_pd_buffered_0/tapered_buf_0/a_210_n610# 29.21fF
C1394 div_pd_buffered_0/divider_0/tspc_1/Z3 div_pd_buffered_0/divider_0/tspc_1/Z4 0.65fF
C1395 pll_full_0/divider_0/and_0/OUT pll_full_0/div 0.01fF
C1396 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C1397 filter_buffered_0/tapered_buf_0/a_1650_0# filter_buffered_0/tapered_buf_0/a_210_n610# 2.89fF
C1398 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1399 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/nor_1/B 1.21fF
C1400 io_clamp_high[0] io_analog[4] 0.53fF
C1401 divider_1/and_0/out1 divider_1/and_0/A 0.01fF
C1402 ro_complete_0/a5 ro_complete_0/cbank_1/v 0.10fF
C1403 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/a0 0.09fF
C1404 ro_complete_buffered_0/tapered_buf_6/a_580_0# ro_complete_buffered_0/tapered_buf_6/a_160_230# 0.02fF
C1405 ro_complete_buffered_0/tapered_buf_6/a_160_n140# ro_complete_buffered_0/tapered_buf_6/a_210_n610# 0.22fF
C1406 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C1407 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C1408 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1409 div_pd_buffered_0/pd_0/R div_pd_buffered_0/pd_0/UP 0.45fF
C1410 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/vco 1.46fF
C1411 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/pd_0/R 0.02fF
C1412 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C1413 divider_1/mc2 divider_1/nor_1/A 0.04fF
C1414 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C1415 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/switch_1/vin 0.19fF
C1416 pll_full_1/ref pll_full_1/pd_0/tspc_r_0/Z2 0.19fF
C1417 pll_full_0/pd_0/DOWN pll_full_0/cp_0/a_1710_0# 0.04fF
C1418 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/and_0/OUT 0.14fF
C1419 pll_full_1/divider_0/prescaler_0/Out pll_full_1/vco 0.51fF
C1420 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_0/z5 0.04fF
C1421 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/tspc_r_0/Z2 0.25fF
C1422 ro_complete_buffered_0/tapered_buf_7/a_580_0# ro_complete_buffered_0/tapered_buf_7/a_160_230# 0.02fF
C1423 ro_complete_buffered_0/tapered_buf_7/a_160_n140# ro_complete_buffered_0/tapered_buf_7/a_210_n610# 0.22fF
C1424 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1425 pll_full_1/pd_0/tspc_r_0/Qbar pll_full_1/pd_0/and_pd_0/Z1 0.02fF
C1426 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/nor_1/A 0.15fF
C1427 ro_complete_buffered_0/ro_complete_0/a3 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C1428 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1429 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C1430 div_pd_buffered_0/divider_0/tspc_1/Q div_pd_buffered_0/divider_0/tspc_2/Z3 0.45fF
C1431 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/and_0/A 0.26fF
C1432 div_pd_buffered_0/tapered_buf_4/a_210_n610# div_pd_buffered_0/tapered_buf_4/a_580_0# 0.84fF
C1433 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_1/Q 0.21fF
C1434 divider_0/nor_1/B divider_0/tspc_0/Q 0.22fF
C1435 cp_buffered_0/tapered_buf_2/a_580_0# cp_buffered_0/tapered_buf_2/a_160_230# 0.02fF
C1436 cp_buffered_0/tapered_buf_2/a_160_n140# cp_buffered_0/tapered_buf_2/a_210_n610# 0.22fF
C1437 pll_full_1/ro_complete_0/cbank_1/switch_4/vin pll_full_1/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C1438 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a3 0.13fF
C1439 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/and_0/B 0.08fF
C1440 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.20fF
C1441 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.09fF
C1442 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/vco 0.12fF
C1443 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/tspc_r_1/Z3 0.65fF
C1444 ro_complete_buffered_0/tapered_buf_5/a_160_n140# ro_complete_buffered_0/tapered_buf_5/a_580_0# 0.35fF
C1445 pll_full_1/pd_0/tspc_r_0/Z1 pll_full_1/pd_0/tspc_r_0/Z2 0.71fF
C1446 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/divider_0/tspc_2/Z3 0.05fF
C1447 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C1448 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C1449 divider_0/nor_1/B divider_0/tspc_1/Z1 0.03fF
C1450 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z3 0.05fF
C1451 divider_0/prescaler_0/tspc_1/Z4 divider_0/prescaler_0/m1_2700_2190# 0.08fF
C1452 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C1453 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_4/vin ro_complete_buffered_0/tapered_buf_1/in 1.30fF
C1454 div_pd_buffered_0/tapered_buf_0/a_1650_0# div_pd_buffered_0/tapered_buf_0/a_210_n610# 2.89fF
C1455 div_pd_buffered_0/divider_0/nor_0/B div_pd_buffered_0/divider_0/tspc_2/Z4 0.22fF
C1456 div_pd_buffered_0/divider_0/tspc_2/Z2 div_pd_buffered_0/divider_0/tspc_2/Z3 0.16fF
C1457 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Q 0.04fF
C1458 divider_0/prescaler_0/tspc_0/Z3 divider_0/clk 0.64fF
C1459 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z2 1.07fF
C1460 divider_1/tspc_0/Q divider_1/tspc_1/Z2 0.14fF
C1461 divider_1/nor_1/A divider_1/tspc_0/Z1 0.03fF
C1462 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/v 1.30fF
C1463 divider_1/nor_0/B divider_1/tspc_1/a_630_n680# 0.00fF
C1464 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/and_0/B 0.31fF
C1465 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/nand_1/z1 0.22fF
C1466 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/prescaler_0/tspc_0/D 0.04fF
C1467 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/DOWN 0.21fF
C1468 div_pd_buffered_0/pd_0/R div_pd_buffered_0/pd_0/and_pd_0/Out1 0.33fF
C1469 div_pd_buffered_0/tapered_buf_2/a_1650_0# div_pd_buffered_0/tapered_buf_2/a_580_0# 1.27fF
C1470 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C1471 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/tspc_1/Z4 0.21fF
C1472 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/tspc_0/Z3 0.45fF
C1473 ro_complete_buffered_0/tapered_buf_1/out ro_complete_buffered_0/tapered_buf_1/a_210_n610# 26.29fF
C1474 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/nor_1/B 0.03fF
C1475 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/a_630_n680# 0.05fF
C1476 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C1477 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C1478 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z4 0.12fF
C1479 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z4 0.36fF
C1480 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/Out 0.05fF
C1481 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_2/vin ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C1482 div_pd_buffered_0/divider_0/and_0/A div_pd_buffered_0/divider_0/and_0/B 0.18fF
C1483 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/nand_1/z1 0.01fF
C1484 divider_0/prescaler_0/tspc_2/Z2 divider_0/clk 0.11fF
C1485 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/a1 0.14fF
C1486 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1487 pll_full_1/ro_complete_0/cbank_0/switch_2/vin pll_full_1/ro_complete_0/a3 0.09fF
C1488 div_pd_buffered_0/tapered_buf_4/a_580_0# div_pd_buffered_0/tapered_buf_4/a_160_n140# 0.35fF
C1489 ro_complete_0/a0 ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1490 ro_complete_0/cbank_0/v ro_complete_0/cbank_1/v 1.27fF
C1491 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z4 0.00fF
C1492 divider_0/nor_1/A divider_0/nor_1/B 1.21fF
C1493 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C1494 div_pd_buffered_0/tapered_buf_1/in div_pd_buffered_0/tapered_buf_1/a_n10_230# 0.02fF
C1495 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D div_pd_buffered_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C1496 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_1/vin ro_complete_buffered_0/ro_complete_0/a3 0.13fF
C1497 ro_complete_buffered_0/tapered_buf_0/a_n10_230# ro_complete_buffered_0/tapered_buf_0/a_n10_n140# 0.01fF
C1498 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_3/vin ro_complete_buffered_0/ro_complete_0/a1 0.14fF
C1499 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C1500 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C1501 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C1502 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/vco 1.46fF
C1503 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/A 0.01fF
C1504 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/Q 0.05fF
C1505 divider_0/tspc_2/Z3 divider_0/tspc_2/Z4 0.65fF
C1506 filter_buffered_0/tapered_buf_1/a_n10_230# filter_buffered_0/tapered_buf_1/a_n10_n140# 0.01fF
C1507 pll_full_1/ro_complete_0/cbank_0/switch_5/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1508 ro_complete_0/a2 ro_complete_0/cbank_2/switch_3/vin 0.09fF
C1509 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/a5 0.09fF
C1510 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1511 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1512 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/vco 0.01fF
C1513 divider_1/nor_1/B divider_1/tspc_2/Z4 0.02fF
C1514 ro_complete_buffered_0/tapered_buf_4/a_n10_230# ro_complete_buffered_0/tapered_buf_4/in 0.02fF
C1515 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/div 0.65fF
C1516 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_0/Z2 0.14fF
C1517 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/tspc_0/Z2 0.11fF
C1518 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C1519 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/v 0.08fF
C1520 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C1521 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D div_pd_buffered_0/divider_0/clk 0.26fF
C1522 div_pd_buffered_0/tapered_buf_3/a_580_0# div_pd_buffered_0/tapered_buf_3/a_160_230# 0.02fF
C1523 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_4/vin ro_complete_buffered_0/ro_complete_0/a0 0.13fF
C1524 ro_complete_buffered_0/ro_complete_0/a5 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C1525 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/vco 0.01fF
C1526 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1527 divider_1/tspc_0/Z2 divider_1/tspc_0/Z1 1.07fF
C1528 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C1529 ro_complete_buffered_0/tapered_buf_4/a_160_n140# ro_complete_buffered_0/tapered_buf_4/a_580_0# 0.35fF
C1530 pll_full_1/ro_complete_0/cbank_2/v pll_full_1/vco 1.36fF
C1531 divider_1/nor_0/B divider_1/tspc_2/Z1 0.03fF
C1532 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z3 0.05fF
C1533 ro_complete_buffered_0/tapered_buf_5/a_1650_0# ro_complete_buffered_0/tapered_buf_5/a_210_n610# 2.89fF
C1534 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/pd_0/tspc_r_1/z5 0.03fF
C1535 div_pd_buffered_0/pd_0/tspc_r_1/Z2 div_pd_buffered_0/pd_0/R 0.21fF
C1536 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/UP 0.03fF
C1537 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1538 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/div 0.12fF
C1539 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1540 ro_complete_buffered_0/ro_complete_0/a1 ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C1541 divider_0/tspc_0/Z4 divider_0/tspc_0/Z3 0.65fF
C1542 divider_1/tspc_0/Q divider_1/tspc_1/Z4 0.15fF
C1543 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/ref 0.02fF
C1544 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/tspc_0/a_630_n680# 0.35fF
C1545 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.91fF
C1546 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1547 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/nor_0/B 0.06fF
C1548 ro_complete_0/a2 ro_complete_0/cbank_2/v 0.05fF
C1549 pll_full_0/pd_0/tspc_r_0/Qbar pll_full_0/pd_0/UP 0.21fF
C1550 ro_complete_buffered_0/tapered_buf_6/a_1650_0# ro_complete_buffered_0/tapered_buf_6/a_210_n610# 2.89fF
C1551 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/tspc_0/Z4 0.12fF
C1552 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C1553 divider_0/mc2 divider_0/and_0/B 0.20fF
C1554 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z4 0.36fF
C1555 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Q 0.05fF
C1556 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1557 divider_0/and_0/OUT divider_0/and_0/B 0.01fF
C1558 filter_buffered_0/filter_0/v filter_buffered_0/filter_0/a_4216_n2998# 0.31fF
C1559 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C1560 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1561 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/D 0.03fF
C1562 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_0/a_630_n680# 0.01fF
C1563 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1564 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_2/D 0.16fF
C1565 pll_full_1/ro_complete_0/cbank_1/switch_2/vin pll_full_1/vco 1.46fF
C1566 div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 div_pd_buffered_0/pd_0/tspc_r_0/Qbar 0.01fF
C1567 div_pd_buffered_0/tapered_buf_4/a_160_n140# div_pd_buffered_0/pd_0/DOWN 0.19fF
C1568 ro_complete_buffered_0/tapered_buf_7/a_1650_0# ro_complete_buffered_0/tapered_buf_7/a_210_n610# 2.89fF
C1569 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C1570 div_pd_buffered_0/divider_0/tspc_1/Q div_pd_buffered_0/divider_0/tspc_2/Z4 0.15fF
C1571 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/tapered_buf_1/in 0.05fF
C1572 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_4/vin ro_complete_buffered_0/ro_complete_0/a0 0.13fF
C1573 cp_buffered_0/tapered_buf_2/a_1650_0# cp_buffered_0/tapered_buf_2/a_210_n610# 2.89fF
C1574 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z3 0.27fF
C1575 divider_0/tspc_0/Z4 divider_0/tspc_0/Z2 0.36fF
C1576 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_1/Q 0.13fF
C1577 divider_0/prescaler_0/m1_2700_2190# divider_0/and_0/OUT 0.14fF
C1578 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1579 divider_0/nor_1/B divider_0/and_0/A 0.26fF
C1580 divider_1/tspc_0/Z4 divider_1/tspc_0/Z1 0.00fF
C1581 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/D 0.05fF
C1582 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1583 divider_1/tspc_1/Q divider_1/tspc_1/a_630_n680# 0.04fF
C1584 ro_complete_buffered_0/tapered_buf_2/a_n10_230# ro_complete_buffered_0/tapered_buf_2/a_160_230# 0.09fF
C1585 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/v 1.30fF
C1586 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1587 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 0.38fF
C1588 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/ro_complete_0/cbank_2/v 0.04fF
C1589 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1590 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C1591 div_pd_buffered_0/divider_0/tspc_2/Z2 div_pd_buffered_0/divider_0/tspc_2/Z4 0.36fF
C1592 divider_0/nor_1/B divider_0/tspc_1/Z3 0.38fF
C1593 divider_0/prescaler_0/tspc_1/Z4 divider_0/prescaler_0/tspc_1/a_630_n680# 0.12fF
C1594 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_0/vin ro_complete_buffered_0/tapered_buf_1/in 1.43fF
C1595 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_0/Q 0.01fF
C1596 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar1 0.01fF
C1597 divider_0/prescaler_0/Out divider_0/tspc_0/Z3 0.45fF
C1598 divider_0/prescaler_0/tspc_0/Z4 divider_0/clk 0.12fF
C1599 pll_full_1/ref pll_full_1/pd_0/DOWN 1.48fF
C1600 divider_1/tspc_1/Z1 divider_1/tspc_1/Z2 1.07fF
C1601 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/Z3 0.16fF
C1602 pll_full_1/ro_complete_0/cbank_2/switch_2/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C1603 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/prescaler_0/nand_1/z1 0.01fF
C1604 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/vco 0.11fF
C1605 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1606 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1607 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/nor_1/B 0.38fF
C1608 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z1 0.00fF
C1609 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C1610 pll_full_0/ro_complete_0/a2 pll_full_0/vco 0.11fF
C1611 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1612 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/div 0.19fF
C1613 div_pd_buffered_0/tapered_buf_2/a_580_0# div_pd_buffered_0/tapered_buf_2/a_210_n610# 0.84fF
C1614 divider_0/nor_1/B divider_0/tspc_1/Z4 0.21fF
C1615 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_4/vin ro_complete_buffered_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C1616 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z1 0.03fF
C1617 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z3 0.05fF
C1618 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/a1 0.14fF
C1619 divider_0/prescaler_0/tspc_0/D divider_0/prescaler_0/nand_1/z1 0.21fF
C1620 pll_full_1/ref pll_full_1/pd_0/R 0.61fF
C1621 ro_complete_buffered_0/tapered_buf_3/in ro_complete_buffered_0/tapered_buf_3/a_n10_n140# 0.04fF
C1622 pll_full_1/divider_0/tspc_2/Z3 pll_full_1/divider_0/tspc_2/Z4 0.65fF
C1623 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.01fF
C1624 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/div 0.02fF
C1625 div_pd_buffered_0/tapered_buf_3/a_580_0# div_pd_buffered_0/tapered_buf_3/a_160_n140# 0.35fF
C1626 ro_complete_buffered_0/tapered_buf_0/a_160_n140# ro_complete_buffered_0/tapered_buf_0/in 0.19fF
C1627 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C1628 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C1629 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C1630 pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_0/vco 1.58fF
C1631 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/tspc_2/Z4 0.02fF
C1632 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1633 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 div_pd_buffered_0/divider_0/clk 0.45fF
C1634 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/UP 0.33fF
C1635 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/UP 0.33fF
C1636 divider_0/prescaler_0/Out divider_0/tspc_0/Z2 0.11fF
C1637 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# 0.21fF
C1638 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C1639 div_pd_buffered_0/tapered_buf_4/a_210_n610# div_pd_buffered_0/tapered_buf_4/a_1650_0# 2.89fF
C1640 divider_1/prescaler_0/tspc_0/Z2 divider_1/and_0/OUT 0.06fF
C1641 divider_1/tspc_1/Q divider_1/tspc_2/Z1 0.01fF
C1642 divider_1/tspc_1/Z3 divider_1/tspc_1/a_630_n680# 0.05fF
C1643 ro_complete_0/a2 ro_complete_0/cbank_0/switch_2/vin 0.14fF
C1644 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a4 0.09fF
C1645 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1646 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z2 0.01fF
C1647 div_pd_buffered_0/tapered_buf_1/a_580_0# div_pd_buffered_0/tapered_buf_1/a_1650_0# 1.27fF
C1648 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1649 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z3 0.65fF
C1650 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C1651 pll_full_1/pd_0/DOWN pll_full_1/pd_0/and_pd_0/Z1 0.07fF
C1652 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/pd_0/UP 0.06fF
C1653 divider_1/nor_1/Z1 divider_1/and_0/B 0.18fF
C1654 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z4 0.36fF
C1655 pll_full_0/pd_0/R pll_full_0/pd_0/UP 0.46fF
C1656 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1657 pll_full_1/ro_complete_0/a1 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1658 divider_1/nor_0/B divider_1/tspc_2/Z3 0.38fF
C1659 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z4 0.12fF
C1660 divider_1/tspc_2/Z1 divider_1/tspc_2/Z2 1.07fF
C1661 ro_complete_buffered_0/tapered_buf_4/a_580_0# ro_complete_buffered_0/tapered_buf_4/a_1650_0# 1.27fF
C1662 div_pd_buffered_0/pd_0/tspc_r_1/Z2 div_pd_buffered_0/pd_0/tspc_r_1/Z4 0.14fF
C1663 pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_0/ro_complete_0/cbank_2/v 1.45fF
C1664 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/and_0/A 0.16fF
C1665 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/and_0/OUT 0.14fF
C1666 divider_0/nor_1/Z1 divider_0/and_0/A 0.80fF
C1667 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_5/vin ro_complete_buffered_0/tapered_buf_1/in 1.30fF
C1668 pll_full_1/pd_0/R pll_full_1/pd_0/and_pd_0/Z1 0.02fF
C1669 div_pd_buffered_0/tapered_buf_4/a_n10_n140# div_pd_buffered_0/tapered_buf_4/a_n10_230# 0.01fF
C1670 divider_0/prescaler_0/tspc_1/Z2 divider_0/clk 0.11fF
C1671 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C1672 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.09fF
C1673 divider_1/tspc_1/Z1 divider_1/tspc_1/Z4 0.00fF
C1674 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z2 0.01fF
C1675 divider_1/and_0/out1 divider_1/and_0/Z1 0.36fF
C1676 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/B 0.01fF
C1677 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.21fF
C1678 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.01fF
C1679 ro_complete_buffered_0/tapered_buf_6/a_160_n140# ro_complete_buffered_0/tapered_buf_6/in 0.19fF
C1680 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1681 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1682 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/a3 3.17fF
C1683 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C1684 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C1685 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z2 0.36fF
C1686 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/Qbar1 0.38fF
C1687 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C1688 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 div_pd_buffered_0/divider_0/clk 0.12fF
C1689 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1690 pll_full_0/div pll_full_0/vco 2.26fF
C1691 filter_buffered_0/tapered_buf_1/a_160_n140# filter_buffered_0/tapered_buf_1/a_580_0# 0.35fF
C1692 cp_buffered_0/tapered_buf_1/a_n10_n140# cp_buffered_0/tapered_buf_1/in 0.04fF
C1693 cp_buffered_0/tapered_buf_1/a_210_n610# cp_buffered_0/cp_0/out 26.29fF
C1694 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/a0 0.13fF
C1695 ro_complete_buffered_0/tapered_buf_2/a_n10_230# ro_complete_buffered_0/tapered_buf_2/in 0.02fF
C1696 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/nand_0/z1 0.07fF
C1697 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1698 divider_1/and_0/OUT divider_1/prescaler_0/nand_0/z1 0.01fF
C1699 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/tspc_r_0/Z4 0.20fF
C1700 div_pd_buffered_0/pd_0/tspc_r_0/Z1 div_pd_buffered_0/pd_0/tspc_r_0/Z2 0.71fF
C1701 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/tspc_r_0/z5 0.04fF
C1702 ro_complete_0/a0 ro_complete_0/cbank_2/switch_5/vin 0.09fF
C1703 ro_complete_buffered_0/tapered_buf_7/a_160_n140# ro_complete_buffered_0/tapered_buf_7/in 0.19fF
C1704 ro_complete_buffered_0/tapered_buf_1/a_n10_230# ro_complete_buffered_0/tapered_buf_1/in 0.02fF
C1705 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C1706 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/Q 0.55fF
C1707 pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_0/vco 1.46fF
C1708 div_pd_buffered_0/tapered_buf_0/a_580_0# div_pd_buffered_0/tapered_buf_0/a_210_n610# 0.84fF
C1709 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 div_pd_buffered_0/divider_0/clk 0.45fF
C1710 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/D 0.11fF
C1711 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_1/Q 0.21fF
C1712 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_2/D 0.16fF
C1713 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/D 0.03fF
C1714 cp_buffered_0/tapered_buf_2/a_160_n140# cp_buffered_0/tapered_buf_2/in 0.19fF
C1715 cp_buffered_0/tapered_buf_0/a_n10_n140# cp_buffered_0/tapered_buf_0/in 0.04fF
C1716 cp_buffered_0/tapered_buf_0/a_210_n610# cp_buffered_0/cp_0/down 26.29fF
C1717 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/nor_1/B 0.18fF
C1718 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_0/Z4 0.12fF
C1719 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# 0.19fF
C1720 divider_1/tspc_0/Z2 divider_1/nor_1/A 0.23fF
C1721 divider_0/and_0/out1 divider_0/and_0/A 0.01fF
C1722 divider_0/tspc_0/Z3 divider_0/tspc_0/Q 0.05fF
C1723 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_0/Q 0.14fF
C1724 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/vco 0.01fF
C1725 div_pd_buffered_0/tapered_buf_4/a_160_230# div_pd_buffered_0/tapered_buf_4/a_160_n140# 0.17fF
C1726 divider_1/and_0/OUT divider_1/clk 0.04fF
C1727 div_pd_buffered_0/tapered_buf_1/a_n10_n140# div_pd_buffered_0/tapered_buf_1/a_160_n140# 0.05fF
C1728 div_pd_buffered_0/pd_0/tspc_r_0/Z4 div_pd_buffered_0/pd_0/tspc_r_1/Z4 0.02fF
C1729 div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 div_pd_buffered_0/pd_0/DOWN 0.11fF
C1730 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/tspc_r_1/Z1 0.17fF
C1731 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1732 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C1733 divider_0/mc2 divider_0/and_0/OUT 0.05fF
C1734 ro_complete_buffered_0/ro_complete_0/a5 ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.08fF
C1735 ro_complete_buffered_0/ro_complete_0/a0 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C1736 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z1 0.01fF
C1737 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_0/Q 0.22fF
C1738 ro_complete_buffered_0/tapered_buf_2/a_1650_0# ro_complete_buffered_0/tapered_buf_2/a_580_0# 1.27fF
C1739 filter_buffered_0/tapered_buf_0/a_160_n140# filter_buffered_0/tapered_buf_0/a_580_0# 0.35fF
C1740 pll_full_1/ro_complete_0/cbank_2/switch_4/vin pll_full_1/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C1741 divider_1/tspc_1/Z2 divider_1/tspc_1/Z3 0.16fF
C1742 ro_complete_buffered_0/tapered_buf_2/a_n10_230# ro_complete_buffered_0/tapered_buf_2/a_n10_n140# 0.01fF
C1743 io_clamp_low[2] io_analog[6] 0.53fF
C1744 pll_full_1/divider_0/and_0/OUT pll_full_1/div 0.01fF
C1745 pll_full_1/divider_0/prescaler_0/tspc_0/D pll_full_1/divider_0/prescaler_0/nand_1/z1 0.21fF
C1746 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1747 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1748 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1749 ro_complete_buffered_0/tapered_buf_1/a_n10_230# ro_complete_buffered_0/tapered_buf_1/a_160_230# 0.09fF
C1750 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1751 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C1752 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/A 0.80fF
C1753 pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1754 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_4/vin ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C1755 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z3 0.38fF
C1756 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z4 0.12fF
C1757 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z2 1.07fF
C1758 div_pd_buffered_0/divider_0/and_0/B div_pd_buffered_0/divider_0/and_0/Z1 0.07fF
C1759 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/a_630_n680# 0.05fF
C1760 filter_buffered_0/tapered_buf_1/a_1650_0# filter_buffered_0/tapered_buf_1/a_580_0# 1.27fF
C1761 cp_buffered_0/tapered_buf_1/a_580_0# cp_buffered_0/tapered_buf_1/a_160_230# 0.02fF
C1762 cp_buffered_0/tapered_buf_1/a_160_n140# cp_buffered_0/tapered_buf_1/a_210_n610# 0.22fF
C1763 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Qbar1 0.38fF
C1764 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C1765 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C1766 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1767 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/and_0/B 0.78fF
C1768 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/vco 1.46fF
C1769 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/D 0.15fF
C1770 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/tspc_0/a_630_n680# 0.01fF
C1771 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.04fF
C1772 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/tspc_0/Z3 0.38fF
C1773 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 div_pd_buffered_0/divider_0/clk 0.12fF
C1774 divider_0/tspc_1/a_630_n680# divider_0/nor_1/B 0.35fF
C1775 divider_0/nor_1/A divider_0/tspc_0/Z3 0.38fF
C1776 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/clk 0.01fF
C1777 ro_complete_buffered_0/tapered_buf_0/a_160_n140# ro_complete_buffered_0/tapered_buf_0/a_160_230# 0.17fF
C1778 ro_complete_buffered_0/tapered_buf_1/a_160_230# ro_complete_buffered_0/tapered_buf_1/a_580_0# 0.02fF
C1779 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z4 0.12fF
C1780 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C1781 pll_full_1/ref pll_full_1/pd_0/tspc_r_0/Z3 0.65fF
C1782 divider_0/nor_1/B divider_0/tspc_2/Z4 0.02fF
C1783 divider_0/tspc_0/Z4 divider_0/tspc_0/Z1 0.00fF
C1784 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1785 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/Z1 0.36fF
C1786 divider_1/tspc_0/Z4 divider_1/nor_1/A 0.21fF
C1787 cp_buffered_0/tapered_buf_0/a_580_0# cp_buffered_0/tapered_buf_0/a_160_230# 0.02fF
C1788 cp_buffered_0/tapered_buf_0/a_160_n140# cp_buffered_0/tapered_buf_0/a_210_n610# 0.22fF
C1789 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_0/Z2 0.14fF
C1790 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1791 ro_complete_buffered_0/tapered_buf_3/a_580_0# ro_complete_buffered_0/tapered_buf_3/a_160_230# 0.02fF
C1792 ro_complete_buffered_0/tapered_buf_2/a_210_n610# ro_complete_buffered_0/tapered_buf_2/a_580_0# 0.84fF
C1793 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Qbar 0.01fF
C1794 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/ref 0.12fF
C1795 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C1796 divider_1/tspc_1/Q divider_1/tspc_2/Z3 0.45fF
C1797 ro_complete_0/cbank_1/v ro_complete_0/cbank_2/v 1.36fF
C1798 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/R 0.29fF
C1799 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/Out 0.04fF
C1800 div_pd_buffered_0/tapered_buf_0/a_160_n140# div_pd_buffered_0/tapered_buf_0/a_580_0# 0.35fF
C1801 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/and_0/OUT 0.06fF
C1802 div_pd_buffered_0/divider_0/nor_1/Z1 div_pd_buffered_0/divider_0/nor_1/B 0.06fF
C1803 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C1804 div_pd_buffered_0/divider_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/nor_0/B 0.35fF
C1805 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q div_pd_buffered_0/divider_0/clk 0.60fF
C1806 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C1807 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/vco 0.11fF
C1808 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/Z1 0.06fF
C1809 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C1810 divider_1/prescaler_0/tspc_1/Z2 divider_1/and_0/OUT 0.06fF
C1811 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1812 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Z1 0.09fF
C1813 divider_1/nor_0/B divider_1/tspc_2/Z4 0.22fF
C1814 divider_1/tspc_2/Z2 divider_1/tspc_2/Z3 0.16fF
C1815 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1816 divider_0/nor_1/A divider_0/tspc_0/Z2 0.23fF
C1817 ro_complete_buffered_0/tapered_buf_0/a_160_n140# ro_complete_buffered_0/tapered_buf_0/a_580_0# 0.35fF
C1818 div_pd_buffered_0/tapered_buf_1/a_160_n140# div_pd_buffered_0/tapered_buf_1/a_160_230# 0.17fF
C1819 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/tspc_0/Z2 0.23fF
C1820 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1821 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C1822 div_pd_buffered_0/tapered_buf_3/a_580_0# div_pd_buffered_0/tapered_buf_3/a_210_n610# 0.84fF
C1823 ro_complete_buffered_0/tapered_buf_1/a_580_0# ro_complete_buffered_0/tapered_buf_1/a_1650_0# 1.27fF
C1824 ro_complete_buffered_0/ro_complete_0/cbank_0/v ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.04fF
C1825 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/div 0.03fF
C1826 pll_full_0/divider_0/and_0/OUT pll_full_0/vco 0.06fF
C1827 filter_buffered_0/tapered_buf_1/a_1650_0# filter_buffered_0/tapered_buf_1/a_4670_0# 4.78fF
C1828 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C1829 divider_1/tspc_1/Z3 divider_1/tspc_1/Z4 0.65fF
C1830 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/nor_1/B 0.03fF
C1831 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_1/a_630_n680# 0.05fF
C1832 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C1833 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C1834 divider_1/and_0/A divider_1/and_0/B 0.18fF
C1835 ro_complete_buffered_0/tapered_buf_4/a_580_0# ro_complete_buffered_0/tapered_buf_4/a_160_230# 0.02fF
C1836 ro_complete_buffered_0/tapered_buf_4/a_160_n140# ro_complete_buffered_0/tapered_buf_4/a_210_n610# 0.22fF
C1837 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/v 1.30fF
C1838 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C1839 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.04fF
C1840 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1841 div_pd_buffered_0/tapered_buf_0/a_160_n140# div_pd_buffered_0/tapered_buf_0/a_n10_n140# 0.05fF
C1842 div_pd_buffered_0/divider_0/nor_1/Z1 div_pd_buffered_0/divider_0/and_0/B 0.18fF
C1843 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/vco 0.64fF
C1844 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/UP 0.11fF
Xcp_buffered_0 vdda1 vdda1 cp_buffered
Xfilter_buffered_0 vssa1 filter_buffered_0/v filter_buffered
Xro_complete_0 ro_complete_0/a0 ro_complete_0/a1 ro_complete_0/a5 ro_complete_0/a4
+ ro_complete_0/a3 ro_complete_0/a2 ro_complete
Xro_complete_buffered_0 vdda1 ro_complete_buffered
Xdivider_0 vdda1 vdd divider_0/Out divider_0/clk divider_0/mc2 vdda1 vdd divider
Xdivider_1 vssa1 vdda1 divider_1/Out divider_1/clk divider_1/mc2 vssa1 vdda1 divider
Xdiv_pd_buffered_0 vdda1 vssa1 div_pd_buffered
Xpll_full_1 vdd pll_full_1/ref pll_full_1/div pll_full_1/vco pll_full
Xpll_full_0 vdd pll_full_0/ref pll_full_0/div pll_full_0/vco pll_full
C1845 io_analog[4] vdda1 43.96fF
C1846 io_analog[5] vdda1 44.13fF
C1847 io_analog[6] vdda1 43.46fF
C1848 io_in_3v3[0] vdda1 0.61fF
C1849 io_oeb[26] vdda1 0.61fF
C1850 io_in[0] vdda1 0.61fF
C1851 io_out[26] vdda1 0.61fF
C1852 io_out[0] vdda1 0.61fF
C1853 io_in[26] vdda1 0.61fF
C1854 io_oeb[0] vdda1 0.61fF
C1855 io_in_3v3[26] vdda1 0.61fF
C1856 io_in_3v3[1] vdda1 0.61fF
C1857 io_oeb[25] vdda1 0.61fF
C1858 io_in[1] vdda1 0.61fF
C1859 io_out[25] vdda1 0.61fF
C1860 io_out[1] vdda1 0.61fF
C1861 io_in[25] vdda1 0.61fF
C1862 io_oeb[1] vdda1 0.61fF
C1863 io_in_3v3[25] vdda1 0.61fF
C1864 io_in_3v3[2] vdda1 0.61fF
C1865 io_oeb[24] vdda1 0.61fF
C1866 io_in[2] vdda1 0.61fF
C1867 io_out[24] vdda1 0.61fF
C1868 io_out[2] vdda1 0.61fF
C1869 io_in[24] vdda1 0.61fF
C1870 io_oeb[2] vdda1 0.61fF
C1871 io_in_3v3[24] vdda1 0.61fF
C1872 io_in_3v3[3] vdda1 0.61fF
C1873 gpio_noesd[17] vdda1 2.32fF
C1874 io_in[3] vdda1 0.61fF
C1875 gpio_analog[17] vdda1 2.30fF
C1876 io_out[3] vdda1 0.61fF
C1877 io_oeb[3] vdda1 0.61fF
C1878 io_in_3v3[4] vdda1 0.61fF
C1879 io_in[4] vdda1 0.61fF
C1880 io_out[4] vdda1 0.61fF
C1881 io_oeb[4] vdda1 0.61fF
C1882 io_oeb[23] vdda1 0.61fF
C1883 io_out[23] vdda1 0.61fF
C1884 io_in[23] vdda1 0.61fF
C1885 io_in_3v3[23] vdda1 0.61fF
C1886 gpio_noesd[16] vdda1 2.30fF
C1887 gpio_analog[16] vdda1 2.30fF
C1888 io_in_3v3[5] vdda1 0.61fF
C1889 io_in[5] vdda1 0.61fF
C1890 io_out[5] vdda1 0.61fF
C1891 io_oeb[5] vdda1 0.61fF
C1892 io_oeb[22] vdda1 0.61fF
C1893 io_out[22] vdda1 0.61fF
C1894 io_in[22] vdda1 0.61fF
C1895 io_in_3v3[22] vdda1 0.61fF
C1896 gpio_noesd[15] vdda1 2.31fF
C1897 gpio_analog[15] vdda1 2.30fF
C1898 io_in_3v3[6] vdda1 0.61fF
C1899 io_in[6] vdda1 0.61fF
C1900 io_out[6] vdda1 0.61fF
C1901 io_oeb[6] vdda1 0.61fF
C1902 io_oeb[21] vdda1 0.61fF
C1903 io_out[21] vdda1 0.61fF
C1904 io_in[21] vdda1 0.61fF
C1905 io_in_3v3[21] vdda1 0.61fF
C1906 gpio_noesd[14] vdda1 2.30fF
C1907 gpio_analog[14] vdda1 2.29fF
C1908 vssd2 vdda1 38.54fF
C1909 vssd1 vdda1 13.04fF
C1910 vdda2 vdda1 38.30fF
C1911 io_oeb[20] vdda1 0.61fF
C1912 io_out[20] vdda1 0.61fF
C1913 io_in[20] vdda1 0.61fF
C1914 io_in_3v3[20] vdda1 0.61fF
C1915 gpio_noesd[13] vdda1 2.31fF
C1916 gpio_analog[13] vdda1 2.30fF
C1917 gpio_analog[0] vdda1 0.61fF
C1918 gpio_noesd[0] vdda1 0.61fF
C1919 io_in_3v3[7] vdda1 0.61fF
C1920 io_in[7] vdda1 0.61fF
C1921 io_out[7] vdda1 0.61fF
C1922 io_oeb[7] vdda1 0.61fF
C1923 io_oeb[19] vdda1 0.61fF
C1924 io_out[19] vdda1 0.61fF
C1925 io_in[19] vdda1 0.61fF
C1926 io_in_3v3[19] vdda1 0.61fF
C1927 gpio_noesd[12] vdda1 2.32fF
C1928 gpio_analog[12] vdda1 2.30fF
C1929 gpio_analog[1] vdda1 0.61fF
C1930 gpio_noesd[1] vdda1 0.61fF
C1931 io_in_3v3[8] vdda1 0.61fF
C1932 io_in[8] vdda1 0.61fF
C1933 io_out[8] vdda1 0.61fF
C1934 io_oeb[8] vdda1 0.61fF
C1935 io_oeb[18] vdda1 0.61fF
C1936 io_out[18] vdda1 0.61fF
C1937 io_in[18] vdda1 0.61fF
C1938 io_in_3v3[18] vdda1 0.61fF
C1939 gpio_noesd[11] vdda1 2.30fF
C1940 gpio_analog[11] vdda1 2.29fF
C1941 gpio_analog[2] vdda1 0.61fF
C1942 gpio_noesd[2] vdda1 0.61fF
C1943 io_in_3v3[9] vdda1 0.61fF
C1944 io_in[9] vdda1 0.61fF
C1945 io_out[9] vdda1 0.61fF
C1946 io_oeb[9] vdda1 0.61fF
C1947 io_oeb[17] vdda1 0.61fF
C1948 io_out[17] vdda1 0.61fF
C1949 io_in[17] vdda1 0.61fF
C1950 io_in_3v3[17] vdda1 0.61fF
C1951 gpio_noesd[10] vdda1 2.31fF
C1952 gpio_analog[10] vdda1 2.29fF
C1953 gpio_analog[3] vdda1 0.61fF
C1954 gpio_noesd[3] vdda1 0.61fF
C1955 io_in_3v3[10] vdda1 0.61fF
C1956 io_in[10] vdda1 0.61fF
C1957 io_out[10] vdda1 0.61fF
C1958 io_oeb[10] vdda1 0.61fF
C1959 io_oeb[16] vdda1 0.61fF
C1960 io_out[16] vdda1 0.61fF
C1961 io_in[16] vdda1 0.61fF
C1962 io_in_3v3[16] vdda1 0.61fF
C1963 gpio_noesd[9] vdda1 2.28fF
C1964 gpio_analog[9] vdda1 2.28fF
C1965 gpio_analog[4] vdda1 0.61fF
C1966 gpio_noesd[4] vdda1 0.61fF
C1967 io_in_3v3[11] vdda1 0.61fF
C1968 io_in[11] vdda1 0.61fF
C1969 io_out[11] vdda1 0.61fF
C1970 io_oeb[11] vdda1 0.61fF
C1971 io_oeb[15] vdda1 0.61fF
C1972 io_out[15] vdda1 0.61fF
C1973 io_in[15] vdda1 0.61fF
C1974 io_in_3v3[15] vdda1 0.61fF
C1975 gpio_noesd[8] vdda1 2.28fF
C1976 gpio_analog[8] vdda1 2.26fF
C1977 gpio_analog[5] vdda1 0.61fF
C1978 gpio_noesd[5] vdda1 0.61fF
C1979 io_in_3v3[12] vdda1 0.61fF
C1980 io_in[12] vdda1 0.61fF
C1981 io_out[12] vdda1 0.61fF
C1982 io_oeb[12] vdda1 0.61fF
C1983 io_oeb[14] vdda1 0.61fF
C1984 io_out[14] vdda1 0.61fF
C1985 io_in[14] vdda1 0.61fF
C1986 io_in_3v3[14] vdda1 0.61fF
C1987 gpio_noesd[7] vdda1 2.30fF
C1988 gpio_analog[7] vdda1 2.28fF
C1989 vssa2 vdda1 38.35fF
C1990 gpio_analog[6] vdda1 5.71fF
C1991 gpio_noesd[6] vdda1 5.70fF
C1992 io_in_3v3[13] vdda1 0.61fF
C1993 io_in[13] vdda1 0.61fF
C1994 io_out[13] vdda1 0.61fF
C1995 io_oeb[13] vdda1 0.61fF
C1996 vccd1 vdda1 39.84fF
C1997 vccd2 vdda1 38.46fF
C1998 io_analog[0] vdda1 19.99fF
C1999 io_analog[10] vdda1 19.36fF
C2000 io_analog[1] vdda1 13.17fF
C2001 io_analog[2] vdda1 12.57fF
C2002 io_analog[3] vdda1 12.83fF
C2003 io_clamp_high[0] vdda1 3.58fF
C2004 io_clamp_low[0] vdda1 3.58fF
C2005 io_clamp_high[1] vdda1 3.58fF
C2006 io_clamp_low[1] vdda1 3.58fF
C2007 io_clamp_high[2] vdda1 3.58fF
C2008 io_clamp_low[2] vdda1 3.58fF
C2009 io_analog[7] vdda1 12.74fF
C2010 io_analog[8] vdda1 13.08fF
C2011 io_analog[9] vdda1 13.08fF
C2012 user_irq[2] vdda1 0.63fF
C2013 user_irq[1] vdda1 0.63fF
C2014 user_irq[0] vdda1 0.63fF
C2015 user_clock2 vdda1 0.63fF
C2016 la_oenb[127] vdda1 0.63fF
C2017 la_data_out[127] vdda1 0.63fF
C2018 la_data_in[127] vdda1 0.63fF
C2019 la_oenb[126] vdda1 0.63fF
C2020 la_data_out[126] vdda1 0.63fF
C2021 la_data_in[126] vdda1 0.63fF
C2022 la_oenb[125] vdda1 0.63fF
C2023 la_data_out[125] vdda1 0.63fF
C2024 la_data_in[125] vdda1 0.63fF
C2025 la_oenb[124] vdda1 0.63fF
C2026 la_data_out[124] vdda1 0.63fF
C2027 la_data_in[124] vdda1 0.63fF
C2028 la_oenb[123] vdda1 0.63fF
C2029 la_data_out[123] vdda1 0.63fF
C2030 la_data_in[123] vdda1 0.63fF
C2031 la_oenb[122] vdda1 0.63fF
C2032 la_data_out[122] vdda1 0.63fF
C2033 la_data_in[122] vdda1 0.63fF
C2034 la_oenb[121] vdda1 0.63fF
C2035 la_data_out[121] vdda1 0.63fF
C2036 la_data_in[121] vdda1 0.63fF
C2037 la_oenb[120] vdda1 0.63fF
C2038 la_data_out[120] vdda1 0.63fF
C2039 la_data_in[120] vdda1 0.63fF
C2040 la_oenb[119] vdda1 0.63fF
C2041 la_data_out[119] vdda1 0.63fF
C2042 la_data_in[119] vdda1 0.63fF
C2043 la_oenb[118] vdda1 0.63fF
C2044 la_data_out[118] vdda1 0.63fF
C2045 la_data_in[118] vdda1 0.63fF
C2046 la_oenb[117] vdda1 0.63fF
C2047 la_data_out[117] vdda1 0.63fF
C2048 la_data_in[117] vdda1 0.63fF
C2049 la_oenb[116] vdda1 0.63fF
C2050 la_data_out[116] vdda1 0.63fF
C2051 la_data_in[116] vdda1 0.63fF
C2052 la_oenb[115] vdda1 0.63fF
C2053 la_data_out[115] vdda1 0.63fF
C2054 la_data_in[115] vdda1 0.63fF
C2055 la_oenb[114] vdda1 0.63fF
C2056 la_data_out[114] vdda1 0.63fF
C2057 la_data_in[114] vdda1 0.63fF
C2058 la_oenb[113] vdda1 0.63fF
C2059 la_data_out[113] vdda1 0.63fF
C2060 la_data_in[113] vdda1 0.63fF
C2061 la_oenb[112] vdda1 0.63fF
C2062 la_data_out[112] vdda1 0.63fF
C2063 la_data_in[112] vdda1 0.63fF
C2064 la_oenb[111] vdda1 0.63fF
C2065 la_data_out[111] vdda1 0.63fF
C2066 la_data_in[111] vdda1 0.63fF
C2067 la_oenb[110] vdda1 0.63fF
C2068 la_data_out[110] vdda1 0.63fF
C2069 la_data_in[110] vdda1 0.63fF
C2070 la_oenb[109] vdda1 0.63fF
C2071 la_data_out[109] vdda1 0.63fF
C2072 la_data_in[109] vdda1 0.63fF
C2073 la_oenb[108] vdda1 0.63fF
C2074 la_data_out[108] vdda1 0.63fF
C2075 la_data_in[108] vdda1 0.63fF
C2076 la_oenb[107] vdda1 0.63fF
C2077 la_data_out[107] vdda1 0.63fF
C2078 la_data_in[107] vdda1 0.63fF
C2079 la_oenb[106] vdda1 0.63fF
C2080 la_data_out[106] vdda1 0.63fF
C2081 la_data_in[106] vdda1 0.63fF
C2082 la_oenb[105] vdda1 0.63fF
C2083 la_data_out[105] vdda1 0.63fF
C2084 la_data_in[105] vdda1 0.63fF
C2085 la_oenb[104] vdda1 0.63fF
C2086 la_data_out[104] vdda1 0.63fF
C2087 la_data_in[104] vdda1 0.63fF
C2088 la_oenb[103] vdda1 0.63fF
C2089 la_data_out[103] vdda1 0.63fF
C2090 la_data_in[103] vdda1 0.63fF
C2091 la_oenb[102] vdda1 0.63fF
C2092 la_data_out[102] vdda1 0.63fF
C2093 la_data_in[102] vdda1 0.63fF
C2094 la_oenb[101] vdda1 0.63fF
C2095 la_data_out[101] vdda1 0.63fF
C2096 la_data_in[101] vdda1 0.63fF
C2097 la_oenb[100] vdda1 0.63fF
C2098 la_data_out[100] vdda1 0.63fF
C2099 la_data_in[100] vdda1 0.63fF
C2100 la_oenb[99] vdda1 0.63fF
C2101 la_data_out[99] vdda1 0.63fF
C2102 la_data_in[99] vdda1 0.63fF
C2103 la_oenb[98] vdda1 0.63fF
C2104 la_data_out[98] vdda1 0.63fF
C2105 la_data_in[98] vdda1 0.63fF
C2106 la_oenb[97] vdda1 0.63fF
C2107 la_data_out[97] vdda1 0.63fF
C2108 la_data_in[97] vdda1 0.63fF
C2109 la_oenb[96] vdda1 0.63fF
C2110 la_data_out[96] vdda1 0.63fF
C2111 la_data_in[96] vdda1 0.63fF
C2112 la_oenb[95] vdda1 0.63fF
C2113 la_data_out[95] vdda1 0.63fF
C2114 la_data_in[95] vdda1 0.63fF
C2115 la_oenb[94] vdda1 0.63fF
C2116 la_data_out[94] vdda1 0.63fF
C2117 la_data_in[94] vdda1 0.63fF
C2118 la_oenb[93] vdda1 0.63fF
C2119 la_data_out[93] vdda1 0.63fF
C2120 la_data_in[93] vdda1 0.63fF
C2121 la_oenb[92] vdda1 0.63fF
C2122 la_data_out[92] vdda1 0.63fF
C2123 la_data_in[92] vdda1 0.63fF
C2124 la_oenb[91] vdda1 0.63fF
C2125 la_data_out[91] vdda1 0.63fF
C2126 la_data_in[91] vdda1 0.63fF
C2127 la_oenb[90] vdda1 0.63fF
C2128 la_data_out[90] vdda1 0.63fF
C2129 la_data_in[90] vdda1 0.63fF
C2130 la_oenb[89] vdda1 0.63fF
C2131 la_data_out[89] vdda1 0.63fF
C2132 la_data_in[89] vdda1 0.63fF
C2133 la_oenb[88] vdda1 0.63fF
C2134 la_data_out[88] vdda1 0.63fF
C2135 la_data_in[88] vdda1 0.63fF
C2136 la_oenb[87] vdda1 0.63fF
C2137 la_data_out[87] vdda1 0.63fF
C2138 la_data_in[87] vdda1 0.63fF
C2139 la_oenb[86] vdda1 0.63fF
C2140 la_data_out[86] vdda1 0.63fF
C2141 la_data_in[86] vdda1 0.63fF
C2142 la_oenb[85] vdda1 0.63fF
C2143 la_data_out[85] vdda1 0.63fF
C2144 la_data_in[85] vdda1 0.63fF
C2145 la_oenb[84] vdda1 0.63fF
C2146 la_data_out[84] vdda1 0.63fF
C2147 la_data_in[84] vdda1 0.63fF
C2148 la_oenb[83] vdda1 0.63fF
C2149 la_data_out[83] vdda1 0.63fF
C2150 la_data_in[83] vdda1 0.63fF
C2151 la_oenb[82] vdda1 0.63fF
C2152 la_data_out[82] vdda1 0.63fF
C2153 la_data_in[82] vdda1 0.63fF
C2154 la_oenb[81] vdda1 0.63fF
C2155 la_data_out[81] vdda1 0.63fF
C2156 la_data_in[81] vdda1 0.63fF
C2157 la_oenb[80] vdda1 0.63fF
C2158 la_data_out[80] vdda1 0.63fF
C2159 la_data_in[80] vdda1 0.63fF
C2160 la_oenb[79] vdda1 0.63fF
C2161 la_data_out[79] vdda1 0.63fF
C2162 la_data_in[79] vdda1 0.63fF
C2163 la_oenb[78] vdda1 0.63fF
C2164 la_data_out[78] vdda1 0.63fF
C2165 la_data_in[78] vdda1 0.63fF
C2166 la_oenb[77] vdda1 0.63fF
C2167 la_data_out[77] vdda1 0.63fF
C2168 la_data_in[77] vdda1 0.63fF
C2169 la_oenb[76] vdda1 0.63fF
C2170 la_data_out[76] vdda1 0.63fF
C2171 la_data_in[76] vdda1 0.63fF
C2172 la_oenb[75] vdda1 0.63fF
C2173 la_data_out[75] vdda1 0.63fF
C2174 la_data_in[75] vdda1 0.63fF
C2175 la_oenb[74] vdda1 0.63fF
C2176 la_data_out[74] vdda1 0.63fF
C2177 la_data_in[74] vdda1 0.63fF
C2178 la_oenb[73] vdda1 0.63fF
C2179 la_data_out[73] vdda1 0.63fF
C2180 la_data_in[73] vdda1 0.63fF
C2181 la_oenb[72] vdda1 0.63fF
C2182 la_data_out[72] vdda1 0.63fF
C2183 la_data_in[72] vdda1 0.63fF
C2184 la_oenb[71] vdda1 0.63fF
C2185 la_data_out[71] vdda1 0.63fF
C2186 la_data_in[71] vdda1 0.63fF
C2187 la_oenb[70] vdda1 0.63fF
C2188 la_data_out[70] vdda1 0.63fF
C2189 la_data_in[70] vdda1 0.63fF
C2190 la_oenb[69] vdda1 0.63fF
C2191 la_data_out[69] vdda1 0.63fF
C2192 la_data_in[69] vdda1 0.63fF
C2193 la_oenb[68] vdda1 0.63fF
C2194 la_data_out[68] vdda1 0.63fF
C2195 la_data_in[68] vdda1 0.63fF
C2196 la_oenb[67] vdda1 0.63fF
C2197 la_data_out[67] vdda1 0.63fF
C2198 la_data_in[67] vdda1 0.63fF
C2199 la_oenb[66] vdda1 0.63fF
C2200 la_data_out[66] vdda1 0.63fF
C2201 la_data_in[66] vdda1 0.63fF
C2202 la_oenb[65] vdda1 0.63fF
C2203 la_data_out[65] vdda1 0.63fF
C2204 la_data_in[65] vdda1 0.63fF
C2205 la_oenb[64] vdda1 0.63fF
C2206 la_data_out[64] vdda1 0.63fF
C2207 la_data_in[64] vdda1 0.63fF
C2208 la_oenb[63] vdda1 0.63fF
C2209 la_data_out[63] vdda1 0.63fF
C2210 la_data_in[63] vdda1 0.63fF
C2211 la_oenb[62] vdda1 0.63fF
C2212 la_data_out[62] vdda1 0.63fF
C2213 la_data_in[62] vdda1 0.63fF
C2214 la_oenb[61] vdda1 0.63fF
C2215 la_data_out[61] vdda1 0.63fF
C2216 la_data_in[61] vdda1 0.63fF
C2217 la_oenb[60] vdda1 0.63fF
C2218 la_data_out[60] vdda1 0.63fF
C2219 la_data_in[60] vdda1 0.63fF
C2220 la_oenb[59] vdda1 0.63fF
C2221 la_data_out[59] vdda1 0.63fF
C2222 la_data_in[59] vdda1 0.63fF
C2223 la_oenb[58] vdda1 0.63fF
C2224 la_data_out[58] vdda1 0.63fF
C2225 la_data_in[58] vdda1 0.63fF
C2226 la_oenb[57] vdda1 0.63fF
C2227 la_data_out[57] vdda1 0.63fF
C2228 la_data_in[57] vdda1 0.63fF
C2229 la_oenb[56] vdda1 0.63fF
C2230 la_data_out[56] vdda1 0.63fF
C2231 la_data_in[56] vdda1 0.63fF
C2232 la_oenb[55] vdda1 0.63fF
C2233 la_data_out[55] vdda1 0.63fF
C2234 la_data_in[55] vdda1 0.63fF
C2235 la_oenb[54] vdda1 0.63fF
C2236 la_data_out[54] vdda1 0.63fF
C2237 la_data_in[54] vdda1 0.63fF
C2238 la_oenb[53] vdda1 0.63fF
C2239 la_data_out[53] vdda1 0.63fF
C2240 la_data_in[53] vdda1 0.63fF
C2241 la_oenb[52] vdda1 0.63fF
C2242 la_data_out[52] vdda1 0.63fF
C2243 la_data_in[52] vdda1 0.63fF
C2244 la_oenb[51] vdda1 0.63fF
C2245 la_data_out[51] vdda1 0.63fF
C2246 la_data_in[51] vdda1 0.63fF
C2247 la_oenb[50] vdda1 0.63fF
C2248 la_data_out[50] vdda1 0.63fF
C2249 la_data_in[50] vdda1 0.63fF
C2250 la_oenb[49] vdda1 0.63fF
C2251 la_data_out[49] vdda1 0.63fF
C2252 la_data_in[49] vdda1 0.63fF
C2253 la_oenb[48] vdda1 0.63fF
C2254 la_data_out[48] vdda1 0.63fF
C2255 la_data_in[48] vdda1 0.63fF
C2256 la_oenb[47] vdda1 0.63fF
C2257 la_data_out[47] vdda1 0.63fF
C2258 la_data_in[47] vdda1 0.63fF
C2259 la_oenb[46] vdda1 0.63fF
C2260 la_data_out[46] vdda1 0.63fF
C2261 la_data_in[46] vdda1 0.63fF
C2262 la_oenb[45] vdda1 0.63fF
C2263 la_data_out[45] vdda1 0.63fF
C2264 la_data_in[45] vdda1 0.63fF
C2265 la_oenb[44] vdda1 0.63fF
C2266 la_data_out[44] vdda1 0.63fF
C2267 la_data_in[44] vdda1 0.63fF
C2268 la_oenb[43] vdda1 0.63fF
C2269 la_data_out[43] vdda1 0.63fF
C2270 la_data_in[43] vdda1 0.63fF
C2271 la_oenb[42] vdda1 0.63fF
C2272 la_data_out[42] vdda1 0.63fF
C2273 la_data_in[42] vdda1 0.63fF
C2274 la_oenb[41] vdda1 0.63fF
C2275 la_data_out[41] vdda1 0.63fF
C2276 la_data_in[41] vdda1 0.63fF
C2277 la_oenb[40] vdda1 0.63fF
C2278 la_data_out[40] vdda1 0.63fF
C2279 la_data_in[40] vdda1 0.63fF
C2280 la_oenb[39] vdda1 0.63fF
C2281 la_data_out[39] vdda1 0.63fF
C2282 la_data_in[39] vdda1 0.63fF
C2283 la_oenb[38] vdda1 0.63fF
C2284 la_data_out[38] vdda1 0.63fF
C2285 la_data_in[38] vdda1 0.63fF
C2286 la_oenb[37] vdda1 0.63fF
C2287 la_data_out[37] vdda1 0.63fF
C2288 la_data_in[37] vdda1 0.63fF
C2289 la_oenb[36] vdda1 0.63fF
C2290 la_data_out[36] vdda1 0.63fF
C2291 la_data_in[36] vdda1 0.63fF
C2292 la_oenb[35] vdda1 0.63fF
C2293 la_data_out[35] vdda1 0.63fF
C2294 la_data_in[35] vdda1 0.63fF
C2295 la_oenb[34] vdda1 0.63fF
C2296 la_data_out[34] vdda1 0.63fF
C2297 la_data_in[34] vdda1 0.63fF
C2298 la_oenb[33] vdda1 0.63fF
C2299 la_data_out[33] vdda1 0.63fF
C2300 la_data_in[33] vdda1 0.63fF
C2301 la_oenb[32] vdda1 0.63fF
C2302 la_data_out[32] vdda1 0.63fF
C2303 la_data_in[32] vdda1 0.63fF
C2304 la_oenb[31] vdda1 0.63fF
C2305 la_data_out[31] vdda1 0.63fF
C2306 la_data_in[31] vdda1 0.63fF
C2307 la_oenb[30] vdda1 0.63fF
C2308 la_data_out[30] vdda1 0.63fF
C2309 la_data_in[30] vdda1 0.63fF
C2310 la_oenb[29] vdda1 0.63fF
C2311 la_data_out[29] vdda1 0.63fF
C2312 la_data_in[29] vdda1 0.63fF
C2313 la_oenb[28] vdda1 0.63fF
C2314 la_data_out[28] vdda1 0.63fF
C2315 la_data_in[28] vdda1 0.63fF
C2316 la_oenb[27] vdda1 0.63fF
C2317 la_data_out[27] vdda1 0.63fF
C2318 la_data_in[27] vdda1 0.63fF
C2319 la_oenb[26] vdda1 0.63fF
C2320 la_data_out[26] vdda1 0.63fF
C2321 la_data_in[26] vdda1 0.63fF
C2322 la_oenb[25] vdda1 0.63fF
C2323 la_data_out[25] vdda1 0.63fF
C2324 la_data_in[25] vdda1 0.63fF
C2325 la_oenb[24] vdda1 0.63fF
C2326 la_data_out[24] vdda1 0.63fF
C2327 la_data_in[24] vdda1 0.63fF
C2328 la_oenb[23] vdda1 0.63fF
C2329 la_data_out[23] vdda1 0.63fF
C2330 la_data_in[23] vdda1 0.63fF
C2331 la_oenb[22] vdda1 0.63fF
C2332 la_data_out[22] vdda1 0.63fF
C2333 la_data_in[22] vdda1 0.63fF
C2334 la_oenb[21] vdda1 0.63fF
C2335 la_data_out[21] vdda1 0.63fF
C2336 la_data_in[21] vdda1 0.63fF
C2337 la_oenb[20] vdda1 0.63fF
C2338 la_data_out[20] vdda1 0.63fF
C2339 la_data_in[20] vdda1 0.63fF
C2340 la_oenb[19] vdda1 0.63fF
C2341 la_data_out[19] vdda1 0.63fF
C2342 la_data_in[19] vdda1 0.63fF
C2343 la_oenb[18] vdda1 0.63fF
C2344 la_data_out[18] vdda1 0.63fF
C2345 la_data_in[18] vdda1 0.63fF
C2346 la_oenb[17] vdda1 0.63fF
C2347 la_data_out[17] vdda1 0.63fF
C2348 la_data_in[17] vdda1 0.63fF
C2349 la_oenb[16] vdda1 0.63fF
C2350 la_data_out[16] vdda1 0.63fF
C2351 la_data_in[16] vdda1 0.63fF
C2352 la_oenb[15] vdda1 0.63fF
C2353 la_data_out[15] vdda1 0.63fF
C2354 la_data_in[15] vdda1 0.63fF
C2355 la_oenb[14] vdda1 0.63fF
C2356 la_data_out[14] vdda1 0.63fF
C2357 la_data_in[14] vdda1 0.63fF
C2358 la_oenb[13] vdda1 0.63fF
C2359 la_data_out[13] vdda1 0.63fF
C2360 la_data_in[13] vdda1 0.63fF
C2361 la_oenb[12] vdda1 0.63fF
C2362 la_data_out[12] vdda1 0.63fF
C2363 la_data_in[12] vdda1 0.63fF
C2364 la_oenb[11] vdda1 0.63fF
C2365 la_data_out[11] vdda1 0.63fF
C2366 la_data_in[11] vdda1 0.63fF
C2367 la_oenb[10] vdda1 0.63fF
C2368 la_data_out[10] vdda1 0.63fF
C2369 la_data_in[10] vdda1 0.63fF
C2370 la_oenb[9] vdda1 0.63fF
C2371 la_data_out[9] vdda1 0.63fF
C2372 la_data_in[9] vdda1 0.63fF
C2373 la_oenb[8] vdda1 0.63fF
C2374 la_data_out[8] vdda1 0.63fF
C2375 la_data_in[8] vdda1 0.63fF
C2376 la_oenb[7] vdda1 0.63fF
C2377 la_data_out[7] vdda1 0.63fF
C2378 la_data_in[7] vdda1 0.63fF
C2379 la_oenb[6] vdda1 0.63fF
C2380 la_data_out[6] vdda1 0.63fF
C2381 la_data_in[6] vdda1 0.63fF
C2382 la_oenb[5] vdda1 0.63fF
C2383 la_data_out[5] vdda1 0.63fF
C2384 la_data_in[5] vdda1 0.63fF
C2385 la_oenb[4] vdda1 0.63fF
C2386 la_data_out[4] vdda1 0.63fF
C2387 la_data_in[4] vdda1 0.63fF
C2388 la_oenb[3] vdda1 0.63fF
C2389 la_data_out[3] vdda1 0.63fF
C2390 la_data_in[3] vdda1 0.63fF
C2391 la_oenb[2] vdda1 0.63fF
C2392 la_data_out[2] vdda1 0.63fF
C2393 la_data_in[2] vdda1 0.63fF
C2394 la_oenb[1] vdda1 0.63fF
C2395 la_data_out[1] vdda1 0.63fF
C2396 la_data_in[1] vdda1 0.63fF
C2397 la_oenb[0] vdda1 0.63fF
C2398 la_data_out[0] vdda1 0.63fF
C2399 la_data_in[0] vdda1 0.63fF
C2400 wbs_dat_o[31] vdda1 0.63fF
C2401 wbs_dat_i[31] vdda1 0.63fF
C2402 wbs_adr_i[31] vdda1 0.63fF
C2403 wbs_dat_o[30] vdda1 0.63fF
C2404 wbs_dat_i[30] vdda1 0.63fF
C2405 wbs_adr_i[30] vdda1 0.63fF
C2406 wbs_dat_o[29] vdda1 0.63fF
C2407 wbs_dat_i[29] vdda1 0.63fF
C2408 wbs_adr_i[29] vdda1 0.63fF
C2409 wbs_dat_o[28] vdda1 0.63fF
C2410 wbs_dat_i[28] vdda1 0.63fF
C2411 wbs_adr_i[28] vdda1 0.63fF
C2412 wbs_dat_o[27] vdda1 0.63fF
C2413 wbs_dat_i[27] vdda1 0.63fF
C2414 wbs_adr_i[27] vdda1 0.63fF
C2415 wbs_dat_o[26] vdda1 0.63fF
C2416 wbs_dat_i[26] vdda1 0.63fF
C2417 wbs_adr_i[26] vdda1 0.63fF
C2418 wbs_dat_o[25] vdda1 0.63fF
C2419 wbs_dat_i[25] vdda1 0.63fF
C2420 wbs_adr_i[25] vdda1 0.63fF
C2421 wbs_dat_o[24] vdda1 0.63fF
C2422 wbs_dat_i[24] vdda1 0.63fF
C2423 wbs_adr_i[24] vdda1 0.63fF
C2424 wbs_dat_o[23] vdda1 0.63fF
C2425 wbs_dat_i[23] vdda1 0.63fF
C2426 wbs_adr_i[23] vdda1 0.63fF
C2427 wbs_dat_o[22] vdda1 0.63fF
C2428 wbs_dat_i[22] vdda1 0.63fF
C2429 wbs_adr_i[22] vdda1 0.63fF
C2430 wbs_dat_o[21] vdda1 0.63fF
C2431 wbs_dat_i[21] vdda1 0.63fF
C2432 wbs_adr_i[21] vdda1 0.63fF
C2433 wbs_dat_o[20] vdda1 0.63fF
C2434 wbs_dat_i[20] vdda1 0.63fF
C2435 wbs_adr_i[20] vdda1 0.63fF
C2436 wbs_dat_o[19] vdda1 0.63fF
C2437 wbs_dat_i[19] vdda1 0.63fF
C2438 wbs_adr_i[19] vdda1 0.63fF
C2439 wbs_dat_o[18] vdda1 0.63fF
C2440 wbs_dat_i[18] vdda1 0.63fF
C2441 wbs_adr_i[18] vdda1 0.63fF
C2442 wbs_dat_o[17] vdda1 0.63fF
C2443 wbs_dat_i[17] vdda1 0.63fF
C2444 wbs_adr_i[17] vdda1 0.63fF
C2445 wbs_dat_o[16] vdda1 0.63fF
C2446 wbs_dat_i[16] vdda1 0.63fF
C2447 wbs_adr_i[16] vdda1 0.63fF
C2448 wbs_dat_o[15] vdda1 0.63fF
C2449 wbs_dat_i[15] vdda1 0.63fF
C2450 wbs_adr_i[15] vdda1 0.63fF
C2451 wbs_dat_o[14] vdda1 0.63fF
C2452 wbs_dat_i[14] vdda1 0.63fF
C2453 wbs_adr_i[14] vdda1 0.63fF
C2454 wbs_dat_o[13] vdda1 0.63fF
C2455 wbs_dat_i[13] vdda1 0.63fF
C2456 wbs_adr_i[13] vdda1 0.63fF
C2457 wbs_dat_o[12] vdda1 0.63fF
C2458 wbs_dat_i[12] vdda1 0.63fF
C2459 wbs_adr_i[12] vdda1 0.63fF
C2460 wbs_dat_o[11] vdda1 0.63fF
C2461 wbs_dat_i[11] vdda1 0.63fF
C2462 wbs_adr_i[11] vdda1 0.63fF
C2463 wbs_dat_o[10] vdda1 0.63fF
C2464 wbs_dat_i[10] vdda1 0.63fF
C2465 wbs_adr_i[10] vdda1 0.63fF
C2466 wbs_dat_o[9] vdda1 0.63fF
C2467 wbs_dat_i[9] vdda1 0.63fF
C2468 wbs_adr_i[9] vdda1 0.63fF
C2469 wbs_dat_o[8] vdda1 0.63fF
C2470 wbs_dat_i[8] vdda1 0.63fF
C2471 wbs_adr_i[8] vdda1 0.63fF
C2472 wbs_dat_o[7] vdda1 0.63fF
C2473 wbs_dat_i[7] vdda1 0.63fF
C2474 wbs_adr_i[7] vdda1 0.63fF
C2475 wbs_dat_o[6] vdda1 0.63fF
C2476 wbs_dat_i[6] vdda1 0.63fF
C2477 wbs_adr_i[6] vdda1 0.63fF
C2478 wbs_dat_o[5] vdda1 0.63fF
C2479 wbs_dat_i[5] vdda1 0.63fF
C2480 wbs_adr_i[5] vdda1 0.63fF
C2481 wbs_dat_o[4] vdda1 0.63fF
C2482 wbs_dat_i[4] vdda1 0.63fF
C2483 wbs_adr_i[4] vdda1 0.63fF
C2484 wbs_sel_i[3] vdda1 0.63fF
C2485 wbs_dat_o[3] vdda1 0.63fF
C2486 wbs_dat_i[3] vdda1 0.63fF
C2487 wbs_adr_i[3] vdda1 0.63fF
C2488 wbs_sel_i[2] vdda1 0.63fF
C2489 wbs_dat_o[2] vdda1 0.63fF
C2490 wbs_dat_i[2] vdda1 0.63fF
C2491 wbs_adr_i[2] vdda1 0.63fF
C2492 wbs_sel_i[1] vdda1 0.63fF
C2493 wbs_dat_o[1] vdda1 0.63fF
C2494 wbs_dat_i[1] vdda1 0.63fF
C2495 wbs_adr_i[1] vdda1 0.63fF
C2496 wbs_sel_i[0] vdda1 0.63fF
C2497 wbs_dat_o[0] vdda1 0.63fF
C2498 wbs_dat_i[0] vdda1 0.63fF
C2499 wbs_adr_i[0] vdda1 0.63fF
C2500 wbs_we_i vdda1 0.63fF
C2501 wbs_stb_i vdda1 0.63fF
C2502 wbs_cyc_i vdda1 0.63fF
C2503 wbs_ack_o vdda1 0.63fF
C2504 wb_rst_i vdda1 0.63fF
C2505 wb_clk_i vdda1 0.63fF
C2506 pll_full_0/divider_0/and_0/Z1 vdda1 0.65fF
C2507 pll_full_0/divider_0/and_0/B vdda1 2.45fF
C2508 pll_full_0/divider_0/and_0/A vdda1 2.35fF
C2509 pll_full_0/divider_0/and_0/out1 vdda1 2.99fF
C2510 pll_full_0/divider_0/tspc_2/Z4 vdda1 0.86fF
C2511 pll_full_0/div vdda1 14.90fF
C2512 pll_full_0/divider_0/tspc_2/Z3 vdda1 2.26fF
C2513 pll_full_0/divider_0/tspc_2/Z2 vdda1 1.46fF
C2514 pll_full_0/divider_0/tspc_2/Z1 vdda1 0.99fF
C2515 pll_full_0/divider_0/nor_0/B vdda1 6.48fF
C2516 pll_full_0/divider_0/tspc_2/a_630_n680# vdda1 1.14fF **FLOATING
C2517 pll_full_0/divider_0/tspc_1/Z4 vdda1 0.86fF
C2518 pll_full_0/divider_0/tspc_1/Q vdda1 3.12fF
C2519 pll_full_0/divider_0/tspc_1/Z3 vdda1 2.26fF
C2520 pll_full_0/divider_0/tspc_1/Z2 vdda1 1.46fF
C2521 pll_full_0/divider_0/tspc_1/Z1 vdda1 0.99fF
C2522 pll_full_0/divider_0/nor_1/B vdda1 7.12fF
C2523 pll_full_0/divider_0/tspc_1/a_630_n680# vdda1 1.15fF **FLOATING
C2524 pll_full_0/divider_0/tspc_0/Z4 vdda1 0.86fF
C2525 pll_full_0/divider_0/tspc_0/Q vdda1 3.14fF
C2526 pll_full_0/divider_0/tspc_0/Z3 vdda1 2.26fF
C2527 pll_full_0/divider_0/tspc_0/Z2 vdda1 1.46fF
C2528 pll_full_0/divider_0/tspc_0/Z1 vdda1 0.99fF
C2529 pll_full_0/divider_0/nor_1/A vdda1 7.08fF
C2530 pll_full_0/divider_0/tspc_0/a_630_n680# vdda1 1.15fF **FLOATING
C2531 pll_full_0/vco vdda1 35.22fF
C2532 pll_full_0/divider_0/prescaler_0/nand_1/z1 vdda1 0.36fF
C2533 pll_full_0/divider_0/prescaler_0/tspc_0/D vdda1 2.64fF
C2534 pll_full_0/divider_0/prescaler_0/tspc_2/Q vdda1 3.72fF
C2535 pll_full_0/divider_0/prescaler_0/tspc_1/Q vdda1 3.61fF
C2536 pll_full_0/divider_0/prescaler_0/nand_0/z1 vdda1 0.36fF
C2537 pll_full_0/divider_0/prescaler_0/tspc_2/D vdda1 3.12fF
C2538 pll_full_0/divider_0/and_0/OUT vdda1 5.67fF
C2539 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 vdda1 0.86fF
C2540 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 vdda1 2.26fF
C2541 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 vdda1 1.19fF
C2542 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 vdda1 0.99fF
C2543 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# vdda1 1.47fF **FLOATING
C2544 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# vdda1 2.11fF **FLOATING
C2545 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 vdda1 0.86fF
C2546 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 vdda1 2.26fF
C2547 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 vdda1 1.48fF
C2548 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 vdda1 0.99fF
C2549 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# vdda1 1.14fF **FLOATING
C2550 pll_full_0/divider_0/prescaler_0/m1_2700_2190# vdda1 4.22fF **FLOATING
C2551 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 vdda1 0.86fF
C2552 pll_full_0/divider_0/prescaler_0/Out vdda1 4.59fF
C2553 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 vdda1 2.26fF
C2554 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 vdda1 1.46fF
C2555 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 vdda1 0.99fF
C2556 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# vdda1 1.16fF **FLOATING
C2557 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# vdda1 2.11fF **FLOATING
C2558 pll_full_0/divider_0/nor_1/Z1 vdda1 1.34fF
C2559 pll_full_0/divider_0/nor_0/Z1 vdda1 1.34fF
C2560 pll_full_0/ro_complete_0/cbank_2/v vdda1 16.43fF
C2561 pll_full_0/ro_complete_0/cbank_2/switch_5/vin vdda1 0.78fF
C2562 pll_full_0/ro_complete_0/cbank_2/switch_4/vin vdda1 1.50fF
C2563 pll_full_0/ro_complete_0/cbank_2/switch_2/vin vdda1 1.30fF
C2564 pll_full_0/ro_complete_0/cbank_2/switch_3/vin vdda1 0.56fF
C2565 pll_full_0/ro_complete_0/cbank_2/switch_1/vin vdda1 1.14fF
C2566 pll_full_0/ro_complete_0/cbank_2/switch_0/vin vdda1 1.02fF
C2567 pll_full_0/ro_complete_0/cbank_1/switch_5/vin vdda1 0.78fF
C2568 pll_full_0/ro_complete_0/a0 vdda1 5.35fF
C2569 pll_full_0/ro_complete_0/cbank_1/switch_4/vin vdda1 1.50fF
C2570 pll_full_0/ro_complete_0/a1 vdda1 6.54fF
C2571 pll_full_0/ro_complete_0/cbank_1/switch_2/vin vdda1 1.30fF
C2572 pll_full_0/ro_complete_0/a3 vdda1 5.96fF
C2573 pll_full_0/ro_complete_0/cbank_1/switch_3/vin vdda1 0.56fF
C2574 pll_full_0/ro_complete_0/a2 vdda1 5.21fF
C2575 pll_full_0/ro_complete_0/cbank_1/switch_1/vin vdda1 1.14fF
C2576 pll_full_0/ro_complete_0/a4 vdda1 5.81fF
C2577 pll_full_0/ro_complete_0/cbank_1/switch_0/vin vdda1 1.02fF
C2578 pll_full_0/ro_complete_0/a5 vdda1 6.74fF
C2579 pll_full_0/ro_complete_0/cbank_0/v vdda1 15.12fF
C2580 pll_full_0/ro_complete_0/cbank_0/switch_5/vin vdda1 0.78fF
C2581 pll_full_0/ro_complete_0/cbank_0/switch_4/vin vdda1 1.50fF
C2582 pll_full_0/ro_complete_0/cbank_0/switch_2/vin vdda1 1.30fF
C2583 pll_full_0/ro_complete_0/cbank_0/switch_3/vin vdda1 0.56fF
C2584 pll_full_0/ro_complete_0/cbank_0/switch_1/vin vdda1 1.14fF
C2585 pll_full_0/ro_complete_0/cbank_0/switch_0/vin vdda1 1.02fF
C2586 pll_full_0/filter_0/a_4216_n5230# vdda1 418.90fF **FLOATING
C2587 pll_full_0/filter_0/a_4216_n2998# vdda1 1.39fF **FLOATING
C2588 pll_full_0/cp_0/down vdda1 1.54fF
C2589 pll_full_0/cp_0/upbar vdda1 1.79fF
C2590 pll_full_0/cp_0/a_7110_n2840# vdda1 0.17fF **FLOATING
C2591 pll_full_0/cp_0/a_3060_n2840# vdda1 1.71fF **FLOATING
C2592 pll_full_0/cp_0/a_7110_0# vdda1 0.17fF **FLOATING
C2593 pll_full_0/cp_0/a_6370_0# vdda1 0.40fF **FLOATING
C2594 pll_full_0/cp_0/a_3060_0# vdda1 2.50fF **FLOATING
C2595 pll_full_0/cp_0/a_1710_0# vdda1 7.47fF **FLOATING
C2596 pll_full_0/pd_0/UP vdda1 5.89fF
C2597 pll_full_0/pd_0/and_pd_0/Z1 vdda1 0.39fF
C2598 pll_full_0/pd_0/and_pd_0/Out1 vdda1 2.22fF
C2599 pll_full_0/pd_0/tspc_r_1/z5 vdda1 1.10fF
C2600 pll_full_0/pd_0/tspc_r_1/Z4 vdda1 1.07fF
C2601 pll_full_0/pd_0/R vdda1 3.05fF
C2602 pll_full_0/pd_0/tspc_r_1/Qbar vdda1 0.79fF
C2603 pll_full_0/pd_0/tspc_r_1/Z2 vdda1 1.22fF
C2604 pll_full_0/pd_0/tspc_r_1/Z1 vdda1 0.67fF
C2605 pll_full_0/pd_0/DOWN vdda1 7.38fF
C2606 pll_full_0/pd_0/tspc_r_1/Qbar1 vdda1 1.34fF
C2607 pll_full_0/pd_0/tspc_r_1/Z3 vdda1 2.12fF
C2608 pll_full_0/pd_0/tspc_r_0/z5 vdda1 1.10fF
C2609 pll_full_0/pd_0/tspc_r_0/Z4 vdda1 1.07fF
C2610 pll_full_0/pd_0/tspc_r_0/Qbar vdda1 0.88fF
C2611 pll_full_0/pd_0/tspc_r_0/Z2 vdda1 1.22fF
C2612 pll_full_0/pd_0/tspc_r_0/Z1 vdda1 0.67fF
C2613 pll_full_0/pd_0/tspc_r_0/Qbar1 vdda1 1.34fF
C2614 pll_full_0/pd_0/tspc_r_0/Z3 vdda1 2.12fF
C2615 pll_full_0/ref vdda1 4.34fF
C2616 pll_full_1/divider_0/and_0/Z1 vdda1 0.65fF
C2617 pll_full_1/divider_0/and_0/B vdda1 2.45fF
C2618 pll_full_1/divider_0/and_0/A vdda1 2.35fF
C2619 pll_full_1/divider_0/and_0/out1 vdda1 2.99fF
C2620 pll_full_1/divider_0/tspc_2/Z4 vdda1 0.86fF
C2621 pll_full_1/div vdda1 14.90fF
C2622 pll_full_1/divider_0/tspc_2/Z3 vdda1 2.26fF
C2623 pll_full_1/divider_0/tspc_2/Z2 vdda1 1.46fF
C2624 pll_full_1/divider_0/tspc_2/Z1 vdda1 0.99fF
C2625 pll_full_1/divider_0/nor_0/B vdda1 6.48fF
C2626 pll_full_1/divider_0/tspc_2/a_630_n680# vdda1 1.14fF **FLOATING
C2627 pll_full_1/divider_0/tspc_1/Z4 vdda1 0.86fF
C2628 pll_full_1/divider_0/tspc_1/Q vdda1 3.12fF
C2629 pll_full_1/divider_0/tspc_1/Z3 vdda1 2.26fF
C2630 pll_full_1/divider_0/tspc_1/Z2 vdda1 1.46fF
C2631 pll_full_1/divider_0/tspc_1/Z1 vdda1 0.99fF
C2632 pll_full_1/divider_0/nor_1/B vdda1 7.12fF
C2633 pll_full_1/divider_0/tspc_1/a_630_n680# vdda1 1.15fF **FLOATING
C2634 pll_full_1/divider_0/tspc_0/Z4 vdda1 0.86fF
C2635 pll_full_1/divider_0/tspc_0/Q vdda1 3.14fF
C2636 pll_full_1/divider_0/tspc_0/Z3 vdda1 2.26fF
C2637 pll_full_1/divider_0/tspc_0/Z2 vdda1 1.46fF
C2638 pll_full_1/divider_0/tspc_0/Z1 vdda1 0.99fF
C2639 pll_full_1/divider_0/nor_1/A vdda1 7.08fF
C2640 pll_full_1/divider_0/tspc_0/a_630_n680# vdda1 1.15fF **FLOATING
C2641 pll_full_1/vco vdda1 35.22fF
C2642 pll_full_1/divider_0/prescaler_0/nand_1/z1 vdda1 0.36fF
C2643 pll_full_1/divider_0/prescaler_0/tspc_0/D vdda1 2.64fF
C2644 pll_full_1/divider_0/prescaler_0/tspc_2/Q vdda1 3.72fF
C2645 pll_full_1/divider_0/prescaler_0/tspc_1/Q vdda1 3.61fF
C2646 pll_full_1/divider_0/prescaler_0/nand_0/z1 vdda1 0.36fF
C2647 pll_full_1/divider_0/prescaler_0/tspc_2/D vdda1 3.12fF
C2648 pll_full_1/divider_0/and_0/OUT vdda1 5.67fF
C2649 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 vdda1 0.86fF
C2650 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 vdda1 2.26fF
C2651 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 vdda1 1.19fF
C2652 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 vdda1 0.99fF
C2653 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# vdda1 1.47fF **FLOATING
C2654 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# vdda1 2.11fF **FLOATING
C2655 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 vdda1 0.86fF
C2656 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 vdda1 2.26fF
C2657 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 vdda1 1.48fF
C2658 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 vdda1 0.99fF
C2659 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# vdda1 1.14fF **FLOATING
C2660 pll_full_1/divider_0/prescaler_0/m1_2700_2190# vdda1 4.22fF **FLOATING
C2661 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 vdda1 0.86fF
C2662 pll_full_1/divider_0/prescaler_0/Out vdda1 4.59fF
C2663 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 vdda1 2.26fF
C2664 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 vdda1 1.46fF
C2665 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 vdda1 0.99fF
C2666 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# vdda1 1.16fF **FLOATING
C2667 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# vdda1 2.11fF **FLOATING
C2668 pll_full_1/divider_0/nor_1/Z1 vdda1 1.34fF
C2669 pll_full_1/divider_0/nor_0/Z1 vdda1 1.34fF
C2670 pll_full_1/ro_complete_0/cbank_2/v vdda1 16.43fF
C2671 pll_full_1/ro_complete_0/cbank_2/switch_5/vin vdda1 0.78fF
C2672 pll_full_1/ro_complete_0/cbank_2/switch_4/vin vdda1 1.50fF
C2673 pll_full_1/ro_complete_0/cbank_2/switch_2/vin vdda1 1.30fF
C2674 pll_full_1/ro_complete_0/cbank_2/switch_3/vin vdda1 0.56fF
C2675 pll_full_1/ro_complete_0/cbank_2/switch_1/vin vdda1 1.14fF
C2676 pll_full_1/ro_complete_0/cbank_2/switch_0/vin vdda1 1.02fF
C2677 pll_full_1/ro_complete_0/cbank_1/switch_5/vin vdda1 0.78fF
C2678 pll_full_1/ro_complete_0/a0 vdda1 5.35fF
C2679 pll_full_1/ro_complete_0/cbank_1/switch_4/vin vdda1 1.50fF
C2680 pll_full_1/ro_complete_0/a1 vdda1 6.54fF
C2681 pll_full_1/ro_complete_0/cbank_1/switch_2/vin vdda1 1.30fF
C2682 pll_full_1/ro_complete_0/a3 vdda1 5.96fF
C2683 pll_full_1/ro_complete_0/cbank_1/switch_3/vin vdda1 0.56fF
C2684 pll_full_1/ro_complete_0/a2 vdda1 5.21fF
C2685 pll_full_1/ro_complete_0/cbank_1/switch_1/vin vdda1 1.14fF
C2686 pll_full_1/ro_complete_0/a4 vdda1 5.81fF
C2687 pll_full_1/ro_complete_0/cbank_1/switch_0/vin vdda1 1.02fF
C2688 pll_full_1/ro_complete_0/a5 vdda1 6.74fF
C2689 pll_full_1/ro_complete_0/cbank_0/v vdda1 15.12fF
C2690 pll_full_1/ro_complete_0/cbank_0/switch_5/vin vdda1 0.78fF
C2691 pll_full_1/ro_complete_0/cbank_0/switch_4/vin vdda1 1.50fF
C2692 pll_full_1/ro_complete_0/cbank_0/switch_2/vin vdda1 1.30fF
C2693 pll_full_1/ro_complete_0/cbank_0/switch_3/vin vdda1 0.56fF
C2694 pll_full_1/ro_complete_0/cbank_0/switch_1/vin vdda1 1.14fF
C2695 pll_full_1/ro_complete_0/cbank_0/switch_0/vin vdda1 1.02fF
C2696 pll_full_1/filter_0/a_4216_n5230# vdda1 418.90fF **FLOATING
C2697 pll_full_1/filter_0/a_4216_n2998# vdda1 1.39fF **FLOATING
C2698 pll_full_1/cp_0/down vdda1 1.54fF
C2699 pll_full_1/cp_0/upbar vdda1 1.79fF
C2700 pll_full_1/cp_0/a_7110_n2840# vdda1 0.17fF **FLOATING
C2701 pll_full_1/cp_0/a_3060_n2840# vdda1 1.71fF **FLOATING
C2702 pll_full_1/cp_0/a_7110_0# vdda1 0.17fF **FLOATING
C2703 pll_full_1/cp_0/a_6370_0# vdda1 0.40fF **FLOATING
C2704 pll_full_1/cp_0/a_3060_0# vdda1 2.50fF **FLOATING
C2705 pll_full_1/cp_0/a_1710_0# vdda1 7.47fF **FLOATING
C2706 pll_full_1/pd_0/UP vdda1 5.89fF
C2707 pll_full_1/pd_0/and_pd_0/Z1 vdda1 0.39fF
C2708 pll_full_1/pd_0/and_pd_0/Out1 vdda1 2.22fF
C2709 pll_full_1/pd_0/tspc_r_1/z5 vdda1 1.10fF
C2710 pll_full_1/pd_0/tspc_r_1/Z4 vdda1 1.07fF
C2711 pll_full_1/pd_0/R vdda1 3.05fF
C2712 pll_full_1/pd_0/tspc_r_1/Qbar vdda1 0.79fF
C2713 pll_full_1/pd_0/tspc_r_1/Z2 vdda1 1.22fF
C2714 pll_full_1/pd_0/tspc_r_1/Z1 vdda1 0.67fF
C2715 pll_full_1/pd_0/DOWN vdda1 7.38fF
C2716 pll_full_1/pd_0/tspc_r_1/Qbar1 vdda1 1.34fF
C2717 pll_full_1/pd_0/tspc_r_1/Z3 vdda1 2.12fF
C2718 pll_full_1/pd_0/tspc_r_0/z5 vdda1 1.10fF
C2719 pll_full_1/pd_0/tspc_r_0/Z4 vdda1 1.07fF
C2720 pll_full_1/pd_0/tspc_r_0/Qbar vdda1 0.88fF
C2721 pll_full_1/pd_0/tspc_r_0/Z2 vdda1 1.22fF
C2722 pll_full_1/pd_0/tspc_r_0/Z1 vdda1 0.67fF
C2723 pll_full_1/pd_0/tspc_r_0/Qbar1 vdda1 1.34fF
C2724 pll_full_1/pd_0/tspc_r_0/Z3 vdda1 2.12fF
C2725 pll_full_1/ref vdda1 4.34fF
C2726 div_pd_buffered_0/tapered_buf_0/out vdda1 385.99fF
C2727 div_pd_buffered_0/tapered_buf_0/a_n10_n140# vdda1 0.06fF **FLOATING
C2728 div_pd_buffered_0/tapered_buf_0/a_210_n610# vdda1 592.97fF **FLOATING
C2729 div_pd_buffered_0/tapered_buf_0/a_160_230# vdda1 0.15fF **FLOATING
C2730 div_pd_buffered_0/tapered_buf_0/a_n10_230# vdda1 0.13fF **FLOATING
C2731 div_pd_buffered_0/tapered_buf_0/a_4670_0# vdda1 252.41fF **FLOATING
C2732 div_pd_buffered_0/tapered_buf_0/a_1650_0# vdda1 63.61fF **FLOATING
C2733 div_pd_buffered_0/tapered_buf_0/a_580_0# vdda1 16.76fF **FLOATING
C2734 div_pd_buffered_0/tapered_buf_0/a_160_n140# vdda1 4.09fF **FLOATING
C2735 div_pd_buffered_0/tapered_buf_1/in vdda1 1.13fF
C2736 div_pd_buffered_0/tapered_buf_1/a_n10_n140# vdda1 0.06fF **FLOATING
C2737 div_pd_buffered_0/tapered_buf_1/a_210_n610# vdda1 592.97fF **FLOATING
C2738 div_pd_buffered_0/tapered_buf_1/a_160_230# vdda1 0.15fF **FLOATING
C2739 div_pd_buffered_0/tapered_buf_1/a_n10_230# vdda1 0.13fF **FLOATING
C2740 div_pd_buffered_0/tapered_buf_1/a_4670_0# vdda1 252.41fF **FLOATING
C2741 div_pd_buffered_0/tapered_buf_1/a_1650_0# vdda1 63.61fF **FLOATING
C2742 div_pd_buffered_0/tapered_buf_1/a_580_0# vdda1 16.76fF **FLOATING
C2743 div_pd_buffered_0/tapered_buf_1/a_160_n140# vdda1 4.09fF **FLOATING
C2744 div_pd_buffered_0/divider_0/and_0/Z1 vdda1 0.74fF
C2745 div_pd_buffered_0/divider_0/and_0/B vdda1 2.25fF
C2746 div_pd_buffered_0/divider_0/and_0/A vdda1 2.19fF
C2747 div_pd_buffered_0/divider_0/and_0/out1 vdda1 2.93fF
C2748 div_pd_buffered_0/divider_0/tspc_2/Z4 vdda1 0.86fF
C2749 div_pd_buffered_0/divider_0/tspc_2/Z3 vdda1 2.26fF
C2750 div_pd_buffered_0/divider_0/tspc_2/Z2 vdda1 1.46fF
C2751 div_pd_buffered_0/divider_0/tspc_2/Z1 vdda1 0.99fF
C2752 div_pd_buffered_0/divider_0/nor_0/B vdda1 6.37fF
C2753 div_pd_buffered_0/divider_0/tspc_2/a_630_n680# vdda1 1.14fF **FLOATING
C2754 div_pd_buffered_0/divider_0/tspc_1/Z4 vdda1 0.86fF
C2755 div_pd_buffered_0/divider_0/tspc_1/Q vdda1 3.12fF
C2756 div_pd_buffered_0/divider_0/tspc_1/Z3 vdda1 2.26fF
C2757 div_pd_buffered_0/divider_0/tspc_1/Z2 vdda1 1.46fF
C2758 div_pd_buffered_0/divider_0/tspc_1/Z1 vdda1 0.99fF
C2759 div_pd_buffered_0/divider_0/nor_1/B vdda1 7.05fF
C2760 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# vdda1 1.15fF **FLOATING
C2761 div_pd_buffered_0/divider_0/tspc_0/Z4 vdda1 0.86fF
C2762 div_pd_buffered_0/divider_0/tspc_0/Q vdda1 3.14fF
C2763 div_pd_buffered_0/divider_0/tspc_0/Z3 vdda1 2.26fF
C2764 div_pd_buffered_0/divider_0/tspc_0/Z2 vdda1 1.46fF
C2765 div_pd_buffered_0/divider_0/tspc_0/Z1 vdda1 0.99fF
C2766 div_pd_buffered_0/divider_0/nor_1/A vdda1 7.04fF
C2767 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# vdda1 1.15fF **FLOATING
C2768 div_pd_buffered_0/divider_0/clk vdda1 399.62fF
C2769 div_pd_buffered_0/divider_0/prescaler_0/nand_1/z1 vdda1 0.36fF
C2770 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D vdda1 2.64fF
C2771 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q vdda1 3.64fF
C2772 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q vdda1 3.61fF
C2773 div_pd_buffered_0/divider_0/prescaler_0/nand_0/z1 vdda1 0.36fF
C2774 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D vdda1 3.12fF
C2775 div_pd_buffered_0/divider_0/and_0/OUT vdda1 5.62fF
C2776 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 vdda1 0.86fF
C2777 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 vdda1 2.26fF
C2778 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 vdda1 1.46fF
C2779 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z1 vdda1 0.99fF
C2780 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# vdda1 1.14fF **FLOATING
C2781 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# vdda1 2.11fF **FLOATING
C2782 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 vdda1 0.86fF
C2783 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 vdda1 2.26fF
C2784 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 vdda1 1.48fF
C2785 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z1 vdda1 0.99fF
C2786 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# vdda1 1.14fF **FLOATING
C2787 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# vdda1 4.22fF **FLOATING
C2788 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 vdda1 0.86fF
C2789 div_pd_buffered_0/divider_0/prescaler_0/Out vdda1 4.59fF
C2790 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 vdda1 2.26fF
C2791 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 vdda1 1.46fF
C2792 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z1 vdda1 0.99fF
C2793 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# vdda1 1.16fF **FLOATING
C2794 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# vdda1 2.11fF **FLOATING
C2795 div_pd_buffered_0/divider_0/nor_1/Z1 vdda1 1.34fF
C2796 div_pd_buffered_0/divider_0/nor_0/Z1 vdda1 1.34fF
C2797 div_pd_buffered_0/divider_0/mc2 vdda1 393.39fF
C2798 div_pd_buffered_0/pd_0/UP vdda1 6.08fF
C2799 div_pd_buffered_0/pd_0/and_pd_0/Z1 vdda1 0.39fF
C2800 div_pd_buffered_0/pd_0/and_pd_0/Out1 vdda1 2.22fF
C2801 div_pd_buffered_0/pd_0/tspc_r_1/z5 vdda1 1.10fF
C2802 div_pd_buffered_0/pd_0/tspc_r_1/Z4 vdda1 1.07fF
C2803 div_pd_buffered_0/pd_0/R vdda1 3.05fF
C2804 div_pd_buffered_0/pd_0/tspc_r_1/Qbar vdda1 0.79fF
C2805 div_pd_buffered_0/pd_0/tspc_r_1/Z2 vdda1 1.22fF
C2806 div_pd_buffered_0/pd_0/tspc_r_1/Z1 vdda1 0.67fF
C2807 div_pd_buffered_0/pd_0/DOWN vdda1 8.79fF
C2808 div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 vdda1 1.34fF
C2809 div_pd_buffered_0/pd_0/tspc_r_1/Z3 vdda1 2.12fF
C2810 div_pd_buffered_0/pd_0/DIV vdda1 6.57fF
C2811 div_pd_buffered_0/pd_0/tspc_r_0/z5 vdda1 1.10fF
C2812 div_pd_buffered_0/pd_0/tspc_r_0/Z4 vdda1 1.07fF
C2813 div_pd_buffered_0/pd_0/tspc_r_0/Qbar vdda1 0.88fF
C2814 div_pd_buffered_0/pd_0/tspc_r_0/Z2 vdda1 1.22fF
C2815 div_pd_buffered_0/pd_0/tspc_r_0/Z1 vdda1 0.67fF
C2816 div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 vdda1 1.34fF
C2817 div_pd_buffered_0/pd_0/tspc_r_0/Z3 vdda1 2.12fF
C2818 div_pd_buffered_0/pd_0/REF vdda1 392.16fF
C2819 div_pd_buffered_0/tapered_buf_4/out vdda1 385.93fF
C2820 div_pd_buffered_0/tapered_buf_4/a_n10_n140# vdda1 0.06fF **FLOATING
C2821 div_pd_buffered_0/tapered_buf_4/a_210_n610# vdda1 592.97fF **FLOATING
C2822 div_pd_buffered_0/tapered_buf_4/a_160_230# vdda1 0.15fF **FLOATING
C2823 div_pd_buffered_0/tapered_buf_4/a_n10_230# vdda1 0.13fF **FLOATING
C2824 div_pd_buffered_0/tapered_buf_4/a_4670_0# vdda1 252.41fF **FLOATING
C2825 div_pd_buffered_0/tapered_buf_4/a_1650_0# vdda1 63.61fF **FLOATING
C2826 div_pd_buffered_0/tapered_buf_4/a_580_0# vdda1 16.76fF **FLOATING
C2827 div_pd_buffered_0/tapered_buf_4/a_160_n140# vdda1 4.09fF **FLOATING
C2828 div_pd_buffered_0/tapered_buf_3/in vdda1 1.13fF
C2829 div_pd_buffered_0/tapered_buf_3/a_n10_n140# vdda1 0.06fF **FLOATING
C2830 div_pd_buffered_0/tapered_buf_3/a_210_n610# vdda1 592.97fF **FLOATING
C2831 div_pd_buffered_0/tapered_buf_3/a_160_230# vdda1 0.15fF **FLOATING
C2832 div_pd_buffered_0/tapered_buf_3/a_n10_230# vdda1 0.13fF **FLOATING
C2833 div_pd_buffered_0/tapered_buf_3/a_4670_0# vdda1 252.41fF **FLOATING
C2834 div_pd_buffered_0/tapered_buf_3/a_1650_0# vdda1 63.61fF **FLOATING
C2835 div_pd_buffered_0/tapered_buf_3/a_580_0# vdda1 16.76fF **FLOATING
C2836 div_pd_buffered_0/tapered_buf_3/a_160_n140# vdda1 4.09fF **FLOATING
C2837 div_pd_buffered_0/tapered_buf_2/in vdda1 1.13fF
C2838 div_pd_buffered_0/tapered_buf_2/a_n10_n140# vdda1 0.06fF **FLOATING
C2839 div_pd_buffered_0/tapered_buf_2/a_210_n610# vdda1 592.97fF **FLOATING
C2840 div_pd_buffered_0/tapered_buf_2/a_160_230# vdda1 0.15fF **FLOATING
C2841 div_pd_buffered_0/tapered_buf_2/a_n10_230# vdda1 0.13fF **FLOATING
C2842 div_pd_buffered_0/tapered_buf_2/a_4670_0# vdda1 252.41fF **FLOATING
C2843 div_pd_buffered_0/tapered_buf_2/a_1650_0# vdda1 63.61fF **FLOATING
C2844 div_pd_buffered_0/tapered_buf_2/a_580_0# vdda1 16.76fF **FLOATING
C2845 div_pd_buffered_0/tapered_buf_2/a_160_n140# vdda1 4.09fF **FLOATING
C2846 divider_1/and_0/Z1 vdda1 0.74fF
C2847 divider_1/and_0/B vdda1 2.25fF
C2848 divider_1/and_0/A vdda1 2.19fF
C2849 divider_1/and_0/out1 vdda1 2.93fF
C2850 divider_1/tspc_2/Z4 vdda1 0.86fF
C2851 divider_1/Out vdda1 1.60fF
C2852 divider_1/tspc_2/Z3 vdda1 2.26fF
C2853 divider_1/tspc_2/Z2 vdda1 1.46fF
C2854 divider_1/tspc_2/Z1 vdda1 0.99fF
C2855 divider_1/nor_0/B vdda1 6.33fF
C2856 divider_1/tspc_2/a_630_n680# vdda1 1.14fF **FLOATING
C2857 divider_1/tspc_1/Z4 vdda1 0.86fF
C2858 divider_1/tspc_1/Q vdda1 3.12fF
C2859 divider_1/tspc_1/Z3 vdda1 2.26fF
C2860 divider_1/tspc_1/Z2 vdda1 1.46fF
C2861 divider_1/tspc_1/Z1 vdda1 0.99fF
C2862 divider_1/nor_1/B vdda1 7.05fF
C2863 divider_1/tspc_1/a_630_n680# vdda1 1.15fF **FLOATING
C2864 divider_1/tspc_0/Z4 vdda1 0.86fF
C2865 divider_1/tspc_0/Q vdda1 3.14fF
C2866 divider_1/tspc_0/Z3 vdda1 2.26fF
C2867 divider_1/tspc_0/Z2 vdda1 1.46fF
C2868 divider_1/tspc_0/Z1 vdda1 0.99fF
C2869 divider_1/nor_1/A vdda1 7.04fF
C2870 divider_1/tspc_0/a_630_n680# vdda1 1.15fF **FLOATING
C2871 divider_1/clk vdda1 5.63fF
C2872 divider_1/prescaler_0/nand_1/z1 vdda1 0.36fF
C2873 divider_1/prescaler_0/tspc_0/D vdda1 2.64fF
C2874 divider_1/prescaler_0/tspc_2/Q vdda1 3.74fF
C2875 divider_1/prescaler_0/tspc_1/Q vdda1 3.61fF
C2876 divider_1/prescaler_0/nand_0/z1 vdda1 0.36fF
C2877 divider_1/prescaler_0/tspc_2/D vdda1 3.12fF
C2878 divider_1/and_0/OUT vdda1 5.62fF
C2879 divider_1/prescaler_0/tspc_2/Z4 vdda1 0.86fF
C2880 divider_1/prescaler_0/tspc_2/Z3 vdda1 2.26fF
C2881 divider_1/prescaler_0/tspc_2/Z2 vdda1 1.46fF
C2882 divider_1/prescaler_0/tspc_2/Z1 vdda1 0.99fF
C2883 divider_1/prescaler_0/tspc_2/a_630_n680# vdda1 1.14fF **FLOATING
C2884 divider_1/prescaler_0/tspc_2/a_740_n680# vdda1 2.11fF **FLOATING
C2885 divider_1/prescaler_0/tspc_1/Z4 vdda1 0.86fF
C2886 divider_1/prescaler_0/tspc_1/Z3 vdda1 2.26fF
C2887 divider_1/prescaler_0/tspc_1/Z2 vdda1 1.48fF
C2888 divider_1/prescaler_0/tspc_1/Z1 vdda1 0.99fF
C2889 divider_1/prescaler_0/tspc_1/a_630_n680# vdda1 1.14fF **FLOATING
C2890 divider_1/prescaler_0/m1_2700_2190# vdda1 4.22fF **FLOATING
C2891 divider_1/prescaler_0/tspc_0/Z4 vdda1 0.86fF
C2892 divider_1/prescaler_0/Out vdda1 4.59fF
C2893 divider_1/prescaler_0/tspc_0/Z3 vdda1 2.26fF
C2894 divider_1/prescaler_0/tspc_0/Z2 vdda1 1.46fF
C2895 divider_1/prescaler_0/tspc_0/Z1 vdda1 0.99fF
C2896 divider_1/prescaler_0/tspc_0/a_630_n680# vdda1 1.16fF **FLOATING
C2897 divider_1/prescaler_0/tspc_0/a_740_n680# vdda1 2.11fF **FLOATING
C2898 divider_1/nor_1/Z1 vdda1 1.34fF
C2899 divider_1/nor_0/Z1 vdda1 1.34fF
C2900 divider_1/mc2 vdda1 5.29fF
C2901 divider_0/and_0/Z1 vdda1 0.74fF
C2902 divider_0/and_0/B vdda1 2.25fF
C2903 divider_0/and_0/A vdda1 2.19fF
C2904 divider_0/and_0/out1 vdda1 2.93fF
C2905 divider_0/tspc_2/Z4 vdda1 0.86fF
C2906 divider_0/Out vdda1 1.60fF
C2907 divider_0/tspc_2/Z3 vdda1 2.26fF
C2908 divider_0/tspc_2/Z2 vdda1 1.46fF
C2909 divider_0/tspc_2/Z1 vdda1 0.99fF
C2910 divider_0/nor_0/B vdda1 6.33fF
C2911 divider_0/tspc_2/a_630_n680# vdda1 1.14fF **FLOATING
C2912 divider_0/tspc_1/Z4 vdda1 0.86fF
C2913 divider_0/tspc_1/Q vdda1 3.12fF
C2914 divider_0/tspc_1/Z3 vdda1 2.26fF
C2915 divider_0/tspc_1/Z2 vdda1 1.46fF
C2916 divider_0/tspc_1/Z1 vdda1 0.99fF
C2917 divider_0/nor_1/B vdda1 7.05fF
C2918 divider_0/tspc_1/a_630_n680# vdda1 1.15fF **FLOATING
C2919 divider_0/tspc_0/Z4 vdda1 0.86fF
C2920 divider_0/tspc_0/Q vdda1 3.14fF
C2921 divider_0/tspc_0/Z3 vdda1 2.26fF
C2922 divider_0/tspc_0/Z2 vdda1 1.46fF
C2923 divider_0/tspc_0/Z1 vdda1 0.99fF
C2924 divider_0/nor_1/A vdda1 7.04fF
C2925 divider_0/tspc_0/a_630_n680# vdda1 1.15fF **FLOATING
C2926 divider_0/clk vdda1 5.63fF
C2927 divider_0/prescaler_0/nand_1/z1 vdda1 0.36fF
C2928 divider_0/prescaler_0/tspc_0/D vdda1 2.64fF
C2929 divider_0/prescaler_0/tspc_2/Q vdda1 3.64fF
C2930 divider_0/prescaler_0/tspc_1/Q vdda1 3.61fF
C2931 divider_0/prescaler_0/nand_0/z1 vdda1 0.36fF
C2932 divider_0/prescaler_0/tspc_2/D vdda1 3.12fF
C2933 divider_0/and_0/OUT vdda1 5.62fF
C2934 divider_0/prescaler_0/tspc_2/Z4 vdda1 0.86fF
C2935 divider_0/prescaler_0/tspc_2/Z3 vdda1 2.26fF
C2936 divider_0/prescaler_0/tspc_2/Z2 vdda1 1.46fF
C2937 divider_0/prescaler_0/tspc_2/Z1 vdda1 0.99fF
C2938 divider_0/prescaler_0/tspc_2/a_630_n680# vdda1 1.14fF **FLOATING
C2939 divider_0/prescaler_0/tspc_2/a_740_n680# vdda1 2.11fF **FLOATING
C2940 divider_0/prescaler_0/tspc_1/Z4 vdda1 0.86fF
C2941 divider_0/prescaler_0/tspc_1/Z3 vdda1 2.26fF
C2942 divider_0/prescaler_0/tspc_1/Z2 vdda1 1.48fF
C2943 divider_0/prescaler_0/tspc_1/Z1 vdda1 0.99fF
C2944 divider_0/prescaler_0/tspc_1/a_630_n680# vdda1 1.14fF **FLOATING
C2945 divider_0/prescaler_0/m1_2700_2190# vdda1 4.22fF **FLOATING
C2946 divider_0/prescaler_0/tspc_0/Z4 vdda1 0.86fF
C2947 divider_0/prescaler_0/Out vdda1 4.59fF
C2948 divider_0/prescaler_0/tspc_0/Z3 vdda1 2.26fF
C2949 divider_0/prescaler_0/tspc_0/Z2 vdda1 1.46fF
C2950 divider_0/prescaler_0/tspc_0/Z1 vdda1 0.99fF
C2951 divider_0/prescaler_0/tspc_0/a_630_n680# vdda1 1.16fF **FLOATING
C2952 divider_0/prescaler_0/tspc_0/a_740_n680# vdda1 2.11fF **FLOATING
C2953 divider_0/nor_1/Z1 vdda1 1.34fF
C2954 divider_0/nor_0/Z1 vdda1 1.34fF
C2955 divider_0/mc2 vdda1 5.29fF
C2956 ro_complete_buffered_0/tapered_buf_0/in vdda1 1.13fF
C2957 ro_complete_buffered_0/tapered_buf_0/a_n10_n140# vdda1 0.06fF **FLOATING
C2958 ro_complete_buffered_0/tapered_buf_0/a_210_n610# vdda1 619.27fF **FLOATING
C2959 ro_complete_buffered_0/tapered_buf_0/a_160_230# vdda1 0.15fF **FLOATING
C2960 ro_complete_buffered_0/tapered_buf_0/a_n10_230# vdda1 0.13fF **FLOATING
C2961 ro_complete_buffered_0/tapered_buf_0/a_4670_0# vdda1 252.41fF **FLOATING
C2962 ro_complete_buffered_0/tapered_buf_0/a_1650_0# vdda1 63.61fF **FLOATING
C2963 ro_complete_buffered_0/tapered_buf_0/a_580_0# vdda1 16.76fF **FLOATING
C2964 ro_complete_buffered_0/tapered_buf_0/a_160_n140# vdda1 4.09fF **FLOATING
C2965 ro_complete_buffered_0/tapered_buf_1/out vdda1 385.87fF
C2966 ro_complete_buffered_0/tapered_buf_1/a_n10_n140# vdda1 0.06fF **FLOATING
C2967 ro_complete_buffered_0/tapered_buf_1/a_210_n610# vdda1 592.97fF **FLOATING
C2968 ro_complete_buffered_0/tapered_buf_1/a_160_230# vdda1 0.15fF **FLOATING
C2969 ro_complete_buffered_0/tapered_buf_1/a_n10_230# vdda1 0.13fF **FLOATING
C2970 ro_complete_buffered_0/tapered_buf_1/a_4670_0# vdda1 252.41fF **FLOATING
C2971 ro_complete_buffered_0/tapered_buf_1/a_1650_0# vdda1 63.61fF **FLOATING
C2972 ro_complete_buffered_0/tapered_buf_1/a_580_0# vdda1 16.76fF **FLOATING
C2973 ro_complete_buffered_0/tapered_buf_1/a_160_n140# vdda1 4.09fF **FLOATING
C2974 ro_complete_buffered_0/ro_complete_0/cbank_2/v vdda1 16.53fF
C2975 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_5/vin vdda1 0.78fF
C2976 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_4/vin vdda1 1.50fF
C2977 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_2/vin vdda1 1.30fF
C2978 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_3/vin vdda1 0.56fF
C2979 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_1/vin vdda1 1.14fF
C2980 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_0/vin vdda1 1.02fF
C2981 ro_complete_buffered_0/tapered_buf_1/in vdda1 26.52fF
C2982 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_5/vin vdda1 0.78fF
C2983 ro_complete_buffered_0/ro_complete_0/a0 vdda1 416.45fF
C2984 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_4/vin vdda1 1.50fF
C2985 ro_complete_buffered_0/ro_complete_0/a1 vdda1 412.13fF
C2986 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_2/vin vdda1 1.30fF
C2987 ro_complete_buffered_0/ro_complete_0/a3 vdda1 402.70fF
C2988 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_3/vin vdda1 0.56fF
C2989 ro_complete_buffered_0/ro_complete_0/a2 vdda1 407.26fF
C2990 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_1/vin vdda1 1.14fF
C2991 ro_complete_buffered_0/ro_complete_0/a4 vdda1 398.93fF
C2992 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_0/vin vdda1 1.02fF
C2993 ro_complete_buffered_0/ro_complete_0/a5 vdda1 395.79fF
C2994 ro_complete_buffered_0/ro_complete_0/cbank_0/v vdda1 15.13fF
C2995 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_5/vin vdda1 0.78fF
C2996 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_4/vin vdda1 1.50fF
C2997 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_2/vin vdda1 1.30fF
C2998 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_3/vin vdda1 0.56fF
C2999 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_1/vin vdda1 1.14fF
C3000 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_0/vin vdda1 1.02fF
C3001 ro_complete_buffered_0/tapered_buf_7/in vdda1 1.13fF
C3002 ro_complete_buffered_0/tapered_buf_7/a_n10_n140# vdda1 0.06fF **FLOATING
C3003 ro_complete_buffered_0/tapered_buf_7/a_210_n610# vdda1 592.97fF **FLOATING
C3004 ro_complete_buffered_0/tapered_buf_7/a_160_230# vdda1 0.15fF **FLOATING
C3005 ro_complete_buffered_0/tapered_buf_7/a_n10_230# vdda1 0.13fF **FLOATING
C3006 ro_complete_buffered_0/tapered_buf_7/a_4670_0# vdda1 252.41fF **FLOATING
C3007 ro_complete_buffered_0/tapered_buf_7/a_1650_0# vdda1 63.61fF **FLOATING
C3008 ro_complete_buffered_0/tapered_buf_7/a_580_0# vdda1 16.76fF **FLOATING
C3009 ro_complete_buffered_0/tapered_buf_7/a_160_n140# vdda1 4.09fF **FLOATING
C3010 ro_complete_buffered_0/tapered_buf_6/in vdda1 1.13fF
C3011 ro_complete_buffered_0/tapered_buf_6/a_n10_n140# vdda1 0.06fF **FLOATING
C3012 ro_complete_buffered_0/tapered_buf_6/a_210_n610# vdda1 592.97fF **FLOATING
C3013 ro_complete_buffered_0/tapered_buf_6/a_160_230# vdda1 0.15fF **FLOATING
C3014 ro_complete_buffered_0/tapered_buf_6/a_n10_230# vdda1 0.13fF **FLOATING
C3015 ro_complete_buffered_0/tapered_buf_6/a_4670_0# vdda1 252.41fF **FLOATING
C3016 ro_complete_buffered_0/tapered_buf_6/a_1650_0# vdda1 63.61fF **FLOATING
C3017 ro_complete_buffered_0/tapered_buf_6/a_580_0# vdda1 16.76fF **FLOATING
C3018 ro_complete_buffered_0/tapered_buf_6/a_160_n140# vdda1 4.09fF **FLOATING
C3019 ro_complete_buffered_0/tapered_buf_5/in vdda1 1.13fF
C3020 ro_complete_buffered_0/tapered_buf_5/a_n10_n140# vdda1 0.06fF **FLOATING
C3021 ro_complete_buffered_0/tapered_buf_5/a_210_n610# vdda1 592.97fF **FLOATING
C3022 ro_complete_buffered_0/tapered_buf_5/a_160_230# vdda1 0.15fF **FLOATING
C3023 ro_complete_buffered_0/tapered_buf_5/a_n10_230# vdda1 0.13fF **FLOATING
C3024 ro_complete_buffered_0/tapered_buf_5/a_4670_0# vdda1 252.41fF **FLOATING
C3025 ro_complete_buffered_0/tapered_buf_5/a_1650_0# vdda1 63.61fF **FLOATING
C3026 ro_complete_buffered_0/tapered_buf_5/a_580_0# vdda1 16.76fF **FLOATING
C3027 ro_complete_buffered_0/tapered_buf_5/a_160_n140# vdda1 4.09fF **FLOATING
C3028 ro_complete_buffered_0/tapered_buf_4/in vdda1 1.13fF
C3029 ro_complete_buffered_0/tapered_buf_4/a_n10_n140# vdda1 0.06fF **FLOATING
C3030 ro_complete_buffered_0/tapered_buf_4/a_210_n610# vdda1 592.97fF **FLOATING
C3031 ro_complete_buffered_0/tapered_buf_4/a_160_230# vdda1 0.15fF **FLOATING
C3032 ro_complete_buffered_0/tapered_buf_4/a_n10_230# vdda1 0.13fF **FLOATING
C3033 ro_complete_buffered_0/tapered_buf_4/a_4670_0# vdda1 252.41fF **FLOATING
C3034 ro_complete_buffered_0/tapered_buf_4/a_1650_0# vdda1 63.61fF **FLOATING
C3035 ro_complete_buffered_0/tapered_buf_4/a_580_0# vdda1 16.76fF **FLOATING
C3036 ro_complete_buffered_0/tapered_buf_4/a_160_n140# vdda1 4.09fF **FLOATING
C3037 ro_complete_buffered_0/tapered_buf_3/in vdda1 1.13fF
C3038 ro_complete_buffered_0/tapered_buf_3/a_n10_n140# vdda1 0.06fF **FLOATING
C3039 ro_complete_buffered_0/tapered_buf_3/a_210_n610# vdda1 592.97fF **FLOATING
C3040 ro_complete_buffered_0/tapered_buf_3/a_160_230# vdda1 0.15fF **FLOATING
C3041 ro_complete_buffered_0/tapered_buf_3/a_n10_230# vdda1 0.13fF **FLOATING
C3042 ro_complete_buffered_0/tapered_buf_3/a_4670_0# vdda1 252.41fF **FLOATING
C3043 ro_complete_buffered_0/tapered_buf_3/a_1650_0# vdda1 63.61fF **FLOATING
C3044 ro_complete_buffered_0/tapered_buf_3/a_580_0# vdda1 16.76fF **FLOATING
C3045 ro_complete_buffered_0/tapered_buf_3/a_160_n140# vdda1 4.09fF **FLOATING
C3046 ro_complete_buffered_0/tapered_buf_2/in vdda1 1.13fF
C3047 ro_complete_buffered_0/tapered_buf_2/a_n10_n140# vdda1 0.06fF **FLOATING
C3048 ro_complete_buffered_0/tapered_buf_2/a_210_n610# vdda1 592.97fF **FLOATING
C3049 ro_complete_buffered_0/tapered_buf_2/a_160_230# vdda1 0.15fF **FLOATING
C3050 ro_complete_buffered_0/tapered_buf_2/a_n10_230# vdda1 0.13fF **FLOATING
C3051 ro_complete_buffered_0/tapered_buf_2/a_4670_0# vdda1 252.41fF **FLOATING
C3052 ro_complete_buffered_0/tapered_buf_2/a_1650_0# vdda1 63.61fF **FLOATING
C3053 ro_complete_buffered_0/tapered_buf_2/a_580_0# vdda1 16.76fF **FLOATING
C3054 ro_complete_buffered_0/tapered_buf_2/a_160_n140# vdda1 4.09fF **FLOATING
C3055 ro_complete_0/cbank_2/v vdda1 16.43fF
C3056 ro_complete_0/cbank_2/switch_5/vin vdda1 0.78fF
C3057 ro_complete_0/cbank_2/switch_4/vin vdda1 1.50fF
C3058 ro_complete_0/cbank_2/switch_2/vin vdda1 1.30fF
C3059 ro_complete_0/cbank_2/switch_3/vin vdda1 0.56fF
C3060 ro_complete_0/cbank_2/switch_1/vin vdda1 1.14fF
C3061 ro_complete_0/cbank_2/switch_0/vin vdda1 1.02fF
C3062 ro_complete_0/cbank_1/v vdda1 16.43fF
C3063 ro_complete_0/cbank_1/switch_5/vin vdda1 0.78fF
C3064 ro_complete_0/a0 vdda1 5.35fF
C3065 ro_complete_0/cbank_1/switch_4/vin vdda1 1.50fF
C3066 ro_complete_0/a1 vdda1 6.54fF
C3067 ro_complete_0/cbank_1/switch_2/vin vdda1 1.30fF
C3068 ro_complete_0/a3 vdda1 5.96fF
C3069 ro_complete_0/cbank_1/switch_3/vin vdda1 0.56fF
C3070 ro_complete_0/a2 vdda1 5.21fF
C3071 ro_complete_0/cbank_1/switch_1/vin vdda1 1.14fF
C3072 ro_complete_0/a4 vdda1 5.81fF
C3073 ro_complete_0/cbank_1/switch_0/vin vdda1 1.02fF
C3074 ro_complete_0/a5 vdda1 6.74fF
C3075 ro_complete_0/cbank_0/v vdda1 15.12fF
C3076 ro_complete_0/cbank_0/switch_5/vin vdda1 0.78fF
C3077 ro_complete_0/cbank_0/switch_4/vin vdda1 1.50fF
C3078 ro_complete_0/cbank_0/switch_2/vin vdda1 1.30fF
C3079 ro_complete_0/cbank_0/switch_3/vin vdda1 0.56fF
C3080 ro_complete_0/cbank_0/switch_1/vin vdda1 1.14fF
C3081 ro_complete_0/cbank_0/switch_0/vin vdda1 1.02fF
C3082 filter_buffered_0/v vdda1 391.91fF
C3083 filter_buffered_0/tapered_buf_0/a_n10_n140# vdda1 0.06fF **FLOATING
C3084 filter_buffered_0/tapered_buf_0/a_210_n610# vdda1 592.97fF **FLOATING
C3085 filter_buffered_0/tapered_buf_0/a_160_230# vdda1 0.15fF **FLOATING
C3086 filter_buffered_0/tapered_buf_0/a_n10_230# vdda1 0.13fF **FLOATING
C3087 filter_buffered_0/tapered_buf_0/a_4670_0# vdda1 252.41fF **FLOATING
C3088 filter_buffered_0/tapered_buf_0/a_1650_0# vdda1 63.61fF **FLOATING
C3089 filter_buffered_0/tapered_buf_0/a_580_0# vdda1 16.76fF **FLOATING
C3090 filter_buffered_0/tapered_buf_0/a_160_n140# vdda1 4.09fF **FLOATING
C3091 filter_buffered_0/tapered_buf_1/a_n10_n140# vdda1 0.06fF **FLOATING
C3092 filter_buffered_0/tapered_buf_1/a_210_n610# vdda1 592.97fF **FLOATING
C3093 filter_buffered_0/tapered_buf_1/a_160_230# vdda1 0.15fF **FLOATING
C3094 filter_buffered_0/tapered_buf_1/a_n10_230# vdda1 0.13fF **FLOATING
C3095 filter_buffered_0/tapered_buf_1/a_4670_0# vdda1 252.41fF **FLOATING
C3096 filter_buffered_0/tapered_buf_1/a_1650_0# vdda1 63.61fF **FLOATING
C3097 filter_buffered_0/tapered_buf_1/a_580_0# vdda1 16.76fF **FLOATING
C3098 filter_buffered_0/tapered_buf_1/a_160_n140# vdda1 4.09fF **FLOATING
C3099 filter_buffered_0/filter_0/v vdda1 476.54fF
C3100 filter_buffered_0/filter_0/a_4216_n5230# vdda1 418.47fF **FLOATING
C3101 filter_buffered_0/filter_0/a_4216_n2998# vdda1 1.03fF **FLOATING
C3102 cp_buffered_0/cp_0/down vdda1 397.14fF
C3103 cp_buffered_0/tapered_buf_0/in vdda1 1.13fF
C3104 cp_buffered_0/tapered_buf_0/a_n10_n140# vdda1 0.06fF **FLOATING
C3105 cp_buffered_0/tapered_buf_0/a_210_n610# vdda1 592.97fF **FLOATING
C3106 cp_buffered_0/tapered_buf_0/a_160_230# vdda1 0.15fF **FLOATING
C3107 cp_buffered_0/tapered_buf_0/a_n10_230# vdda1 0.13fF **FLOATING
C3108 cp_buffered_0/tapered_buf_0/a_4670_0# vdda1 252.41fF **FLOATING
C3109 cp_buffered_0/tapered_buf_0/a_1650_0# vdda1 63.61fF **FLOATING
C3110 cp_buffered_0/tapered_buf_0/a_580_0# vdda1 16.76fF **FLOATING
C3111 cp_buffered_0/tapered_buf_0/a_160_n140# vdda1 4.09fF **FLOATING
C3112 cp_buffered_0/cp_0/out vdda1 397.36fF
C3113 cp_buffered_0/tapered_buf_1/in vdda1 1.13fF
C3114 cp_buffered_0/tapered_buf_1/a_n10_n140# vdda1 0.06fF **FLOATING
C3115 cp_buffered_0/tapered_buf_1/a_210_n610# vdda1 592.97fF **FLOATING
C3116 cp_buffered_0/tapered_buf_1/a_160_230# vdda1 0.15fF **FLOATING
C3117 cp_buffered_0/tapered_buf_1/a_n10_230# vdda1 0.13fF **FLOATING
C3118 cp_buffered_0/tapered_buf_1/a_4670_0# vdda1 252.41fF **FLOATING
C3119 cp_buffered_0/tapered_buf_1/a_1650_0# vdda1 63.61fF **FLOATING
C3120 cp_buffered_0/tapered_buf_1/a_580_0# vdda1 16.76fF **FLOATING
C3121 cp_buffered_0/tapered_buf_1/a_160_n140# vdda1 4.09fF **FLOATING
C3122 cp_buffered_0/cp_0/upbar vdda1 393.41fF
C3123 cp_buffered_0/cp_0/a_7110_n2840# vdda1 0.17fF **FLOATING
C3124 cp_buffered_0/cp_0/a_3060_n2840# vdda1 1.71fF **FLOATING
C3125 cp_buffered_0/cp_0/a_7110_0# vdda1 0.17fF **FLOATING
C3126 cp_buffered_0/cp_0/a_6370_0# vdda1 0.40fF **FLOATING
C3127 cp_buffered_0/cp_0/a_3060_0# vdda1 1.65fF **FLOATING
C3128 cp_buffered_0/cp_0/a_1710_0# vdda1 5.76fF **FLOATING
C3129 cp_buffered_0/cp_0/a_1710_n2840# vdda1 5.24fF **FLOATING
C3130 cp_buffered_0/cp_0/a_10_n50# vdda1 3.19fF **FLOATING
C3131 cp_buffered_0/tapered_buf_2/in vdda1 1.13fF
C3132 cp_buffered_0/tapered_buf_2/a_n10_n140# vdda1 0.06fF **FLOATING
C3133 cp_buffered_0/tapered_buf_2/a_210_n610# vdda1 592.97fF **FLOATING
C3134 cp_buffered_0/tapered_buf_2/a_160_230# vdda1 0.15fF **FLOATING
C3135 cp_buffered_0/tapered_buf_2/a_n10_230# vdda1 0.13fF **FLOATING
C3136 cp_buffered_0/tapered_buf_2/a_4670_0# vdda1 252.41fF **FLOATING
C3137 cp_buffered_0/tapered_buf_2/a_1650_0# vdda1 63.61fF **FLOATING
C3138 cp_buffered_0/tapered_buf_2/a_580_0# vdda1 16.76fF **FLOATING
C3139 cp_buffered_0/tapered_buf_2/a_160_n140# vdda1 4.09fF **FLOATING
.ends
