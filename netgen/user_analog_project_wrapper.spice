* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[5] io_analog[6] io_analog[7]
+ io_analog[8] io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
C0 ro_complete_buffered_0/tapered_buf_7/in ro_complete_buffered_0/tapered_buf_7/in1 0.19fF
C1 divider_buffered_0/divider_0/tspc_1/Z3 divider_buffered_0/divider_0/tspc_1/a_630_n680# 0.05fF
C2 pd_buffered_0/tapered_buf_3/in4 pd_buffered_0/tapered_buf_3/in5 29.21fF
C3 pll_full_buffered1_0/pll_full_0/divider_0/nor_0/B pll_full_buffered1_0/pll_full_0/divider_0/and_0/B 0.29fF
C4 div_pd_buffered_0/pd_0/tspc_r_0/Qbar div_pd_buffered_0/pd_0/DOWN 0.02fF
C5 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered2_0/pll_full_0/divider_0/nor_1/A 0.15fF
C6 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/a0 0.09fF
C7 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_4/vin ro_divider_buffered_0/divider_0/clk 1.30fF
C8 pll_full_buffered1_0/pll_full_0/ref pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z3 0.65fF
C9 div_pd_buffered_0/divider_0/tspc_1/Z2 div_pd_buffered_0/divider_0/nor_1/A 0.15fF
C10 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C11 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C12 ro_divider_buffered_0/tapered_buf_3/in4 ro_divider_buffered_0/tapered_buf_3/in5 29.21fF
C13 ro_complete_buffered_0/tapered_buf_4/in1 ro_complete_buffered_0/tapered_buf_4/in2 0.37fF
C14 divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# divider_buffered_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C15 pll_full_buffered2_0/pll_full_0/divider_0/and_0/B pll_full_buffered2_0/pll_full_0/divider_0/and_0/Z1 0.07fF
C16 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C17 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C18 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z2 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C19 pll_full_buffered1_0/tapered_buf_0/in4 pll_full_buffered1_0/tapered_buf_0/in5 29.21fF
C20 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/A pll_full_buffered1_0/pll_full_0/divider_0/and_0/B 0.08fF
C21 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C22 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C23 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_buffered1_0/pll_full_0/vco 0.12fF
C24 ro_complete_buffered_0/tapered_buf_6/in5 ro_complete_buffered_0/ro_complete_0/a4 26.29fF
C25 ro_complete_buffered_0/tapered_buf_5/in5 ro_complete_buffered_0/ro_complete_0/a3 26.29fF
C26 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z3 divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# 0.33fF
C27 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Qbar pll_full_buffered1_0/pll_full_0/pd_0/DOWN 0.02fF
C28 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_buffered1_0/pll_full_0/pd_0/R 0.30fF
C29 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z1 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z3 0.06fF
C30 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_buffered2_0/pll_full_0/vco 0.12fF
C31 pll_full_buffered2_0/tapered_buf_5/in3 pll_full_buffered2_0/tapered_buf_5/in4 4.78fF
C32 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z1 divider_buffered_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C33 divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# divider_buffered_0/divider_0/clk 0.01fF
C34 div_pd_buffered_0/divider_0/and_0/out1 div_pd_buffered_0/divider_0/and_0/A 0.01fF
C35 div_pd_buffered_0/divider_0/tspc_0/Z3 div_pd_buffered_0/divider_0/tspc_0/Q 0.05fF
C36 pd_buffered_0/pd_0/tspc_r_0/Z4 pd_buffered_0/pd_0/tspc_r_1/Z4 0.02fF
C37 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/A pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Q 0.55fF
C38 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Q ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C39 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Q ro_divider_buffered_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C40 ro_divider_buffered_0/tapered_buf_0/in5 ro_divider_buffered_0/tapered_buf_0/in4 29.21fF
C41 pll_full_buffered2_0/tapered_buf_3/in pll_full_buffered2_0/pll_full_0/pd_0/R 0.36fF
C42 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z1 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z2 0.71fF
C43 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z3 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z4 0.20fF
C44 pd_buffered_0/tapered_buf_2/in3 pd_buffered_0/tapered_buf_2/in5 2.89fF
C45 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Q pll_full_buffered1_0/pll_full_0/divider_0/nor_0/B 0.22fF
C46 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C47 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C48 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C49 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_1/vin ro_complete_buffered_0/ro_complete_0/a4 0.09fF
C50 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_0/vin ro_complete_buffered_0/ro_complete_0/a5 0.09fF
C51 pll_full_buffered2_0/tapered_buf_4/in5 pll_full_buffered2_0/tapered_buf_4/in1 0.22fF
C52 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/a3 0.13fF
C53 cp_buffered_0/tapered_buf_2/in2 cp_buffered_0/tapered_buf_2/in3 1.27fF
C54 div_pd_buffered_0/tapered_buf_4/in3 div_pd_buffered_0/tapered_buf_4/in5 2.89fF
C55 ro_divider_buffered_0/tapered_buf_0/in5 ro_divider_buffered_0/tapered_buf_0/in3 2.89fF
C56 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z2 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C57 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C58 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C59 div_pd_buffered_0/divider_0/tspc_1/Z1 div_pd_buffered_0/divider_0/tspc_0/Q 0.01fF
C60 divider_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# divider_buffered_0/divider_0/clk 0.14fF
C61 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/nor_0/B 0.35fF
C62 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_buffered2_0/pll_full_0/vco 0.60fF
C63 ro_divider_buffered_0/tapered_buf_6/in1 ro_divider_buffered_0/tapered_buf_6/in2 0.37fF
C64 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/a1 0.14fF
C65 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C66 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/a3 0.09fF
C67 divider_buffered_0/divider_0/tspc_1/Q divider_buffered_0/divider_0/tspc_2/Z3 0.45fF
C68 divider_buffered_0/divider_0/tspc_0/a_630_n680# divider_buffered_0/divider_0/tspc_0/Z4 0.12fF
C69 ro_divider_buffered_0/tapered_buf_1/in3 ro_divider_buffered_0/tapered_buf_1/in2 1.27fF
C70 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Q pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C71 ro_complete_buffered_0/tapered_buf_6/in3 ro_complete_buffered_0/tapered_buf_6/in5 2.89fF
C72 ro_divider_buffered_0/divider_0/tspc_2/Z1 ro_divider_buffered_0/divider_0/tspc_2/Z4 0.00fF
C73 pll_full_buffered1_0/pll_full_0/divider_0/nor_0/B pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z2 0.40fF
C74 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_buffered1_0/pll_full_0/div 0.04fF
C75 ro_divider_buffered_0/divider_0/tspc_1/Z1 ro_divider_buffered_0/divider_0/tspc_1/Z3 0.06fF
C76 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_1/vin ro_divider_buffered_0/divider_0/clk 1.30fF
C77 div_pd_buffered_0/divider_0/nor_0/Z1 div_pd_buffered_0/divider_0/nor_1/B 0.18fF
C78 div_pd_buffered_0/divider_0/tspc_1/Z1 div_pd_buffered_0/divider_0/tspc_1/Z2 1.07fF
C79 divider_buffered_0/tapered_buf_0/in4 divider_buffered_0/tapered_buf_0/in3 4.78fF
C80 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z1 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z2 1.07fF
C81 pll_full_buffered2_0/pll_full_0/ro_complete_0/a1 pll_full_buffered2_0/pll_full_0/vco 0.11fF
C82 ro_divider_buffered_0/tapered_buf_7/in4 ro_divider_buffered_0/tapered_buf_7/in5 29.21fF
C83 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z2 divider_buffered_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C84 divider_buffered_0/divider_0/mc2 divider_buffered_0/divider_0/nor_0/B 0.15fF
C85 pll_full_buffered1_0/pll_full_0/ref pll_full_buffered1_0/pll_full_0/vco 0.55fF
C86 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C87 divider_buffered_0/divider_0/tspc_2/Z2 divider_buffered_0/divider_0/tspc_2/Z3 0.16fF
C88 divider_buffered_0/divider_0/nor_0/B divider_buffered_0/divider_0/tspc_2/Z4 0.22fF
C89 ro_divider_buffered_0/ro_complete_0/a4 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_0/vin 0.12fF
C90 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z1 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C91 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C92 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_2/vin ro_divider_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C93 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Q 0.04fF
C94 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z4 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z2 0.36fF
C95 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C96 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C97 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_buffered1_0/pll_full_0/vco 0.01fF
C98 div_pd_buffered_0/tapered_buf_3/in1 div_pd_buffered_0/tapered_buf_3/in2 0.37fF
C99 pll_full_buffered2_0/pll_full_0/ref pll_full_buffered2_0/pll_full_0/pd_0/R 0.61fF
C100 pll_full_buffered1_0/pll_full_0/divider_0/and_0/out1 pll_full_buffered1_0/pll_full_0/divider_0/and_0/Z1 0.36fF
C101 pll_full_buffered2_0/pll_full_0/ro_complete_0/a0 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C102 cp_buffered_0/tapered_buf_1/in4 cp_buffered_0/tapered_buf_1/in5 29.21fF
C103 cp_buffered_0/cp_0/upbar cp_buffered_0/cp_0/down 0.02fF
C104 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/R 0.51fF
C105 ro_divider_buffered_0/tapered_buf_1/in5 ro_divider_buffered_0/tapered_buf_1/in4 29.21fF
C106 pll_full_buffered1_0/pll_full_0/cp_0/upbar pll_full_buffered1_0/pll_full_0/pd_0/DOWN 0.02fF
C107 div_pd_buffered_0/tapered_buf_1/in1 div_pd_buffered_0/tapered_buf_1/in2 0.37fF
C108 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z3 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Q 0.45fF
C109 pd_buffered_0/pd_0/tspc_r_0/Z4 pd_buffered_0/pd_0/tspc_r_0/Z3 0.20fF
C110 pd_buffered_0/pd_0/tspc_r_0/z5 pd_buffered_0/pd_0/REF 0.04fF
C111 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C112 divider_buffered_0/divider_0/and_0/A divider_buffered_0/divider_0/and_0/B 0.18fF
C113 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/v pll_full_buffered1_0/pll_full_0/vco 1.36fF
C114 ro_complete_buffered_0/tapered_buf_1/in5 ro_complete_buffered_0/tapered_buf_1/in1 0.22fF
C115 ro_complete_buffered_0/tapered_buf_7/in5 ro_complete_buffered_0/ro_complete_0/a5 26.29fF
C116 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Qbar pll_full_buffered2_0/pll_full_0/pd_0/R 0.03fF
C117 io_clamp_high[0] io_analog[4] 0.53fF
C118 divider_buffered_0/divider_0/tspc_1/Z2 divider_buffered_0/divider_0/nor_1/A 0.15fF
C119 pll_full_buffered2_0/pll_full_0/ro_complete_0/a2 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C120 ro_divider_buffered_0/divider_0/prescaler_0/Out ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C121 ro_divider_buffered_0/ro_complete_0/a0 ro_divider_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C122 ro_complete_buffered_0/ro_complete_0/a0 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C123 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z2 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z3 0.25fF
C124 divider_buffered_0/divider_0/tspc_1/Z2 divider_buffered_0/divider_0/nor_1/B 0.30fF
C125 divider_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# divider_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C126 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_buffered2_0/pll_full_0/divider_0/and_0/OUT 0.06fF
C127 div_pd_buffered_0/divider_0/nor_1/Z1 div_pd_buffered_0/divider_0/nor_1/B 0.06fF
C128 ro_divider_buffered_0/divider_0/tspc_1/Z3 ro_divider_buffered_0/divider_0/tspc_1/Z4 0.65fF
C129 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C130 ro_divider_buffered_0/ro_complete_0/a0 ro_divider_buffered_0/divider_0/clk 0.05fF
C131 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# div_pd_buffered_0/divider_0/clk 0.14fF
C132 div_pd_buffered_0/divider_0/nor_0/Z1 div_pd_buffered_0/divider_0/and_0/B 0.78fF
C133 divider_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# divider_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C134 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z2 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z3 0.16fF
C135 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_buffered2_0/pll_full_0/vco 0.12fF
C136 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z2 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C137 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 divider_buffered_0/divider_0/prescaler_0/Out 0.05fF
C138 divider_buffered_0/tapered_buf_1/in2 divider_buffered_0/tapered_buf_1/in1 0.37fF
C139 divider_buffered_0/divider_0/prescaler_0/tspc_2/D divider_buffered_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C140 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/A pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/a_630_n680# 0.35fF
C141 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C142 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C143 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_5/vin ro_divider_buffered_0/ro_complete_0/a0 0.09fF
C144 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/a5 2.39fF
C145 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_0/vin ro_complete_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C146 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/z5 pll_full_buffered2_0/pll_full_0/pd_0/UP 0.03fF
C147 pll_full_buffered2_0/tapered_buf_0/in5 pll_full_buffered2_0/tapered_buf_0/in1 0.22fF
C148 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C149 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z1 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C150 pll_full_buffered1_0/tapered_buf_2/in2 pll_full_buffered1_0/tapered_buf_2/in5 0.84fF
C151 pll_full_buffered1_0/tapered_buf_2/in3 pll_full_buffered1_0/tapered_buf_2/in4 4.78fF
C152 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z1 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z4 0.00fF
C153 filter_buffered_0/tapered_buf_0/in5 filter_buffered_0/v 26.29fF
C154 div_pd_buffered_0/divider_0/tspc_0/Z1 div_pd_buffered_0/divider_0/nor_1/A 0.03fF
C155 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C156 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/tspc_0/Q 0.01fF
C157 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/and_0/A 0.01fF
C158 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_3/vin ro_divider_buffered_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C159 pll_full_buffered1_0/pll_full_0/ro_complete_0/a3 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C160 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C161 divider_buffered_0/divider_0/prescaler_0/tspc_2/D divider_buffered_0/divider_0/clk 0.26fF
C162 ashish_0/vop ashish_0/cm 3.87fF
C163 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C164 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C165 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_buffered1_0/pll_full_0/vco 1.46fF
C166 ro_complete_buffered_0/tapered_buf_7/in1 ro_complete_buffered_0/tapered_buf_7/in2 0.37fF
C167 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z3 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/z5 0.11fF
C168 pll_full_buffered2_0/pll_full_0/pd_0/and_pd_0/Z1 pll_full_buffered2_0/pll_full_0/pd_0/UP 0.06fF
C169 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C170 pll_full_buffered2_0/pll_full_0/ro_complete_0/a2 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C171 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z3 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Qbar1 0.38fF
C172 divider_buffered_0/tapered_buf_0/in5 divider_buffered_0/tapered_buf_0/in2 0.84fF
C173 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C174 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_buffered2_0/pll_full_0/vco 0.14fF
C175 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/clk 0.04fF
C176 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/nor_1/A 0.01fF
C177 div_pd_buffered_0/divider_0/nor_1/Z1 div_pd_buffered_0/divider_0/and_0/B 0.18fF
C178 div_pd_buffered_0/divider_0/tspc_1/Z2 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# 0.01fF
C179 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C180 div_pd_buffered_0/divider_0/nor_0/B div_pd_buffered_0/divider_0/tspc_2/Z1 0.03fF
C181 div_pd_buffered_0/divider_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/tspc_2/Z3 0.05fF
C182 divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C183 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C184 pd_buffered_0/pd_0/tspc_r_0/Qbar pd_buffered_0/pd_0/and_pd_0/Z1 0.02fF
C185 pd_buffered_0/pd_0/tspc_r_1/Qbar1 pd_buffered_0/pd_0/tspc_r_1/Qbar 0.01fF
C186 pll_full_buffered1_0/pll_full_0/ro_complete_0/a4 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C187 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_buffered1_0/pll_full_0/div 0.12fF
C188 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z3 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z4 0.65fF
C189 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C190 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/tspc_r_0/Z1 0.17fF
C191 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C192 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C193 pll_full_buffered2_0/tapered_buf_3/in5 pll_full_buffered2_0/tapered_buf_3/in3 2.89fF
C194 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z4 divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# 0.08fF
C195 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/A pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z2 0.15fF
C196 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C197 filter_buffered_0/filter_0/v filter_buffered_0/v 0.54fF
C198 div_pd_buffered_0/pd_0/tspc_r_1/Z4 div_pd_buffered_0/pd_0/tspc_r_1/z5 0.04fF
C199 divider_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C200 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Q pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C201 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z1 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C202 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/tspc_1/Z4 0.02fF
C203 div_pd_buffered_0/divider_0/tspc_0/Z1 div_pd_buffered_0/divider_0/tspc_0/Z3 0.06fF
C204 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z3 divider_buffered_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C205 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Q ro_divider_buffered_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C206 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z2 ro_divider_buffered_0/divider_0/clk 0.11fF
C207 pd_buffered_0/pd_0/DOWN pd_buffered_0/pd_0/tspc_r_1/z5 0.03fF
C208 pd_buffered_0/pd_0/REF pd_buffered_0/pd_0/R 0.61fF
C209 pd_buffered_0/tapered_buf_2/in1 pd_buffered_0/tapered_buf_2/in2 0.37fF
C210 pll_full_buffered1_0/pll_full_0/filter_0/a_4216_n5230# pll_full_buffered1_0/pll_full_0/vco 1.58fF
C211 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/B pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z1 0.03fF
C212 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C213 ro_divider_buffered_0/divider_0/nor_1/Z1 ro_divider_buffered_0/divider_0/nor_1/B 0.06fF
C214 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Q pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z2 0.14fF
C215 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C216 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_buffered1_0/pll_full_0/vco 0.11fF
C217 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/z5 0.20fF
C218 cp_buffered_0/tapered_buf_2/in2 cp_buffered_0/tapered_buf_2/in5 0.84fF
C219 cp_buffered_0/tapered_buf_2/in3 cp_buffered_0/tapered_buf_2/in4 4.78fF
C220 pd_buffered_0/tapered_buf_0/in5 pd_buffered_0/tapered_buf_0/in2 0.84fF
C221 pd_buffered_0/tapered_buf_0/in4 pd_buffered_0/tapered_buf_0/in3 4.78fF
C222 ro_complete_buffered_0/tapered_buf_1/in ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.36fF
C223 divider_buffered_0/divider_0/tspc_0/Z1 divider_buffered_0/divider_0/nor_1/A 0.03fF
C224 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z4 divider_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.01fF
C225 pll_full_buffered2_0/tapered_buf_2/in5 pll_full_buffered2_0/tapered_buf_2/in3 2.89fF
C226 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z2 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/B 0.30fF
C227 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C228 div_pd_buffered_0/pd_0/and_pd_0/Out1 div_pd_buffered_0/pd_0/UP 0.33fF
C229 pll_full_buffered1_0/pll_full_0/pd_0/DOWN pll_full_buffered1_0/pll_full_0/cp_0/a_1710_0# 0.32fF
C230 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z4 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C231 divider_buffered_0/divider_0/nor_1/A divider_buffered_0/divider_0/tspc_0/Q 0.55fF
C232 pll_full_buffered2_0/pll_full_0/divider_0/and_0/OUT pll_full_buffered2_0/pll_full_0/divider_0/and_0/Z1 0.04fF
C233 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z2 0.01fF
C234 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_buffered2_0/pll_full_0/vco 0.05fF
C235 ro_divider_buffered_0/tapered_buf_6/in2 ro_divider_buffered_0/tapered_buf_6/in3 1.27fF
C236 div_pd_buffered_0/divider_0/tspc_1/Z3 div_pd_buffered_0/divider_0/tspc_0/Q 0.45fF
C237 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C238 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_3/vin ro_divider_buffered_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C239 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/a1 0.14fF
C240 divider_buffered_0/divider_0/tspc_1/Q divider_buffered_0/divider_0/tspc_2/Z4 0.15fF
C241 divider_buffered_0/divider_0/nor_1/B divider_buffered_0/divider_0/tspc_0/Q 0.22fF
C242 ro_divider_buffered_0/divider_0/tspc_2/Z3 ro_divider_buffered_0/divider_0/tspc_2/Z4 0.65fF
C243 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Q pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/a_630_n680# 0.04fF
C244 ro_complete_buffered_0/tapered_buf_4/in5 ro_complete_buffered_0/ro_complete_0/a2 26.29fF
C245 ro_divider_buffered_0/divider_0/tspc_0/Q ro_divider_buffered_0/divider_0/tspc_1/Z2 0.14fF
C246 pll_full_buffered2_0/pll_full_0/pd_0/and_pd_0/Out1 pll_full_buffered2_0/pll_full_0/pd_0/and_pd_0/Z1 0.18fF
C247 pll_full_buffered1_0/pll_full_0/divider_0/nor_0/B pll_full_buffered1_0/pll_full_0/div 0.27fF
C248 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z1 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z3 0.06fF
C249 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C250 div_pd_buffered_0/pd_0/tspc_r_0/Z2 div_pd_buffered_0/pd_0/tspc_r_0/Z4 0.14fF
C251 DIGITAL_BUFFER_v1_0/in1 DIGITAL_BUFFER_v1_0/in3 0.38fF
C252 div_pd_buffered_0/divider_0/tspc_1/Z2 div_pd_buffered_0/divider_0/tspc_1/Z3 0.16fF
C253 div_pd_buffered_0/divider_0/tspc_0/Z1 div_pd_buffered_0/divider_0/tspc_0/Z2 1.07fF
C254 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C255 pll_full_buffered1_0/pll_full_0/pd_0/and_pd_0/Out1 pll_full_buffered1_0/pll_full_0/pd_0/UP 0.33fF
C256 pll_full_buffered2_0/pll_full_0/divider_0/and_0/out1 pll_full_buffered2_0/pll_full_0/divider_0/and_0/B 0.18fF
C257 ro_divider_buffered_0/tapered_buf_3/in5 ro_divider_buffered_0/ro_complete_0/a5 26.29fF
C258 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z2 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C259 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_4/vin ro_divider_buffered_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C260 pd_buffered_0/pd_0/tspc_r_0/z5 pd_buffered_0/pd_0/tspc_r_0/Qbar1 0.20fF
C261 pd_buffered_0/tapered_buf_3/in2 pd_buffered_0/tapered_buf_3/in5 0.84fF
C262 pd_buffered_0/tapered_buf_3/in3 pd_buffered_0/tapered_buf_3/in4 4.78fF
C263 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.21fF
C264 pll_full_buffered1_0/pll_full_0/ro_complete_0/a5 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C265 divider_buffered_0/divider_0/tspc_2/Z2 divider_buffered_0/divider_0/tspc_2/Z4 0.36fF
C266 divider_buffered_0/divider_0/tspc_2/Z3 divider_buffered_0/divider_0/Out 0.05fF
C267 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_buffered2_0/pll_full_0/pd_0/R 0.30fF
C268 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C269 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z2 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C270 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_2/vin ro_complete_buffered_0/tapered_buf_1/in 1.30fF
C271 cp_buffered_0/tapered_buf_1/in5 cp_buffered_0/cp_0/out 26.29fF
C272 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/tspc_r_1/Z4 0.02fF
C273 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/pd_0/tspc_r_1/Qbar 0.21fF
C274 div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 div_pd_buffered_0/pd_0/R 0.01fF
C275 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C276 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z2 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z4 0.14fF
C277 divider_buffered_0/divider_0/nor_1/A divider_buffered_0/divider_0/tspc_0/Z3 0.38fF
C278 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/nor_0/B 0.00fF
C279 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C280 ro_divider_buffered_0/tapered_buf_4/in1 ro_divider_buffered_0/tapered_buf_4/in5 0.22fF
C281 div_pd_buffered_0/divider_0/tspc_1/Z1 div_pd_buffered_0/divider_0/tspc_1/Z4 0.00fF
C282 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C283 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z1 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C284 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z1 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z2 0.71fF
C285 pd_buffered_0/pd_0/DIV pd_buffered_0/pd_0/tspc_r_1/Z2 0.19fF
C286 pll_full_buffered1_0/tapered_buf_1/in5 pll_full_buffered1_0/tapered_buf_1/in2 0.84fF
C287 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C288 pll_full_buffered1_0/pll_full_0/ro_complete_0/a1 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C289 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C290 ashish_0/von ashish_0/b 4.11fF
C291 pll_full_buffered2_0/pll_full_0/ro_complete_0/a2 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C292 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/a4 0.09fF
C293 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/a5 0.09fF
C294 ro_complete_buffered_0/ro_complete_0/a0 ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C295 filter_buffered_0/tapered_buf_1/in3 filter_buffered_0/tapered_buf_1/in4 4.78fF
C296 div_pd_buffered_0/divider_0/tspc_0/Z1 div_pd_buffered_0/divider_0/tspc_0/Z4 0.00fF
C297 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/A pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z1 0.03fF
C298 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C299 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C300 pd_buffered_0/pd_0/tspc_r_0/Z2 pd_buffered_0/pd_0/tspc_r_0/Z4 0.14fF
C301 pll_full_buffered1_0/pll_full_0/pd_0/DOWN pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Qbar 0.21fF
C302 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_buffered1_0/pll_full_0/pd_0/R 0.01fF
C303 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 ro_divider_buffered_0/divider_0/clk 0.64fF
C304 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/clk 0.01fF
C305 divider_buffered_0/divider_0/nor_1/B divider_buffered_0/divider_0/nor_0/B 0.47fF
C306 divider_buffered_0/divider_0/and_0/OUT divider_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C307 pll_full_buffered2_0/tapered_buf_3/in3 pll_full_buffered2_0/tapered_buf_3/in2 1.27fF
C308 ro_divider_buffered_0/divider_0/and_0/OUT ro_divider_buffered_0/divider_0/and_0/B 0.01fF
C309 pd_buffered_0/pd_0/DIV pd_buffered_0/pd_0/tspc_r_1/z5 0.04fF
C310 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/A pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z4 0.21fF
C311 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C312 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C313 pll_full_buffered1_0/pll_full_0/divider_0/nor_0/Z1 pll_full_buffered1_0/pll_full_0/divider_0/nor_0/B 0.06fF
C314 ro_divider_buffered_0/ro_complete_0/a2 ro_divider_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C315 divider_buffered_0/divider_0/tspc_1/Z1 divider_buffered_0/divider_0/tspc_1/Z3 0.06fF
C316 pll_full_buffered1_0/pll_full_0/divider_0/and_0/OUT pll_full_buffered1_0/pll_full_0/divider_0/and_0/B 0.01fF
C317 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_3/vin ro_complete_buffered_0/ro_complete_0/a1 0.14fF
C318 divider_buffered_0/tapered_buf_2/in5 divider_buffered_0/tapered_buf_2/in4 29.21fF
C319 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/Out 0.05fF
C320 cp_buffered_0/cp_0/a_1710_n2840# cp_buffered_0/cp_0/out 0.61fF
C321 divider_buffered_0/tapered_buf_2/in1 divider_buffered_0/tapered_buf_2/in5 0.22fF
C322 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z2 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z4 0.14fF
C323 pll_full_buffered2_0/tapered_buf_3/in5 pll_full_buffered2_0/tapered_buf_3/in2 0.84fF
C324 pll_full_buffered2_0/tapered_buf_2/in2 pll_full_buffered2_0/tapered_buf_2/in1 0.37fF
C325 ro_divider_buffered_0/ro_complete_0/a2 ro_divider_buffered_0/divider_0/clk 0.05fF
C326 pll_full_buffered1_0/tapered_buf_2/in4 pll_full_buffered1_0/tapered_buf_2/in5 29.21fF
C327 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C328 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C329 divider_buffered_0/divider_0/tspc_1/a_630_n680# divider_buffered_0/divider_0/tspc_1/Z4 0.12fF
C330 divider_buffered_0/divider_0/tspc_0/Z2 divider_buffered_0/divider_0/tspc_0/Z4 0.36fF
C331 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z3 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z4 0.65fF
C332 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C333 pll_full_buffered2_0/pll_full_0/ro_complete_0/a5 pll_full_buffered2_0/pll_full_0/vco 0.15fF
C334 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z3 ro_divider_buffered_0/divider_0/clk 0.45fF
C335 div_pd_buffered_0/divider_0/tspc_1/Q div_pd_buffered_0/divider_0/tspc_2/Z1 0.01fF
C336 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/tspc_0/Q 0.22fF
C337 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/a0 0.13fF
C338 ro_divider_buffered_0/ro_complete_0/a4 ro_divider_buffered_0/ro_complete_0/a3 2.04fF
C339 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C340 pll_full_buffered1_0/tapered_buf_0/in1 pll_full_buffered1_0/tapered_buf_0/in5 0.22fF
C341 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C342 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C343 ro_complete_buffered_0/tapered_buf_7/in2 ro_complete_buffered_0/tapered_buf_7/in3 1.27fF
C344 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C345 divider_buffered_0/tapered_buf_0/in4 divider_buffered_0/tapered_buf_0/in5 29.21fF
C346 pll_full_buffered2_0/tapered_buf_0/in5 pll_full_buffered2_0/tapered_buf_0/in3 2.89fF
C347 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C348 filter_buffered_0/filter_0/v filter_buffered_0/filter_0/a_4216_n2998# 0.31fF
C349 div_pd_buffered_0/pd_0/tspc_r_0/Z2 div_pd_buffered_0/pd_0/R 0.21fF
C350 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_0/vin ro_divider_buffered_0/divider_0/clk 1.43fF
C351 pll_full_buffered2_0/tapered_buf_4/in5 pll_full_buffered2_0/tapered_buf_4/out 26.29fF
C352 pll_full_buffered1_0/pll_full_0/ref pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z1 0.17fF
C353 div_pd_buffered_0/divider_0/tspc_1/Z2 div_pd_buffered_0/divider_0/nor_1/B 0.30fF
C354 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z3 divider_buffered_0/divider_0/clk 0.45fF
C355 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/A pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z3 0.38fF
C356 ro_divider_buffered_0/tapered_buf_8/in1 ro_divider_buffered_0/tapered_buf_8/in5 0.22fF
C357 div_pd_buffered_0/divider_0/tspc_2/Z1 div_pd_buffered_0/divider_0/tspc_2/Z2 1.07fF
C358 div_pd_buffered_0/divider_0/nor_0/B div_pd_buffered_0/divider_0/tspc_2/Z3 0.38fF
C359 div_pd_buffered_0/divider_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/tspc_2/Z4 0.12fF
C360 divider_buffered_0/divider_0/mc2 divider_buffered_0/divider_0/and_0/B 0.20fF
C361 pd_buffered_0/pd_0/DOWN pd_buffered_0/pd_0/R 0.36fF
C362 pd_buffered_0/pd_0/tspc_r_1/Z1 pd_buffered_0/pd_0/tspc_r_1/Z2 0.71fF
C363 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z3 0.45fF
C364 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.19fF
C365 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z4 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C366 pd_buffered_0/pd_0/tspc_r_0/Qbar1 pd_buffered_0/pd_0/R 0.30fF
C367 pll_full_buffered1_0/tapered_buf_1/in2 pll_full_buffered1_0/tapered_buf_1/in3 1.27fF
C368 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_buffered1_0/pll_full_0/vco 0.01fF
C369 DIGITAL_BUFFER_v1_0/in5 DIGITAL_BUFFER_v1_0/out 26.29fF
C370 ro_complete_buffered_0/tapered_buf_0/in3 ro_complete_buffered_0/tapered_buf_0/in2 1.27fF
C371 cp_buffered_0/cp_0/a_1710_n2840# cp_buffered_0/cp_0/a_1710_0# 0.83fF
C372 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/tspc_r_0/Z2 0.25fF
C373 ro_complete_buffered_0/ro_complete_0/a3 ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C374 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/A pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.01fF
C375 pll_full_buffered2_0/pll_full_0/ro_complete_0/a0 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C376 cp_buffered_0/tapered_buf_0/in1 cp_buffered_0/tapered_buf_0/in5 0.22fF
C377 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/pd_0/and_pd_0/Z1 0.07fF
C378 ro_divider_buffered_0/tapered_buf_5/in ro_divider_buffered_0/tapered_buf_5/in1 0.19fF
C379 pd_buffered_0/tapered_buf_3/in pd_buffered_0/tapered_buf_3/in1 0.19fF
C380 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z2 pll_full_buffered1_0/pll_full_0/pd_0/R 0.21fF
C381 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/tspc_1/Z4 0.12fF
C382 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C383 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/clk 0.64fF
C384 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Q pll_full_buffered2_0/pll_full_0/divider_0/nor_0/B 0.22fF
C385 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C386 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_buffered2_0/pll_full_0/vco 0.01fF
C387 ro_complete_buffered_0/tapered_buf_3/in4 ro_complete_buffered_0/tapered_buf_3/in5 29.21fF
C388 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z4 divider_buffered_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C389 div_pd_buffered_0/divider_0/and_0/out1 div_pd_buffered_0/divider_0/and_0/Z1 0.36fF
C390 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C391 ro_complete_buffered_0/tapered_buf_5/in1 ro_complete_buffered_0/tapered_buf_5/in5 0.22fF
C392 ro_divider_buffered_0/tapered_buf_0/in2 ro_divider_buffered_0/tapered_buf_0/in3 1.27fF
C393 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/D ro_divider_buffered_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C394 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C395 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C396 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C397 cp_buffered_0/tapered_buf_2/in4 cp_buffered_0/tapered_buf_2/in5 29.21fF
C398 pll_full_buffered2_0/pll_full_0/cp_0/upbar pll_full_buffered2_0/tapered_buf_3/in 5.03fF
C399 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_divider_buffered_0/divider_0/clk 0.14fF
C400 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/A pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z2 0.23fF
C401 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C402 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_buffered2_0/pll_full_0/vco 1.46fF
C403 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C404 divider_buffered_0/tapered_buf_0/in divider_buffered_0/tapered_buf_0/in1 0.19fF
C405 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 divider_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.33fF
C406 ro_divider_buffered_0/tapered_buf_6/in2 ro_divider_buffered_0/tapered_buf_6/in5 0.84fF
C407 ro_divider_buffered_0/tapered_buf_6/in3 ro_divider_buffered_0/tapered_buf_6/in4 4.78fF
C408 pll_full_buffered1_0/pll_full_0/pd_0/DOWN pll_full_buffered1_0/pll_full_0/pd_0/and_pd_0/Z1 0.07fF
C409 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/tspc_0/Q 0.04fF
C410 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C411 pll_full_buffered2_0/tapered_buf_1/in5 pll_full_buffered2_0/tapered_buf_1/in4 29.21fF
C412 pll_full_buffered2_0/pll_full_0/divider_0/nor_0/B pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z2 0.40fF
C413 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_buffered2_0/pll_full_0/div 0.04fF
C414 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_buffered2_0/pll_full_0/vco 0.29fF
C415 pll_full_buffered1_0/tapered_buf_1/in1 pll_full_buffered1_0/tapered_buf_1/in 0.19fF
C416 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C417 pll_full_buffered1_0/pll_full_0/ro_complete_0/a4 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C418 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C419 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z3 divider_buffered_0/divider_0/clk 0.45fF
C420 pll_full_buffered1_0/pll_full_0/divider_0/nor_0/Z1 pll_full_buffered1_0/pll_full_0/divider_0/and_0/B 0.78fF
C421 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_buffered1_0/pll_full_0/vco 1.46fF
C422 ro_complete_buffered_0/ro_complete_0/a3 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_2/vin 0.21fF
C423 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z1 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z4 0.00fF
C424 pll_full_buffered2_0/pll_full_0/cp_0/upbar pll_full_buffered2_0/tapered_buf_4/in 0.05fF
C425 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.05fF
C426 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z2 pll_full_buffered2_0/pll_full_0/pd_0/R 0.21fF
C427 divider_buffered_0/divider_0/tspc_1/Z2 divider_buffered_0/divider_0/tspc_0/Q 0.14fF
C428 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Q 0.04fF
C429 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C430 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/v pll_full_buffered2_0/pll_full_0/vco 1.27fF
C431 pll_full_buffered2_0/tapered_buf_4/in2 pll_full_buffered2_0/tapered_buf_4/in5 0.84fF
C432 divider_buffered_0/divider_0/mc2 divider_buffered_0/tapered_buf_0/in5 26.29fF
C433 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/clk 0.04fF
C434 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z2 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C435 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C436 ro_divider_buffered_0/ro_complete_0/a5 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C437 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_4/vin ro_divider_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C438 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C439 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_4/vin ro_complete_buffered_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C440 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 ro_divider_buffered_0/divider_0/prescaler_0/Out 0.05fF
C441 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/z5 pll_full_buffered2_0/pll_full_0/div 0.04fF
C442 div_pd_buffered_0/tapered_buf_0/in3 div_pd_buffered_0/tapered_buf_0/in4 4.78fF
C443 div_pd_buffered_0/pd_0/tspc_r_0/Qbar div_pd_buffered_0/pd_0/and_pd_0/Z1 0.02fF
C444 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/tspc_r_1/z5 0.11fF
C445 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/B pll_full_buffered2_0/pll_full_0/divider_0/nor_0/B 0.47fF
C446 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C447 ro_divider_buffered_0/tapered_buf_4/in3 ro_divider_buffered_0/tapered_buf_4/in5 2.89fF
C448 pd_buffered_0/tapered_buf_3/in2 pd_buffered_0/tapered_buf_3/in1 0.37fF
C449 div_pd_buffered_0/divider_0/tspc_1/Z3 div_pd_buffered_0/divider_0/tspc_1/Z4 0.65fF
C450 pd_buffered_0/pd_0/REF pd_buffered_0/pd_0/tspc_r_0/Z3 0.65fF
C451 divider_buffered_0/divider_0/nor_1/B divider_buffered_0/divider_0/tspc_1/Q 0.51fF
C452 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z1 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C453 pd_buffered_0/pd_0/DIV pd_buffered_0/pd_0/R 0.51fF
C454 ro_complete_buffered_0/tapered_buf_3/in2 ro_complete_buffered_0/tapered_buf_3/in3 1.27fF
C455 divider_buffered_0/divider_0/and_0/B divider_buffered_0/divider_0/and_0/Z1 0.07fF
C456 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C457 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z3 pll_full_buffered2_0/tapered_buf_3/in 0.03fF
C458 ro_divider_buffered_0/divider_0/prescaler_0/Out ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C459 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_2/vin ro_divider_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C460 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z1 divider_buffered_0/divider_0/prescaler_0/Out 0.08fF
C461 divider_buffered_0/tapered_buf_2/in5 divider_buffered_0/divider_0/clk 26.29fF
C462 filter_buffered_0/tapered_buf_1/in4 filter_buffered_0/tapered_buf_1/in5 29.21fF
C463 div_pd_buffered_0/pd_0/R div_pd_buffered_0/pd_0/UP 0.45fF
C464 pll_full_buffered2_0/pll_full_0/divider_0/and_0/OUT pll_full_buffered2_0/pll_full_0/divider_0/and_0/out1 0.31fF
C465 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z4 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Q 0.15fF
C466 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z3 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C467 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Qbar pll_full_buffered1_0/pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C468 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z3 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/z5 0.11fF
C469 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C470 divider_buffered_0/tapered_buf_1/in3 divider_buffered_0/tapered_buf_1/in4 4.78fF
C471 ro_divider_buffered_0/ro_complete_0/a2 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C472 pll_full_buffered1_0/pll_full_0/ro_complete_0/a4 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C473 ro_complete_buffered_0/tapered_buf_4/in1 ro_complete_buffered_0/tapered_buf_4/in5 0.22fF
C474 divider_buffered_0/divider_0/nor_1/B divider_buffered_0/divider_0/tspc_2/Z2 0.20fF
C475 divider_buffered_0/divider_0/nor_1/Z1 divider_buffered_0/divider_0/and_0/B 0.18fF
C476 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C477 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C478 ro_complete_buffered_0/tapered_buf_6/in ro_complete_buffered_0/tapered_buf_6/in1 0.19fF
C479 ro_divider_buffered_0/tapered_buf_1/in2 ro_divider_buffered_0/tapered_buf_1/in5 0.84fF
C480 ashish_0/cm ashish_0/b 0.27fF
C481 ashish_0/von ashish_0/a 8.93fF
C482 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_3/vin ro_complete_buffered_0/ro_complete_0/a1 0.14fF
C483 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C484 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_2/vin ro_complete_buffered_0/ro_complete_0/a3 0.09fF
C485 pll_full_buffered2_0/pll_full_0/pd_0/R pll_full_buffered2_0/pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C486 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/UP 0.03fF
C487 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C488 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z2 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z1 1.07fF
C489 pll_full_buffered2_0/pll_full_0/cp_0/vbias pll_full_buffered2_0/pll_full_0/cp_0/a_10_n50# 0.19fF
C490 ro_divider_buffered_0/divider_0/nor_1/Z1 ro_divider_buffered_0/divider_0/and_0/B 0.18fF
C491 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z3 divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C492 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/nor_1/B 0.35fF
C493 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_buffered2_0/pll_full_0/vco 0.11fF
C494 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/nor_1/A 0.15fF
C495 pll_full_buffered1_0/pll_full_0/pd_0/R pll_full_buffered1_0/pll_full_0/pd_0/UP 0.45fF
C496 pll_full_buffered2_0/pll_full_0/divider_0/nor_0/B pll_full_buffered2_0/pll_full_0/divider_0/and_0/B 0.29fF
C497 ro_divider_buffered_0/divider_0/mc2 ro_divider_buffered_0/divider_0/and_0/A 0.16fF
C498 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z4 ro_divider_buffered_0/divider_0/clk 0.12fF
C499 div_pd_buffered_0/divider_0/tspc_1/Q div_pd_buffered_0/divider_0/tspc_2/Z3 0.45fF
C500 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/and_0/A 0.26fF
C501 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_1/vin ro_divider_buffered_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C502 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C503 ro_complete_buffered_0/tapered_buf_3/in5 ro_complete_buffered_0/tapered_buf_3/in3 2.89fF
C504 divider_buffered_0/divider_0/tspc_2/a_630_n680# divider_buffered_0/divider_0/nor_0/B 0.35fF
C505 divider_buffered_0/divider_0/prescaler_0/tspc_1/Q divider_buffered_0/divider_0/clk 0.60fF
C506 ro_divider_buffered_0/divider_0/and_0/out1 ro_divider_buffered_0/divider_0/and_0/A 0.01fF
C507 ro_divider_buffered_0/divider_0/tspc_0/Z1 ro_divider_buffered_0/divider_0/tspc_0/Z2 1.07fF
C508 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z4 0.12fF
C509 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_buffered1_0/pll_full_0/divider_0/and_0/OUT 0.06fF
C510 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C511 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C512 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_buffered1_0/pll_full_0/vco 1.46fF
C513 ro_complete_buffered_0/tapered_buf_7/in2 ro_complete_buffered_0/tapered_buf_7/in5 0.84fF
C514 ro_complete_buffered_0/tapered_buf_7/in3 ro_complete_buffered_0/tapered_buf_7/in4 4.78fF
C515 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_1/vin ro_complete_buffered_0/tapered_buf_1/in 1.30fF
C516 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_5/vin ro_complete_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C517 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z3 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C518 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/tspc_r_1/Z3 0.65fF
C519 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/Z1 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/B 0.06fF
C520 pd_buffered_0/tapered_buf_3/in2 pd_buffered_0/tapered_buf_3/in3 1.27fF
C521 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z3 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z2 0.25fF
C522 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z4 divider_buffered_0/divider_0/clk 0.12fF
C523 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_buffered2_0/pll_full_0/divider_0/and_0/OUT 0.05fF
C524 ro_divider_buffered_0/divider_0/prescaler_0/Out ro_divider_buffered_0/divider_0/nor_1/A 0.15fF
C525 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/and_0/A 0.16fF
C526 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/divider_0/tspc_2/Z3 0.05fF
C527 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C528 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C529 ro_divider_buffered_0/tapered_buf_8/in3 ro_divider_buffered_0/tapered_buf_8/in5 2.89fF
C530 ro_divider_buffered_0/tapered_buf_6/in5 ro_divider_buffered_0/ro_complete_0/a2 26.29fF
C531 div_pd_buffered_0/divider_0/tspc_2/Z2 div_pd_buffered_0/divider_0/tspc_2/Z3 0.16fF
C532 div_pd_buffered_0/divider_0/nor_0/B div_pd_buffered_0/divider_0/tspc_2/Z4 0.22fF
C533 ro_divider_buffered_0/divider_0/nor_1/A ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C534 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C535 pll_full_buffered1_0/pll_full_0/ro_complete_0/a5 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/v 0.08fF
C536 pll_full_buffered1_0/pll_full_0/ro_complete_0/a0 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C537 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z2 pll_full_buffered1_0/pll_full_0/div 0.19fF
C538 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_divider_buffered_0/divider_0/prescaler_0/Out 0.21fF
C539 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C540 pll_full_buffered1_0/tapered_buf_0/in3 pll_full_buffered1_0/tapered_buf_0/in5 2.89fF
C541 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_buffered1_0/pll_full_0/vco 0.01fF
C542 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/B pll_full_buffered1_0/pll_full_0/divider_0/and_0/A 0.26fF
C543 ro_complete_buffered_0/tapered_buf_0/in5 ro_complete_buffered_0/tapered_buf_0/in2 0.84fF
C544 io_clamp_low[2] io_analog[6] 0.53fF
C545 div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 div_pd_buffered_0/pd_0/tspc_r_0/Qbar 0.01fF
C546 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C547 div_pd_buffered_0/pd_0/R div_pd_buffered_0/pd_0/and_pd_0/Out1 0.33fF
C548 pll_full_buffered2_0/pll_full_0/ro_complete_0/a0 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C549 ro_divider_buffered_0/tapered_buf_2/in3 ro_divider_buffered_0/tapered_buf_2/in5 2.89fF
C550 cp_buffered_0/tapered_buf_0/in3 cp_buffered_0/tapered_buf_0/in5 2.89fF
C551 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Q pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z2 0.14fF
C552 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z3 0.05fF
C553 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C554 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_buffered2_0/pll_full_0/vco 0.01fF
C555 pll_full_buffered2_0/tapered_buf_5/in2 pll_full_buffered2_0/tapered_buf_5/in5 0.84fF
C556 ro_divider_buffered_0/tapered_buf_5/in1 ro_divider_buffered_0/tapered_buf_5/in2 0.37fF
C557 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/tspc_1/Z4 0.21fF
C558 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/tspc_0/Z3 0.45fF
C559 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C560 div_pd_buffered_0/divider_0/and_0/A div_pd_buffered_0/divider_0/and_0/B 0.18fF
C561 pll_full_buffered2_0/tapered_buf_2/in4 pll_full_buffered2_0/tapered_buf_2/in5 29.21fF
C562 ro_divider_buffered_0/divider_0/nor_1/A ro_divider_buffered_0/divider_0/tspc_0/Z2 0.23fF
C563 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C564 ro_complete_buffered_0/tapered_buf_5/in3 ro_complete_buffered_0/tapered_buf_5/in5 2.89fF
C565 ro_divider_buffered_0/tapered_buf_0/in5 ro_divider_buffered_0/tapered_buf_0/in1 0.22fF
C566 pll_full_buffered2_0/pll_full_0/ref pll_full_buffered2_0/tapered_buf_0/in5 26.29fF
C567 pll_full_buffered1_0/pll_full_0/divider_0/and_0/OUT pll_full_buffered1_0/pll_full_0/div 0.01fF
C568 ro_divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C569 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_divider_buffered_0/divider_0/clk 0.01fF
C570 ro_complete_buffered_0/tapered_buf_4/in ro_complete_buffered_0/tapered_buf_4/in1 0.19fF
C571 divider_buffered_0/divider_0/tspc_0/Z1 divider_buffered_0/divider_0/tspc_0/Z3 0.06fF
C572 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/Z1 pll_full_buffered2_0/pll_full_0/divider_0/and_0/B 0.18fF
C573 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C574 pll_full_buffered2_0/tapered_buf_1/in3 pll_full_buffered2_0/tapered_buf_1/in2 1.27fF
C575 pd_buffered_0/tapered_buf_3/in pd_buffered_0/pd_0/DIV 0.02fF
C576 pd_buffered_0/pd_0/tspc_r_1/Qbar1 pd_buffered_0/pd_0/DOWN 0.11fF
C577 pll_full_buffered1_0/pll_full_0/pd_0/R pll_full_buffered1_0/pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C578 divider_buffered_0/tapered_buf_0/in5 divider_buffered_0/tapered_buf_0/in1 0.22fF
C579 divider_buffered_0/divider_0/nor_1/A divider_buffered_0/divider_0/and_0/B 0.08fF
C580 pll_full_buffered2_0/pll_full_0/divider_0/nor_0/B pll_full_buffered2_0/pll_full_0/div 0.27fF
C581 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z1 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z3 0.06fF
C582 ro_divider_buffered_0/tapered_buf_6/in4 ro_divider_buffered_0/tapered_buf_6/in5 29.21fF
C583 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D div_pd_buffered_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C584 divider_buffered_0/divider_0/mc2 divider_buffered_0/divider_0/and_0/OUT 0.05fF
C585 pd_buffered_0/pd_0/tspc_r_0/Qbar pd_buffered_0/pd_0/R 0.03fF
C586 divider_buffered_0/divider_0/nor_1/B divider_buffered_0/divider_0/and_0/B 0.31fF
C587 divider_buffered_0/divider_0/tspc_0/Z3 divider_buffered_0/divider_0/tspc_0/Q 0.05fF
C588 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z4 divider_buffered_0/divider_0/clk 0.12fF
C589 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_1/vin ro_divider_buffered_0/ro_complete_0/a3 0.13fF
C590 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_3/vin ro_divider_buffered_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C591 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z1 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z2 1.07fF
C592 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/B pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z3 0.38fF
C593 ro_divider_buffered_0/ro_complete_0/a3 ro_divider_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C594 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z3 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z4 0.65fF
C595 ro_complete_buffered_0/ro_complete_0/a3 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C596 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C597 ro_divider_buffered_0/tapered_buf_2/in2 ro_divider_buffered_0/tapered_buf_2/in3 1.27fF
C598 pll_full_buffered2_0/pll_full_0/ro_complete_0/a4 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C599 ro_divider_buffered_0/ro_complete_0/a3 ro_divider_buffered_0/divider_0/clk 0.05fF
C600 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/tspc_0/Z2 0.11fF
C601 divider_buffered_0/divider_0/nor_1/A divider_buffered_0/divider_0/prescaler_0/Out 0.15fF
C602 divider_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# divider_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C603 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/B pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Q 0.51fF
C604 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z2 0.01fF
C605 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C606 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C607 pll_full_buffered2_0/tapered_buf_4/in4 pll_full_buffered2_0/tapered_buf_4/in5 29.21fF
C608 ro_complete_buffered_0/tapered_buf_2/in3 ro_complete_buffered_0/tapered_buf_2/in4 4.78fF
C609 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D div_pd_buffered_0/divider_0/clk 0.26fF
C610 pd_buffered_0/pd_0/tspc_r_0/Z3 pd_buffered_0/pd_0/tspc_r_0/Qbar1 0.38fF
C611 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C612 pd_buffered_0/tapered_buf_2/out pd_buffered_0/tapered_buf_2/in5 26.29fF
C613 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/tapered_buf_1/in5 26.29fF
C614 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C615 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_4/vin ro_complete_buffered_0/tapered_buf_1/in 1.30fF
C616 pll_full_buffered2_0/tapered_buf_5/in5 pll_full_buffered2_0/tapered_buf_5/in1 0.22fF
C617 ro_divider_buffered_0/divider_0/tspc_0/a_630_n680# ro_divider_buffered_0/divider_0/nor_1/A 0.35fF
C618 div_pd_buffered_0/pd_0/tspc_r_1/Z2 div_pd_buffered_0/pd_0/R 0.21fF
C619 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/pd_0/tspc_r_1/z5 0.03fF
C620 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C621 pll_full_buffered2_0/pll_full_0/ro_complete_0/a3 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C622 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/B pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z2 0.20fF
C623 ro_divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# ro_divider_buffered_0/divider_0/nor_1/A 0.01fF
C624 ro_divider_buffered_0/divider_0/tspc_1/a_630_n680# ro_divider_buffered_0/divider_0/tspc_1/Z4 0.12fF
C625 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z3 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C626 pd_buffered_0/pd_0/DIV pd_buffered_0/pd_0/tspc_r_1/Z4 0.02fF
C627 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/v pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/v 0.04fF
C628 ro_divider_buffered_0/divider_0/tspc_0/a_630_n680# ro_divider_buffered_0/divider_0/nor_1/B 0.01fF
C629 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z3 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z1 0.09fF
C630 ro_divider_buffered_0/divider_0/prescaler_0/Out ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C631 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_4/vin ro_divider_buffered_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C632 div_pd_buffered_0/tapered_buf_4/in1 div_pd_buffered_0/tapered_buf_4/in2 0.37fF
C633 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_2/vin ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C634 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/tspc_0/Z4 0.12fF
C635 divider_buffered_0/divider_0/tspc_1/Z1 divider_buffered_0/divider_0/tspc_1/Z4 0.00fF
C636 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C637 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/A pll_full_buffered2_0/pll_full_0/divider_0/nor_1/B 1.21fF
C638 pd_buffered_0/pd_0/tspc_r_0/Z1 pd_buffered_0/pd_0/tspc_r_0/Z3 0.09fF
C639 pd_buffered_0/pd_0/tspc_r_0/Z2 pd_buffered_0/pd_0/REF 0.19fF
C640 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z2 pll_full_buffered1_0/pll_full_0/pd_0/R 0.21fF
C641 pll_full_buffered1_0/pll_full_0/pd_0/DOWN pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/z5 0.03fF
C642 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z3 pll_full_buffered1_0/pll_full_0/pd_0/UP 0.03fF
C643 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C644 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C645 divider_buffered_0/divider_0/tspc_1/Q divider_buffered_0/divider_0/tspc_2/a_630_n680# 0.01fF
C646 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_0/vin ro_divider_buffered_0/ro_complete_0/a4 0.12fF
C647 ro_divider_buffered_0/ro_complete_0/a2 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C648 pd_buffered_0/pd_0/DOWN pd_buffered_0/pd_0/UP 1.14fF
C649 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z3 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z1 0.06fF
C650 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C651 pll_full_buffered1_0/pll_full_0/ro_complete_0/a2 pll_full_buffered1_0/pll_full_0/vco 0.11fF
C652 div_pd_buffered_0/tapered_buf_2/in5 div_pd_buffered_0/tapered_buf_2/in2 0.84fF
C653 ro_complete_buffered_0/tapered_buf_6/in1 ro_complete_buffered_0/tapered_buf_6/in2 0.37fF
C654 ro_divider_buffered_0/divider_0/nor_0/B ro_divider_buffered_0/divider_0/tspc_2/Z1 0.03fF
C655 ro_divider_buffered_0/divider_0/tspc_2/a_630_n680# ro_divider_buffered_0/divider_0/tspc_2/Z3 0.05fF
C656 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_4/vin ro_divider_buffered_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C657 pd_buffered_0/pd_0/tspc_r_0/Qbar1 pd_buffered_0/pd_0/UP 0.11fF
C658 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_1/vin ro_complete_buffered_0/ro_complete_0/a3 0.13fF
C659 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_3/vin ro_complete_buffered_0/ro_complete_0/a1 0.14fF
C660 pll_full_buffered2_0/pll_full_0/ro_complete_0/a3 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C661 pll_full_buffered2_0/tapered_buf_4/in2 pll_full_buffered2_0/tapered_buf_4/in3 1.27fF
C662 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_buffered2_0/pll_full_0/divider_0/and_0/OUT 0.14fF
C663 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered2_0/pll_full_0/vco 0.51fF
C664 pd_buffered_0/tapered_buf_1/in3 pd_buffered_0/tapered_buf_1/in4 4.78fF
C665 pd_buffered_0/pd_0/tspc_r_1/Qbar1 pd_buffered_0/pd_0/DIV 0.12fF
C666 div_pd_buffered_0/divider_0/tspc_1/Q div_pd_buffered_0/divider_0/tspc_2/Z4 0.15fF
C667 pll_full_buffered1_0/tapered_buf_1/in1 pll_full_buffered1_0/tapered_buf_1/in2 0.37fF
C668 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.01fF
C669 divider_buffered_0/divider_0/and_0/OUT divider_buffered_0/divider_0/and_0/Z1 0.04fF
C670 divider_buffered_0/divider_0/tspc_2/a_630_n680# divider_buffered_0/divider_0/tspc_2/Z2 0.01fF
C671 divider_buffered_0/divider_0/prescaler_0/tspc_2/Q divider_buffered_0/divider_0/clk 0.05fF
C672 ro_divider_buffered_0/ro_complete_0/a2 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C673 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C674 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_buffered1_0/pll_full_0/vco 1.58fF
C675 ro_complete_buffered_0/tapered_buf_7/in4 ro_complete_buffered_0/tapered_buf_7/in5 29.21fF
C676 pll_full_buffered2_0/pll_full_0/ref pll_full_buffered2_0/tapered_buf_3/in 0.32fF
C677 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 divider_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.01fF
C678 ashish_0/cm ashish_0/a 0.27fF
C679 pd_buffered_0/pd_0/R pd_buffered_0/pd_0/and_pd_0/Z1 0.02fF
C680 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_4/vin ro_complete_buffered_0/ro_complete_0/a0 0.13fF
C681 ro_complete_buffered_0/ro_complete_0/a5 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C682 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C683 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_buffered2_0/pll_full_0/div 0.12fF
C684 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 0.38fF
C685 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Qbar 0.01fF
C686 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C687 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C688 divider_buffered_0/divider_0/nor_1/A divider_buffered_0/divider_0/tspc_0/a_630_n680# 0.35fF
C689 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/A pll_full_buffered2_0/pll_full_0/divider_0/and_0/B 0.08fF
C690 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C691 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C692 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_buffered2_0/pll_full_0/vco 0.12fF
C693 pll_full_buffered1_0/tapered_buf_0/in2 pll_full_buffered1_0/tapered_buf_0/in1 0.37fF
C694 div_pd_buffered_0/divider_0/tspc_2/Z2 div_pd_buffered_0/divider_0/tspc_2/Z4 0.36fF
C695 divider_buffered_0/divider_0/tspc_0/a_630_n680# divider_buffered_0/divider_0/nor_1/B 0.01fF
C696 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 divider_buffered_0/divider_0/clk 0.64fF
C697 filter_buffered_0/filter_0/a_4216_n5230# filter_buffered_0/filter_0/v 0.19fF
C698 pll_full_buffered1_0/pll_full_0/pd_0/R pll_full_buffered1_0/pll_full_0/div 0.51fF
C699 divider_buffered_0/divider_0/and_0/out1 divider_buffered_0/divider_0/and_0/B 0.18fF
C700 ro_divider_buffered_0/divider_0/and_0/OUT ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C701 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_divider_buffered_0/divider_0/prescaler_0/Out 0.04fF
C702 pll_full_buffered1_0/pll_full_0/divider_0/and_0/OUT pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C703 ro_complete_buffered_0/tapered_buf_3/in1 ro_complete_buffered_0/tapered_buf_3/in2 0.37fF
C704 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Qbar pll_full_buffered2_0/tapered_buf_3/in 0.02fF
C705 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/tspc_r_0/Z4 0.20fF
C706 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/tspc_r_0/z5 0.04fF
C707 ro_complete_buffered_0/ro_complete_0/a1 ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C708 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 divider_buffered_0/divider_0/prescaler_0/Out 0.19fF
C709 pll_full_buffered2_0/tapered_buf_1/in1 pll_full_buffered2_0/tapered_buf_1/in5 0.22fF
C710 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z1 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z2 1.07fF
C711 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C712 pll_full_buffered2_0/tapered_buf_5/in4 pll_full_buffered2_0/tapered_buf_5/in5 29.21fF
C713 ro_divider_buffered_0/tapered_buf_0/in1 ro_divider_buffered_0/tapered_buf_0/in 0.19fF
C714 ro_divider_buffered_0/tapered_buf_5/in2 ro_divider_buffered_0/tapered_buf_5/in3 1.27fF
C715 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z3 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Qbar1 0.38fF
C716 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C717 divider_buffered_0/divider_0/nor_0/Z1 divider_buffered_0/divider_0/nor_1/B 0.18fF
C718 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/B pll_full_buffered2_0/pll_full_0/divider_0/and_0/B 0.31fF
C719 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C720 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C721 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z3 divider_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C722 ro_divider_buffered_0/divider_0/nor_1/A ro_divider_buffered_0/divider_0/and_0/A 0.01fF
C723 pd_buffered_0/pd_0/DOWN pd_buffered_0/pd_0/and_pd_0/Out1 0.12fF
C724 pd_buffered_0/tapered_buf_2/in1 pd_buffered_0/tapered_buf_2/in5 0.22fF
C725 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z1 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Q 0.01fF
C726 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/v 1.45fF
C727 ro_divider_buffered_0/ro_complete_0/a4 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C728 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/a1 0.14fF
C729 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C730 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/a3 0.09fF
C731 ro_divider_buffered_0/divider_0/nor_1/B ro_divider_buffered_0/divider_0/tspc_1/Z1 0.03fF
C732 ro_divider_buffered_0/divider_0/tspc_1/a_630_n680# ro_divider_buffered_0/divider_0/tspc_1/Z3 0.05fF
C733 ro_divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C734 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C735 divider_buffered_0/divider_0/tspc_1/a_630_n680# divider_buffered_0/divider_0/nor_1/B 0.35fF
C736 filter_buffered_0/tapered_buf_0/in1 filter_buffered_0/tapered_buf_0/in5 0.22fF
C737 div_pd_buffered_0/tapered_buf_1/in5 div_pd_buffered_0/tapered_buf_1/in2 0.84fF
C738 ro_divider_buffered_0/divider_0/nor_1/B ro_divider_buffered_0/divider_0/and_0/A 0.26fF
C739 pll_full_buffered1_0/pll_full_0/cp_0/a_10_n50# pll_full_buffered1_0/pll_full_0/cp_0/a_1710_0# 0.04fF
C740 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/tspc_2/Z4 0.02fF
C741 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C742 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 div_pd_buffered_0/divider_0/clk 0.45fF
C743 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z1 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z4 0.00fF
C744 ro_divider_buffered_0/ro_complete_0/a2 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_2/vin 0.15fF
C745 pll_full_buffered1_0/pll_full_0/ro_complete_0/a2 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C746 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C747 cp_buffered_0/tapered_buf_2/in1 cp_buffered_0/tapered_buf_2/in2 0.37fF
C748 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/A pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C749 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/B pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z4 0.21fF
C750 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z3 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z2 0.16fF
C751 ro_complete_buffered_0/tapered_buf_3/in1 ro_complete_buffered_0/tapered_buf_3/in5 0.22fF
C752 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/tapered_buf_1/in 0.05fF
C753 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_4/vin ro_complete_buffered_0/ro_complete_0/a0 0.13fF
C754 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C755 ro_divider_buffered_0/tapered_buf_2/in3 ro_divider_buffered_0/tapered_buf_2/in4 4.78fF
C756 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C757 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C758 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_buffered2_0/pll_full_0/vco 0.01fF
C759 ro_divider_buffered_0/tapered_buf_3/in1 ro_divider_buffered_0/tapered_buf_3/in5 0.22fF
C760 ro_divider_buffered_0/divider_0/nor_1/A ro_divider_buffered_0/divider_0/tspc_1/Z4 0.02fF
C761 pd_buffered_0/tapered_buf_1/in2 pd_buffered_0/tapered_buf_1/in5 0.84fF
C762 ro_complete_buffered_0/tapered_buf_4/in3 ro_complete_buffered_0/tapered_buf_4/in4 4.78fF
C763 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_buffered1_0/pll_full_0/vco 1.46fF
C764 ro_complete_buffered_0/tapered_buf_0/in3 ro_complete_buffered_0/tapered_buf_0/in5 2.89fF
C765 div_pd_buffered_0/tapered_buf_3/in5 div_pd_buffered_0/tapered_buf_3/in3 2.89fF
C766 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_0/vin ro_complete_buffered_0/tapered_buf_1/in 1.43fF
C767 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z1 0.06fF
C768 ro_divider_buffered_0/ro_complete_0/a0 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C769 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C770 filter_buffered_0/filter_0/v filter_buffered_0/tapered_buf_0/in1 0.19fF
C771 filter_buffered_0/tapered_buf_1/in1 filter_buffered_0/tapered_buf_1/in5 0.22fF
C772 div_pd_buffered_0/pd_0/tspc_r_1/Z2 div_pd_buffered_0/pd_0/tspc_r_1/Z4 0.14fF
C773 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/v pll_full_buffered2_0/pll_full_0/vco 1.36fF
C774 ro_divider_buffered_0/divider_0/mc2 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.33fF
C775 ro_divider_buffered_0/divider_0/nor_1/B ro_divider_buffered_0/divider_0/tspc_1/Z4 0.21fF
C776 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C777 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/and_0/OUT 0.14fF
C778 ro_divider_buffered_0/divider_0/tspc_1/Q ro_divider_buffered_0/divider_0/tspc_2/Z1 0.01fF
C779 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/R 0.29fF
C780 div_pd_buffered_0/tapered_buf_4/in2 div_pd_buffered_0/tapered_buf_4/in3 1.27fF
C781 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_4/vin ro_complete_buffered_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C782 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_4/vin ro_divider_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C783 divider_buffered_0/divider_0/tspc_1/Z3 divider_buffered_0/divider_0/tspc_1/Z4 0.65fF
C784 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/A pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/a_630_n680# 0.35fF
C785 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C786 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C787 pll_full_buffered2_0/pll_full_0/divider_0/nor_0/Z1 pll_full_buffered2_0/pll_full_0/divider_0/nor_0/B 0.06fF
C788 ro_divider_buffered_0/tapered_buf_2/in ro_divider_buffered_0/tapered_buf_2/in1 0.19fF
C789 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.33fF
C790 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.21fF
C791 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.01fF
C792 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z2 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z4 0.14fF
C793 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C794 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 div_pd_buffered_0/divider_0/clk 0.12fF
C795 divider_buffered_0/divider_0/tspc_1/Q divider_buffered_0/divider_0/nor_0/B 0.22fF
C796 divider_buffered_0/divider_0/prescaler_0/tspc_1/Q divider_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C797 ro_divider_buffered_0/divider_0/tspc_2/Z1 ro_divider_buffered_0/divider_0/tspc_2/Z2 1.07fF
C798 ro_divider_buffered_0/divider_0/nor_0/B ro_divider_buffered_0/divider_0/tspc_2/Z3 0.38fF
C799 ro_divider_buffered_0/divider_0/tspc_2/a_630_n680# ro_divider_buffered_0/divider_0/tspc_2/Z4 0.12fF
C800 pd_buffered_0/pd_0/tspc_r_0/z5 pd_buffered_0/pd_0/tspc_r_1/z5 0.02fF
C801 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C802 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/Z1 pll_full_buffered1_0/pll_full_0/divider_0/and_0/A 0.80fF
C803 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C804 div_pd_buffered_0/tapered_buf_2/in5 div_pd_buffered_0/tapered_buf_2/in4 29.21fF
C805 ro_complete_buffered_0/tapered_buf_6/in2 ro_complete_buffered_0/tapered_buf_6/in3 1.27fF
C806 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_3/vin ro_divider_buffered_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C807 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 0.12fF
C808 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C809 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C810 div_pd_buffered_0/pd_0/tspc_r_0/Z1 div_pd_buffered_0/pd_0/tspc_r_0/Z2 0.71fF
C811 pll_full_buffered2_0/pll_full_0/ro_complete_0/a3 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C812 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C813 ro_divider_buffered_0/divider_0/tspc_0/Z3 ro_divider_buffered_0/divider_0/tspc_0/Z1 0.06fF
C814 pd_buffered_0/pd_0/tspc_r_0/Z1 pd_buffered_0/pd_0/tspc_r_0/Z2 0.71fF
C815 divider_buffered_0/divider_0/nor_1/A divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# 0.01fF
C816 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/B pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C817 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C818 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C819 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_buffered2_0/pll_full_0/vco 1.46fF
C820 pll_full_buffered2_0/tapered_buf_4/in3 pll_full_buffered2_0/tapered_buf_4/in4 4.78fF
C821 pd_buffered_0/pd_0/DOWN pd_buffered_0/pd_0/tspc_r_1/Z3 0.03fF
C822 ro_divider_buffered_0/tapered_buf_7/in1 ro_divider_buffered_0/tapered_buf_7/in5 0.22fF
C823 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 div_pd_buffered_0/divider_0/clk 0.45fF
C824 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C825 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C826 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.04fF
C827 divider_buffered_0/divider_0/nor_0/B divider_buffered_0/divider_0/tspc_2/Z2 0.40fF
C828 divider_buffered_0/divider_0/tspc_2/a_630_n680# divider_buffered_0/divider_0/Out 0.04fF
C829 divider_buffered_0/divider_0/prescaler_0/tspc_0/D divider_buffered_0/divider_0/clk 0.29fF
C830 ro_divider_buffered_0/divider_0/and_0/out1 ro_divider_buffered_0/divider_0/and_0/Z1 0.36fF
C831 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C832 pll_full_buffered1_0/pll_full_0/divider_0/and_0/out1 pll_full_buffered1_0/pll_full_0/divider_0/and_0/B 0.18fF
C833 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C834 pll_full_buffered2_0/tapered_buf_5/in2 pll_full_buffered2_0/tapered_buf_5/in1 0.37fF
C835 cp_buffered_0/tapered_buf_1/in1 cp_buffered_0/tapered_buf_1/in5 0.22fF
C836 div_pd_buffered_0/pd_0/tspc_r_0/Z4 div_pd_buffered_0/pd_0/tspc_r_1/Z4 0.02fF
C837 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/tspc_r_1/Z1 0.17fF
C838 div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 div_pd_buffered_0/pd_0/DOWN 0.11fF
C839 pll_full_buffered2_0/pll_full_0/ro_complete_0/a4 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C840 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z1 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z2 0.71fF
C841 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z3 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z4 0.20fF
C842 pll_full_buffered1_0/pll_full_0/ref pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C843 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C844 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z2 ro_divider_buffered_0/divider_0/and_0/OUT 0.06fF
C845 ro_divider_buffered_0/tapered_buf_4/in ro_divider_buffered_0/tapered_buf_4/in1 0.19fF
C846 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C847 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C848 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z2 divider_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.01fF
C849 ro_complete_buffered_0/tapered_buf_2/in4 ro_complete_buffered_0/tapered_buf_2/in5 29.21fF
C850 io_clamp_low[2] io_clamp_high[2] 0.53fF
C851 ro_divider_buffered_0/divider_0/and_0/OUT ro_divider_buffered_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C852 pd_buffered_0/pd_0/tspc_r_0/Qbar pd_buffered_0/pd_0/UP 0.21fF
C853 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C854 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z4 pll_full_buffered1_0/pll_full_0/div 0.02fF
C855 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z3 pll_full_buffered2_0/pll_full_0/pd_0/UP 0.03fF
C856 pll_full_buffered1_0/pll_full_0/divider_0/and_0/OUT pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C857 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_buffered1_0/pll_full_0/vco 0.11fF
C858 ro_complete_buffered_0/tapered_buf_0/in ro_complete_buffered_0/tapered_buf_0/in1 0.19fF
C859 io_clamp_high[1] io_analog[5] 0.53fF
C860 ro_divider_buffered_0/divider_0/prescaler_0/Out ro_divider_buffered_0/divider_0/tspc_0/Z4 0.12fF
C861 div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 div_pd_buffered_0/pd_0/tspc_r_0/z5 0.20fF
C862 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_5/vin ro_complete_buffered_0/tapered_buf_1/in 1.30fF
C863 ro_divider_buffered_0/divider_0/tspc_0/Z3 ro_divider_buffered_0/divider_0/nor_1/A 0.38fF
C864 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C865 pll_full_buffered2_0/pll_full_0/filter_0/a_4216_n5230# pll_full_buffered2_0/pll_full_0/vco 1.58fF
C866 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z2 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z3 0.16fF
C867 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C868 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z4 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C869 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_buffered1_0/pll_full_0/pd_0/DOWN 0.11fF
C870 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C871 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_buffered2_0/pll_full_0/vco 0.11fF
C872 ro_divider_buffered_0/tapered_buf_0/in1 ro_divider_buffered_0/tapered_buf_0/in2 0.37fF
C873 ro_divider_buffered_0/tapered_buf_5/in2 ro_divider_buffered_0/tapered_buf_5/in5 0.84fF
C874 ro_divider_buffered_0/tapered_buf_5/in3 ro_divider_buffered_0/tapered_buf_5/in4 4.78fF
C875 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C876 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C877 pll_full_buffered1_0/tapered_buf_0/in2 pll_full_buffered1_0/tapered_buf_0/in3 1.27fF
C878 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C879 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z4 divider_buffered_0/divider_0/clk 0.12fF
C880 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_0/vin ro_divider_buffered_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C881 ro_divider_buffered_0/tapered_buf_7/in5 ro_divider_buffered_0/ro_complete_0/a1 26.29fF
C882 div_pd_buffered_0/divider_0/and_0/B div_pd_buffered_0/divider_0/and_0/Z1 0.07fF
C883 pll_full_buffered2_0/pll_full_0/ref pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Qbar1 0.12fF
C884 ro_divider_buffered_0/divider_0/and_0/OUT ro_divider_buffered_0/divider_0/clk 0.04fF
C885 pd_buffered_0/tapered_buf_1/in3 pd_buffered_0/tapered_buf_1/in5 2.89fF
C886 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_4/vin ro_divider_buffered_0/ro_complete_0/a0 0.13fF
C887 pll_full_buffered2_0/tapered_buf_3/in pll_full_buffered2_0/pll_full_0/cp_0/a_1710_0# 0.32fF
C888 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z4 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C889 pd_buffered_0/tapered_buf_1/in1 pd_buffered_0/tapered_buf_1/in5 0.22fF
C890 pd_buffered_0/pd_0/tspc_r_1/Z2 pd_buffered_0/pd_0/R 0.21fF
C891 pll_full_buffered1_0/pll_full_0/divider_0/and_0/OUT pll_full_buffered1_0/pll_full_0/vco 0.06fF
C892 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/a3 3.17fF
C893 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C894 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/a1 0.14fF
C895 ro_divider_buffered_0/divider_0/nor_1/B ro_divider_buffered_0/divider_0/tspc_1/Z3 0.38fF
C896 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C897 pd_buffered_0/tapered_buf_0/in2 pd_buffered_0/tapered_buf_0/in3 1.27fF
C898 filter_buffered_0/tapered_buf_0/in3 filter_buffered_0/tapered_buf_0/in5 2.89fF
C899 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/tspc_0/a_630_n680# 0.01fF
C900 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 divider_buffered_0/divider_0/and_0/OUT 0.06fF
C901 div_pd_buffered_0/tapered_buf_2/in div_pd_buffered_0/tapered_buf_2/in1 0.19fF
C902 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z3 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z4 0.65fF
C903 ro_divider_buffered_0/divider_0/tspc_0/Z4 ro_divider_buffered_0/divider_0/tspc_0/Z2 0.36fF
C904 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/tspc_0/Z3 0.38fF
C905 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 div_pd_buffered_0/divider_0/clk 0.12fF
C906 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C907 divider_buffered_0/divider_0/and_0/OUT divider_buffered_0/divider_0/and_0/out1 0.31fF
C908 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Qbar 0.01fF
C909 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_buffered1_0/pll_full_0/vco 0.64fF
C910 pll_full_buffered2_0/tapered_buf_2/in2 pll_full_buffered2_0/tapered_buf_2/in3 1.27fF
C911 ro_divider_buffered_0/ro_complete_0/a1 ro_divider_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C912 divider_buffered_0/divider_0/tspc_1/Z2 divider_buffered_0/divider_0/tspc_1/a_630_n680# 0.01fF
C913 pll_full_buffered2_0/pll_full_0/pd_0/and_pd_0/Out1 pll_full_buffered2_0/pll_full_0/pd_0/UP 0.33fF
C914 pll_full_buffered1_0/pll_full_0/div pll_full_buffered1_0/pll_full_0/vco 2.26fF
C915 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C916 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.21fF
C917 pll_full_buffered2_0/pll_full_0/ro_complete_0/a5 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C918 ro_divider_buffered_0/ro_complete_0/a1 ro_divider_buffered_0/divider_0/clk 0.05fF
C919 ro_divider_buffered_0/tapered_buf_3/in3 ro_divider_buffered_0/tapered_buf_3/in5 2.89fF
C920 div_pd_buffered_0/tapered_buf_0/in4 div_pd_buffered_0/tapered_buf_0/in5 29.21fF
C921 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/and_0/OUT 0.06fF
C922 divider_buffered_0/tapered_buf_2/in2 divider_buffered_0/tapered_buf_2/in3 1.27fF
C923 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C924 divider_buffered_0/tapered_buf_1/in3 divider_buffered_0/tapered_buf_1/in5 2.89fF
C925 pd_buffered_0/pd_0/DIV pd_buffered_0/pd_0/tspc_r_1/Z3 0.65fF
C926 divider_buffered_0/divider_0/prescaler_0/Out divider_buffered_0/divider_0/tspc_0/Z3 0.45fF
C927 ro_divider_buffered_0/tapered_buf_8/in ro_divider_buffered_0/tapered_buf_8/in1 0.19fF
C928 div_pd_buffered_0/divider_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/nor_0/B 0.35fF
C929 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q div_pd_buffered_0/divider_0/clk 0.60fF
C930 divider_buffered_0/divider_0/mc2 divider_buffered_0/divider_0/clk 0.26fF
C931 pd_buffered_0/pd_0/tspc_r_0/Qbar pd_buffered_0/pd_0/and_pd_0/Out1 0.05fF
C932 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C933 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C934 ro_complete_buffered_0/tapered_buf_4/in4 ro_complete_buffered_0/tapered_buf_4/in5 29.21fF
C935 divider_buffered_0/divider_0/nor_0/B divider_buffered_0/divider_0/and_0/B 0.29fF
C936 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z1 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C937 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/B pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z4 0.02fF
C938 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z2 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z3 0.16fF
C939 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C940 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/A pll_full_buffered1_0/pll_full_0/divider_0/and_0/A 0.01fF
C941 ro_complete_buffered_0/tapered_buf_3/in ro_complete_buffered_0/tapered_buf_3/in1 0.19fF
C942 divider_buffered_0/divider_0/tspc_0/Z2 divider_buffered_0/divider_0/nor_1/A 0.23fF
C943 ro_complete_buffered_0/ro_complete_0/a5 ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.08fF
C944 ro_complete_buffered_0/ro_complete_0/a0 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C945 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C946 pll_full_buffered2_0/pll_full_0/ro_complete_0/a1 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C947 cp_buffered_0/tapered_buf_0/in cp_buffered_0/tapered_buf_0/in1 0.19fF
C948 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z3 pll_full_buffered1_0/pll_full_0/pd_0/R 0.29fF
C949 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/tspc_0/Z2 0.23fF
C950 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C951 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C952 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z2 divider_buffered_0/divider_0/and_0/OUT 0.05fF
C953 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/A pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z3 0.38fF
C954 ro_complete_buffered_0/tapered_buf_5/in ro_complete_buffered_0/tapered_buf_5/in1 0.19fF
C955 ro_divider_buffered_0/divider_0/tspc_1/Q ro_divider_buffered_0/divider_0/tspc_2/Z3 0.45fF
C956 ro_divider_buffered_0/divider_0/tspc_0/a_630_n680# ro_divider_buffered_0/divider_0/tspc_0/Z4 0.12fF
C957 ro_complete_buffered_0/tapered_buf_1/in2 ro_complete_buffered_0/tapered_buf_1/in3 1.27fF
C958 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C959 pll_full_buffered2_0/tapered_buf_3/in pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Qbar 0.21fF
C960 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_buffered2_0/pll_full_0/pd_0/R 0.01fF
C961 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 divider_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.01fF
C962 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_0/vin ro_divider_buffered_0/ro_complete_0/cbank_2/v 1.45fF
C963 pd_buffered_0/pd_0/and_pd_0/Z1 pd_buffered_0/pd_0/UP 0.06fF
C964 div_pd_buffered_0/tapered_buf_4/in2 div_pd_buffered_0/tapered_buf_4/in5 0.84fF
C965 div_pd_buffered_0/tapered_buf_4/in3 div_pd_buffered_0/tapered_buf_4/in4 4.78fF
C966 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_4/vin ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C967 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C968 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C969 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.04fF
C970 ro_divider_buffered_0/divider_0/nor_1/B ro_divider_buffered_0/divider_0/tspc_2/Z4 0.02fF
C971 DIGITAL_BUFFER_v1_0/in1 DIGITAL_BUFFER_v1_0/in 0.19fF
C972 pll_full_buffered2_0/pll_full_0/divider_0/and_0/OUT pll_full_buffered2_0/pll_full_0/divider_0/and_0/B 0.01fF
C973 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C974 divider_buffered_0/divider_0/tspc_1/Q divider_buffered_0/divider_0/tspc_2/Z2 0.14fF
C975 divider_buffered_0/divider_0/tspc_0/a_630_n680# divider_buffered_0/divider_0/tspc_0/Q 0.04fF
C976 divider_buffered_0/divider_0/prescaler_0/tspc_1/Q divider_buffered_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C977 divider_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# divider_buffered_0/divider_0/clk 0.01fF
C978 ro_divider_buffered_0/ro_complete_0/a2 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C979 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_1/vin ro_divider_buffered_0/ro_complete_0/a4 0.09fF
C980 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_0/vin ro_divider_buffered_0/ro_complete_0/a5 0.09fF
C981 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C982 ro_complete_buffered_0/tapered_buf_6/in2 ro_complete_buffered_0/tapered_buf_6/in5 0.84fF
C983 ro_complete_buffered_0/tapered_buf_6/in3 ro_complete_buffered_0/tapered_buf_6/in4 4.78fF
C984 ro_divider_buffered_0/divider_0/tspc_2/Z2 ro_divider_buffered_0/divider_0/tspc_2/Z3 0.16fF
C985 ro_divider_buffered_0/divider_0/nor_0/B ro_divider_buffered_0/divider_0/tspc_2/Z4 0.22fF
C986 ro_divider_buffered_0/ro_complete_0/a4 ro_divider_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C987 pll_full_buffered1_0/pll_full_0/divider_0/nor_0/B pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z1 0.03fF
C988 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z3 0.05fF
C989 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/a0 0.13fF
C990 ro_divider_buffered_0/divider_0/tspc_1/Z1 ro_divider_buffered_0/divider_0/tspc_1/Z2 1.07fF
C991 ro_divider_buffered_0/ro_complete_0/a4 ro_divider_buffered_0/divider_0/clk 0.05fF
C992 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C993 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C994 div_pd_buffered_0/divider_0/tspc_0/Z4 div_pd_buffered_0/divider_0/nor_1/A 0.21fF
C995 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C996 ro_divider_buffered_0/tapered_buf_7/in3 ro_divider_buffered_0/tapered_buf_7/in5 2.89fF
C997 pd_buffered_0/pd_0/tspc_r_1/Z1 pd_buffered_0/pd_0/tspc_r_1/Z3 0.09fF
C998 div_pd_buffered_0/divider_0/tspc_0/Z2 div_pd_buffered_0/divider_0/tspc_0/Z3 0.16fF
C999 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 div_pd_buffered_0/divider_0/clk 0.12fF
C1000 pll_full_buffered1_0/tapered_buf_0/out pll_full_buffered1_0/tapered_buf_0/in5 26.29fF
C1001 divider_buffered_0/divider_0/nor_0/B divider_buffered_0/divider_0/Out 0.44fF
C1002 divider_buffered_0/divider_0/tspc_2/Z1 divider_buffered_0/divider_0/tspc_2/Z3 0.06fF
C1003 ro_divider_buffered_0/ro_complete_0/a3 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_2/vin 0.21fF
C1004 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z3 0.05fF
C1005 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1006 pll_full_buffered1_0/pll_full_0/ro_complete_0/a0 pll_full_buffered1_0/pll_full_0/vco 0.11fF
C1007 ro_divider_buffered_0/divider_0/and_0/A ro_divider_buffered_0/divider_0/and_0/B 0.18fF
C1008 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z3 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z1 0.06fF
C1009 pll_full_buffered1_0/pll_full_0/divider_0/and_0/A pll_full_buffered1_0/pll_full_0/divider_0/and_0/B 0.18fF
C1010 pll_full_buffered2_0/pll_full_0/divider_0/nor_0/Z1 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/B 0.18fF
C1011 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z4 0.12fF
C1012 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.19fF
C1013 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z2 pll_full_buffered2_0/pll_full_0/div 0.19fF
C1014 cp_buffered_0/tapered_buf_1/in3 cp_buffered_0/tapered_buf_1/in5 2.89fF
C1015 div_pd_buffered_0/pd_0/tspc_r_0/z5 div_pd_buffered_0/pd_0/tspc_r_1/z5 0.02fF
C1016 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/tspc_r_1/Z2 0.25fF
C1017 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/z5 0.20fF
C1018 divider_buffered_0/tapered_buf_1/in5 divider_buffered_0/tapered_buf_1/in2 0.84fF
C1019 divider_buffered_0/divider_0/tspc_1/a_630_n680# divider_buffered_0/divider_0/tspc_0/Q 0.01fF
C1020 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z2 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Q 0.14fF
C1021 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_buffered2_0/pll_full_0/vco 0.01fF
C1022 ro_divider_buffered_0/tapered_buf_4/in1 ro_divider_buffered_0/tapered_buf_4/in2 0.37fF
C1023 ro_divider_buffered_0/tapered_buf_5/in5 ro_divider_buffered_0/ro_complete_0/a3 26.29fF
C1024 pd_buffered_0/pd_0/tspc_r_0/Z4 pd_buffered_0/pd_0/REF 0.02fF
C1025 divider_buffered_0/divider_0/tspc_0/a_630_n680# divider_buffered_0/divider_0/tspc_0/Z3 0.05fF
C1026 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z4 divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1027 divider_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# divider_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1028 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/D ro_divider_buffered_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C1029 ashish_0/von ashish_0/cm 1.96fF
C1030 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C1031 ro_complete_buffered_0/tapered_buf_0/in1 ro_complete_buffered_0/tapered_buf_0/in2 0.37fF
C1032 io_clamp_low[0] io_analog[4] 0.53fF
C1033 ro_complete_buffered_0/ro_complete_0/cbank_0/v ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.04fF
C1034 ro_divider_buffered_0/divider_0/prescaler_0/Out ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C1035 pd_buffered_0/pd_0/and_pd_0/Out1 pd_buffered_0/pd_0/and_pd_0/Z1 0.18fF
C1036 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z1 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z3 0.09fF
C1037 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z2 pll_full_buffered2_0/pll_full_0/ref 0.19fF
C1038 ro_divider_buffered_0/tapered_buf_0/in5 ro_divider_buffered_0/tapered_buf_0/in2 0.84fF
C1039 divider_buffered_0/divider_0/tspc_1/Z1 divider_buffered_0/divider_0/nor_1/B 0.03fF
C1040 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C1041 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/prescaler_0/Out 0.05fF
C1042 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/pd_0/UP 2.89fF
C1043 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/z5 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/z5 0.02fF
C1044 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z3 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z2 0.25fF
C1045 divider_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# divider_buffered_0/divider_0/prescaler_0/Out 0.04fF
C1046 pll_full_buffered2_0/pll_full_0/divider_0/and_0/OUT pll_full_buffered2_0/pll_full_0/div 0.01fF
C1047 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C1048 ro_divider_buffered_0/divider_0/tspc_1/Z2 ro_divider_buffered_0/divider_0/tspc_1/Z4 0.36fF
C1049 ro_divider_buffered_0/divider_0/tspc_1/Z3 ro_divider_buffered_0/divider_0/tspc_1/Q 0.05fF
C1050 ro_divider_buffered_0/tapered_buf_5/in4 ro_divider_buffered_0/tapered_buf_5/in5 29.21fF
C1051 div_pd_buffered_0/tapered_buf_0/in5 div_pd_buffered_0/tapered_buf_0/in1 0.22fF
C1052 div_pd_buffered_0/divider_0/tspc_0/Z4 div_pd_buffered_0/divider_0/tspc_0/Z3 0.65fF
C1053 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1054 ro_divider_buffered_0/divider_0/tspc_0/a_630_n680# ro_divider_buffered_0/divider_0/tspc_0/Q 0.04fF
C1055 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/D ro_divider_buffered_0/divider_0/clk 0.26fF
C1056 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z3 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Q 0.05fF
C1057 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C1058 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_1/vin ro_divider_buffered_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1059 ro_divider_buffered_0/ro_complete_0/a5 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C1060 pd_buffered_0/pd_0/tspc_r_1/Z2 pd_buffered_0/pd_0/tspc_r_1/Z4 0.14fF
C1061 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_buffered1_0/pll_full_0/div 0.03fF
C1062 pll_full_buffered1_0/pll_full_0/divider_0/and_0/OUT pll_full_buffered1_0/pll_full_0/divider_0/and_0/out1 0.31fF
C1063 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_buffered1_0/pll_full_0/vco 0.26fF
C1064 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1065 pll_full_buffered2_0/tapered_buf_3/in pll_full_buffered2_0/pll_full_0/pd_0/and_pd_0/Z1 0.07fF
C1066 pll_full_buffered2_0/tapered_buf_1/in1 pll_full_buffered2_0/tapered_buf_1/in 0.19fF
C1067 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C1068 pll_full_buffered2_0/pll_full_0/ro_complete_0/a4 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C1069 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1070 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C1071 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_5/vin ro_divider_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C1072 pll_full_buffered1_0/tapered_buf_2/in1 pll_full_buffered1_0/tapered_buf_2/in5 0.22fF
C1073 pll_full_buffered2_0/pll_full_0/divider_0/nor_0/Z1 pll_full_buffered2_0/pll_full_0/divider_0/and_0/B 0.78fF
C1074 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_buffered2_0/pll_full_0/vco 1.46fF
C1075 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/tapered_buf_1/in 0.02fF
C1076 div_pd_buffered_0/tapered_buf_3/in5 div_pd_buffered_0/divider_0/clk 26.29fF
C1077 pll_full_buffered1_0/pll_full_0/pd_0/DOWN pll_full_buffered1_0/pll_full_0/pd_0/UP 0.61fF
C1078 divider_buffered_0/tapered_buf_0/in5 divider_buffered_0/tapered_buf_0/in3 2.89fF
C1079 divider_buffered_0/divider_0/nor_0/Z1 divider_buffered_0/divider_0/nor_0/B 0.06fF
C1080 ro_divider_buffered_0/divider_0/mc2 ro_divider_buffered_0/divider_0/and_0/out1 0.06fF
C1081 div_pd_buffered_0/divider_0/tspc_1/Q div_pd_buffered_0/divider_0/tspc_2/a_630_n680# 0.01fF
C1082 ro_divider_buffered_0/ro_complete_0/a4 ro_divider_buffered_0/ro_complete_0/a5 2.39fF
C1083 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_3/vin ro_divider_buffered_0/ro_complete_0/a1 0.14fF
C1084 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_0/vin ro_divider_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C1085 pll_full_buffered1_0/pll_full_0/ro_complete_0/a5 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C1086 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1087 div_pd_buffered_0/tapered_buf_3/in div_pd_buffered_0/tapered_buf_3/in1 0.19fF
C1088 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z3 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z4 0.20fF
C1089 pll_full_buffered2_0/pll_full_0/ref pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C1090 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Q pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z3 0.45fF
C1091 pll_full_buffered1_0/pll_full_0/ro_complete_0/a3 pll_full_buffered1_0/pll_full_0/vco 0.11fF
C1092 pd_buffered_0/pd_0/tspc_r_1/Z4 pd_buffered_0/pd_0/tspc_r_1/z5 0.04fF
C1093 ro_complete_buffered_0/ro_complete_0/a1 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_4/vin 0.09fF
C1094 filter_buffered_0/tapered_buf_1/in1 filter_buffered_0/tapered_buf_1/in2 0.37fF
C1095 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1096 pll_full_buffered1_0/pll_full_0/ref pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Qbar1 0.12fF
C1097 divider_buffered_0/divider_0/tspc_1/a_630_n680# divider_buffered_0/divider_0/nor_0/B 0.00fF
C1098 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C1099 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/and_0/out1 0.06fF
C1100 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/divider_0/tspc_2/a_630_n680# 0.04fF
C1101 div_pd_buffered_0/divider_0/tspc_0/Z4 div_pd_buffered_0/divider_0/tspc_0/Z2 0.36fF
C1102 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C1103 div_pd_buffered_0/divider_0/nor_1/Z1 div_pd_buffered_0/divider_0/and_0/A 0.80fF
C1104 ro_divider_buffered_0/tapered_buf_8/in1 ro_divider_buffered_0/tapered_buf_8/in2 0.37fF
C1105 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/and_0/Z1 0.04fF
C1106 div_pd_buffered_0/divider_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/tspc_2/Z2 0.01fF
C1107 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q div_pd_buffered_0/divider_0/clk 0.05fF
C1108 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z3 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C1109 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C1110 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z3 pll_full_buffered1_0/pll_full_0/div 0.65fF
C1111 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z2 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z4 0.36fF
C1112 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z3 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Q 0.05fF
C1113 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C1114 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/divider_0/mc2 0.34fF
C1115 div_pd_buffered_0/tapered_buf_3/in2 div_pd_buffered_0/tapered_buf_3/in3 1.27fF
C1116 ro_complete_buffered_0/ro_complete_0/a0 ro_complete_buffered_0/tapered_buf_1/in 0.05fF
C1117 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z2 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C1118 cp_buffered_0/cp_0/out cp_buffered_0/cp_0/down 0.79fF
C1119 cp_buffered_0/tapered_buf_0/in1 cp_buffered_0/tapered_buf_0/in2 0.37fF
C1120 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/pd_0/and_pd_0/Out1 0.12fF
C1121 div_pd_buffered_0/pd_0/tspc_r_0/Qbar div_pd_buffered_0/pd_0/UP 0.21fF
C1122 ro_divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# ro_divider_buffered_0/divider_0/and_0/OUT 0.14fF
C1123 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C1124 pll_full_buffered1_0/pll_full_0/ro_complete_0/a2 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1125 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z2 divider_buffered_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C1126 div_pd_buffered_0/divider_0/and_0/out1 div_pd_buffered_0/divider_0/and_0/B 0.18fF
C1127 ro_divider_buffered_0/divider_0/tspc_1/Q ro_divider_buffered_0/divider_0/tspc_2/Z4 0.15fF
C1128 pd_buffered_0/pd_0/tspc_r_1/Qbar1 pd_buffered_0/pd_0/tspc_r_1/z5 0.20fF
C1129 pll_full_buffered1_0/tapered_buf_0/in4 pll_full_buffered1_0/tapered_buf_0/in3 4.78fF
C1130 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z2 0.11fF
C1131 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1132 ro_complete_buffered_0/tapered_buf_5/in1 ro_complete_buffered_0/tapered_buf_5/in2 0.37fF
C1133 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1134 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_4/vin ro_divider_buffered_0/ro_complete_0/a0 0.13fF
C1135 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Qbar pll_full_buffered2_0/pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C1136 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z3 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/z5 0.11fF
C1137 pd_buffered_0/tapered_buf_1/in1 pd_buffered_0/tapered_buf_1/in 0.19fF
C1138 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Q pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z1 0.01fF
C1139 div_pd_buffered_0/tapered_buf_4/in4 div_pd_buffered_0/tapered_buf_4/in5 29.21fF
C1140 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_0/vin ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.45fF
C1141 pll_full_buffered2_0/pll_full_0/ro_complete_0/a4 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C1142 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z1 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/B 0.03fF
C1143 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z3 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/a_630_n680# 0.05fF
C1144 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C1145 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C1146 pll_full_buffered1_0/pll_full_0/pd_0/DOWN pll_full_buffered1_0/pll_full_0/pd_0/and_pd_0/Out1 0.12fF
C1147 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Qbar pll_full_buffered1_0/pll_full_0/pd_0/UP 0.21fF
C1148 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z4 ro_divider_buffered_0/divider_0/clk 0.12fF
C1149 div_pd_buffered_0/tapered_buf_1/in4 div_pd_buffered_0/tapered_buf_1/in3 4.78fF
C1150 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/nor_0/B 0.00fF
C1151 div_pd_buffered_0/divider_0/tspc_1/Z2 div_pd_buffered_0/divider_0/tspc_0/Q 0.14fF
C1152 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C1153 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/clk 0.01fF
C1154 divider_buffered_0/divider_0/prescaler_0/tspc_2/Q divider_buffered_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C1155 divider_buffered_0/divider_0/prescaler_0/tspc_1/Q divider_buffered_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C1156 ro_divider_buffered_0/divider_0/tspc_2/Z2 ro_divider_buffered_0/divider_0/tspc_2/Z4 0.36fF
C1157 ro_divider_buffered_0/divider_0/tspc_2/Z3 ro_divider_buffered_0/divider_0/Out 0.05fF
C1158 pll_full_buffered1_0/tapered_buf_1/in5 pll_full_buffered1_0/tapered_buf_1/in4 29.21fF
C1159 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/A pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z4 0.02fF
C1160 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z3 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/a_630_n680# 0.05fF
C1161 ro_complete_buffered_0/tapered_buf_6/in4 ro_complete_buffered_0/tapered_buf_6/in5 29.21fF
C1162 ro_divider_buffered_0/divider_0/tspc_0/Q ro_divider_buffered_0/divider_0/tspc_1/Z1 0.01fF
C1163 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_3/vin ro_divider_buffered_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C1164 pll_full_buffered2_0/pll_full_0/pd_0/R pll_full_buffered2_0/pll_full_0/pd_0/UP 0.45fF
C1165 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z1 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z2 1.07fF
C1166 pll_full_buffered1_0/pll_full_0/divider_0/nor_0/B pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z3 0.38fF
C1167 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z4 0.12fF
C1168 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_0/vin 0.12fF
C1169 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1170 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_2/vin ro_complete_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C1171 cp_buffered_0/cp_0/a_1710_0# cp_buffered_0/cp_0/down 0.32fF
C1172 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C1173 ro_divider_buffered_0/divider_0/tspc_1/Z2 ro_divider_buffered_0/divider_0/tspc_1/Z3 0.16fF
C1174 pll_full_buffered1_0/tapered_buf_2/in5 pll_full_buffered1_0/pll_full_0/ref 26.29fF
C1175 div_pd_buffered_0/tapered_buf_0/in2 div_pd_buffered_0/tapered_buf_0/in1 0.37fF
C1176 div_pd_buffered_0/divider_0/tspc_1/Z1 div_pd_buffered_0/divider_0/tspc_1/Z3 0.06fF
C1177 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_buffered2_0/pll_full_0/divider_0/and_0/OUT 0.06fF
C1178 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C1179 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C1180 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_buffered2_0/pll_full_0/vco 1.46fF
C1181 pll_full_buffered2_0/pll_full_0/divider_0/and_0/out1 pll_full_buffered2_0/pll_full_0/divider_0/and_0/A 0.01fF
C1182 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z3 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Q 0.05fF
C1183 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 divider_buffered_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C1184 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.33fF
C1185 pll_full_buffered1_0/pll_full_0/ro_complete_0/a3 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1186 divider_buffered_0/divider_0/tspc_2/Z1 divider_buffered_0/divider_0/tspc_2/Z4 0.00fF
C1187 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z1 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1188 ro_divider_buffered_0/ro_complete_0/a3 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C1189 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_1/vin ro_divider_buffered_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1190 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z3 pll_full_buffered2_0/pll_full_0/pd_0/R 0.29fF
C1191 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z4 0.12fF
C1192 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1193 ro_complete_buffered_0/tapered_buf_1/in5 ro_complete_buffered_0/tapered_buf_1/out 26.29fF
C1194 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z4 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z1 0.00fF
C1195 ro_complete_buffered_0/ro_complete_0/a3 ro_complete_buffered_0/tapered_buf_1/in 0.05fF
C1196 div_pd_buffered_0/pd_0/tspc_r_0/Qbar div_pd_buffered_0/pd_0/and_pd_0/Out1 0.05fF
C1197 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/R 0.27fF
C1198 div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 div_pd_buffered_0/pd_0/tspc_r_1/Qbar 0.01fF
C1199 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C1200 pll_full_buffered2_0/pll_full_0/ro_complete_0/a5 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/v 0.08fF
C1201 pll_full_buffered2_0/pll_full_0/ro_complete_0/a0 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C1202 pll_full_buffered2_0/pll_full_0/pd_0/R pll_full_buffered2_0/pll_full_0/div 0.51fF
C1203 ro_divider_buffered_0/tapered_buf_4/in2 ro_divider_buffered_0/tapered_buf_4/in3 1.27fF
C1204 div_pd_buffered_0/pd_0/UP div_pd_buffered_0/tapered_buf_0/in1 0.19fF
C1205 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/nor_1/B 1.21fF
C1206 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_buffered2_0/pll_full_0/vco 0.01fF
C1207 pd_buffered_0/pd_0/tspc_r_0/z5 pd_buffered_0/pd_0/tspc_r_0/Z3 0.11fF
C1208 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z1 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1209 divider_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# divider_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1210 div_pd_buffered_0/tapered_buf_2/in1 div_pd_buffered_0/tapered_buf_2/in2 0.37fF
C1211 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1212 io_clamp_low[1] io_clamp_high[1] 0.53fF
C1213 ro_divider_buffered_0/divider_0/and_0/OUT ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1214 pll_full_buffered1_0/pll_full_0/divider_0/and_0/OUT pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1215 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_buffered1_0/pll_full_0/vco 0.45fF
C1216 pll_full_buffered2_0/tapered_buf_4/in2 pll_full_buffered2_0/tapered_buf_4/in1 0.37fF
C1217 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1218 ro_divider_buffered_0/divider_0/tspc_0/Q ro_divider_buffered_0/divider_0/tspc_1/Z4 0.15fF
C1219 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/nor_1/A 0.04fF
C1220 divider_buffered_0/divider_0/tspc_1/Z3 divider_buffered_0/divider_0/nor_1/B 0.38fF
C1221 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1222 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z2 ro_divider_buffered_0/divider_0/clk 0.11fF
C1223 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Qbar pll_full_buffered1_0/pll_full_0/pd_0/and_pd_0/Out1 0.05fF
C1224 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z3 pll_full_buffered1_0/pll_full_0/pd_0/R 0.27fF
C1225 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Qbar 0.01fF
C1226 pll_full_buffered1_0/pll_full_0/cp_0/upbar pll_full_buffered1_0/pll_full_0/pd_0/UP 0.05fF
C1227 ro_complete_buffered_0/tapered_buf_2/in1 ro_complete_buffered_0/tapered_buf_2/in2 0.37fF
C1228 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1229 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1230 pd_buffered_0/pd_0/REF pd_buffered_0/tapered_buf_3/in5 26.29fF
C1231 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C1232 ro_divider_buffered_0/tapered_buf_1/in1 ro_divider_buffered_0/tapered_buf_1/in 0.19fF
C1233 ro_divider_buffered_0/divider_0/tspc_0/Z3 ro_divider_buffered_0/divider_0/tspc_0/Z4 0.65fF
C1234 divider_buffered_0/divider_0/tspc_1/Z1 divider_buffered_0/divider_0/tspc_1/Z2 1.07fF
C1235 divider_buffered_0/divider_0/tspc_0/Z2 divider_buffered_0/divider_0/tspc_0/Z1 1.07fF
C1236 pll_full_buffered2_0/pll_full_0/pd_0/R pll_full_buffered2_0/pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C1237 pll_full_buffered1_0/tapered_buf_1/in4 pll_full_buffered1_0/tapered_buf_1/in3 4.78fF
C1238 div_pd_buffered_0/tapered_buf_2/in5 div_pd_buffered_0/divider_0/mc2 26.29fF
C1239 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/a1 3.18fF
C1240 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C1241 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_5/vin ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C1242 pll_full_buffered2_0/tapered_buf_3/in5 pll_full_buffered2_0/tapered_buf_3/in1 0.22fF
C1243 pll_full_buffered1_0/tapered_buf_2/in3 pll_full_buffered1_0/tapered_buf_2/in5 2.89fF
C1244 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C1245 divider_buffered_0/divider_0/tspc_1/a_630_n680# divider_buffered_0/divider_0/tspc_1/Q 0.04fF
C1246 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z2 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z4 0.36fF
C1247 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z3 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Q 0.05fF
C1248 ro_divider_buffered_0/ro_complete_0/cbank_2/v ro_divider_buffered_0/divider_0/clk 1.36fF
C1249 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/and_0/B 0.08fF
C1250 div_pd_buffered_0/divider_0/tspc_1/Q div_pd_buffered_0/divider_0/nor_0/B 0.22fF
C1251 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C1252 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# div_pd_buffered_0/divider_0/clk 0.01fF
C1253 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z2 divider_buffered_0/divider_0/and_0/OUT 0.06fF
C1254 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_3/vin ro_divider_buffered_0/ro_complete_0/a1 0.14fF
C1255 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_2/vin ro_divider_buffered_0/ro_complete_0/a3 0.09fF
C1256 pd_buffered_0/pd_0/tspc_r_0/z5 pd_buffered_0/pd_0/UP 0.03fF
C1257 pll_full_buffered1_0/tapered_buf_0/in1 pll_full_buffered1_0/pll_full_0/vco 0.19fF
C1258 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Q pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z4 0.15fF
C1259 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/z5 0.20fF
C1260 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C1261 DIGITAL_BUFFER_v1_0/in5 DIGITAL_BUFFER_v1_0/in4 29.21fF
C1262 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C1263 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/divider_0/nor_0/B 0.42fF
C1264 div_pd_buffered_0/divider_0/tspc_1/Z1 div_pd_buffered_0/divider_0/nor_1/B 0.03fF
C1265 div_pd_buffered_0/divider_0/tspc_1/Z3 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# 0.05fF
C1266 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/nor_1/A 0.35fF
C1267 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C1268 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C1269 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 divider_buffered_0/divider_0/clk 0.11fF
C1270 ro_divider_buffered_0/tapered_buf_8/in2 ro_divider_buffered_0/tapered_buf_8/in3 1.27fF
C1271 div_pd_buffered_0/divider_0/nor_0/B div_pd_buffered_0/divider_0/tspc_2/Z2 0.40fF
C1272 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D div_pd_buffered_0/divider_0/clk 0.29fF
C1273 divider_buffered_0/divider_0/mc2 divider_buffered_0/divider_0/and_0/A 0.16fF
C1274 pll_full_buffered2_0/tapered_buf_3/in3 pll_full_buffered2_0/tapered_buf_3/in4 4.78fF
C1275 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z4 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C1276 pd_buffered_0/pd_0/DOWN pd_buffered_0/pd_0/tspc_r_1/Qbar 0.21fF
C1277 pd_buffered_0/pd_0/tspc_r_1/Qbar1 pd_buffered_0/pd_0/R 0.01fF
C1278 pd_buffered_0/tapered_buf_3/in1 pd_buffered_0/tapered_buf_3/in5 0.22fF
C1279 ro_divider_buffered_0/ro_complete_0/a1 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_3/vin 0.14fF
C1280 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C1281 cp_buffered_0/cp_0/a_10_n50# cp_buffered_0/cp_0/a_1710_0# 0.04fF
C1282 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/tspc_r_0/Z1 0.09fF
C1283 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/tspc_r_0/Z2 0.19fF
C1284 div_pd_buffered_0/tapered_buf_3/in3 div_pd_buffered_0/tapered_buf_3/in4 4.78fF
C1285 pll_full_buffered2_0/tapered_buf_3/in5 pll_full_buffered2_0/tapered_buf_3/in4 29.21fF
C1286 divider_buffered_0/divider_0/tspc_0/Z2 divider_buffered_0/divider_0/tspc_0/Z3 0.16fF
C1287 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/v pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/v 0.04fF
C1288 cp_buffered_0/tapered_buf_0/in2 cp_buffered_0/tapered_buf_0/in3 1.27fF
C1289 ro_divider_buffered_0/tapered_buf_1/in5 ro_divider_buffered_0/tapered_buf_1/in1 0.22fF
C1290 ro_divider_buffered_0/divider_0/mc2 ro_divider_buffered_0/divider_0/nor_1/A 0.04fF
C1291 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z4 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1292 ro_divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C1293 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/tspc_1/Q 0.04fF
C1294 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 div_pd_buffered_0/divider_0/and_0/OUT 0.06fF
C1295 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1296 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C1297 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/clk 0.11fF
C1298 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C1299 divider_buffered_0/divider_0/nor_1/A divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C1300 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Q 0.01fF
C1301 pll_full_buffered2_0/tapered_buf_3/in5 pll_full_buffered2_0/tapered_buf_3/out 26.29fF
C1302 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/a4 0.12fF
C1303 pll_full_buffered1_0/pll_full_0/ro_complete_0/a2 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1304 divider_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# divider_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1305 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z3 ro_divider_buffered_0/divider_0/clk 0.45fF
C1306 pd_buffered_0/pd_0/tspc_r_0/Z3 pd_buffered_0/pd_0/R 0.29fF
C1307 ro_complete_buffered_0/tapered_buf_5/in2 ro_complete_buffered_0/tapered_buf_5/in3 1.27fF
C1308 pll_full_buffered2_0/tapered_buf_2/out pll_full_buffered2_0/tapered_buf_2/in5 26.29fF
C1309 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Q pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z3 0.45fF
C1310 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_buffered1_0/pll_full_0/vco 0.45fF
C1311 ro_complete_buffered_0/tapered_buf_1/in3 ro_complete_buffered_0/tapered_buf_1/in4 4.78fF
C1312 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1313 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z2 pll_full_buffered2_0/pll_full_0/pd_0/R 0.21fF
C1314 pll_full_buffered2_0/tapered_buf_3/in pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/z5 0.03fF
C1315 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1316 ro_divider_buffered_0/divider_0/nor_1/B ro_divider_buffered_0/divider_0/mc2 0.06fF
C1317 cp_buffered_0/cp_0/a_1710_n2840# cp_buffered_0/cp_0/upbar 0.29fF
C1318 cp_buffered_0/tapered_buf_2/in3 cp_buffered_0/tapered_buf_2/in5 2.89fF
C1319 pd_buffered_0/tapered_buf_0/in5 pd_buffered_0/tapered_buf_0/in3 2.89fF
C1320 div_pd_buffered_0/tapered_buf_4/in5 div_pd_buffered_0/tapered_buf_4/out 26.29fF
C1321 divider_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# divider_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C1322 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z3 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/B 0.38fF
C1323 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z4 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z1 0.00fF
C1324 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C1325 pll_full_buffered2_0/pll_full_0/ro_complete_0/a2 pll_full_buffered2_0/pll_full_0/vco 0.11fF
C1326 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C1327 divider_buffered_0/divider_0/nor_1/A divider_buffered_0/divider_0/tspc_0/Z4 0.21fF
C1328 pll_full_buffered2_0/pll_full_0/divider_0/nor_0/B pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z1 0.03fF
C1329 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z3 0.05fF
C1330 ro_divider_buffered_0/divider_0/mc2 ro_divider_buffered_0/divider_0/nor_0/B 0.15fF
C1331 ro_divider_buffered_0/tapered_buf_6/in1 ro_divider_buffered_0/tapered_buf_6/in5 0.22fF
C1332 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/nor_0/B 0.47fF
C1333 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/tspc_0/Z3 0.05fF
C1334 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/clk 0.01fF
C1335 ro_divider_buffered_0/divider_0/tspc_0/Z3 ro_divider_buffered_0/divider_0/tspc_0/Q 0.05fF
C1336 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1337 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1338 divider_buffered_0/divider_0/prescaler_0/tspc_2/Q divider_buffered_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C1339 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z2 divider_buffered_0/divider_0/clk 0.11fF
C1340 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z3 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z4 0.65fF
C1341 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1342 pll_full_buffered1_0/pll_full_0/ro_complete_0/a4 pll_full_buffered1_0/pll_full_0/vco 0.01fF
C1343 ro_divider_buffered_0/divider_0/tspc_0/Q ro_divider_buffered_0/divider_0/tspc_1/Z3 0.45fF
C1344 ro_divider_buffered_0/ro_complete_0/a5 ro_divider_buffered_0/ro_complete_0/cbank_2/v 0.08fF
C1345 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z2 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z3 0.16fF
C1346 pll_full_buffered1_0/pll_full_0/divider_0/nor_0/B pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z4 0.22fF
C1347 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_4/vin ro_complete_buffered_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C1348 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.01fF
C1349 ro_divider_buffered_0/ro_complete_0/a5 ro_divider_buffered_0/divider_0/clk 0.10fF
C1350 divider_buffered_0/divider_0/tspc_1/Z1 divider_buffered_0/divider_0/tspc_0/Q 0.01fF
C1351 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C1352 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_buffered2_0/pll_full_0/vco 1.58fF
C1353 ro_divider_buffered_0/tapered_buf_3/in ro_divider_buffered_0/tapered_buf_3/in1 0.19fF
C1354 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/nor_0/B 0.15fF
C1355 divider_buffered_0/divider_0/prescaler_0/Out divider_buffered_0/divider_0/tspc_0/a_630_n680# 0.01fF
C1356 divider_buffered_0/divider_0/nor_0/Z1 divider_buffered_0/divider_0/and_0/B 0.78fF
C1357 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/and_0/out1 0.31fF
C1358 div_pd_buffered_0/divider_0/tspc_1/Z4 div_pd_buffered_0/divider_0/tspc_0/Q 0.15fF
C1359 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z1 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1360 pd_buffered_0/tapered_buf_3/in3 pd_buffered_0/tapered_buf_3/in5 2.89fF
C1361 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered1_0/pll_full_0/divider_0/nor_1/A 0.15fF
C1362 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/a0 0.09fF
C1363 divider_buffered_0/divider_0/tspc_2/Z3 divider_buffered_0/divider_0/tspc_2/Z4 0.65fF
C1364 pll_full_buffered2_0/tapered_buf_3/in1 pll_full_buffered2_0/tapered_buf_3/in2 0.37fF
C1365 ro_divider_buffered_0/divider_0/and_0/B ro_divider_buffered_0/divider_0/and_0/Z1 0.07fF
C1366 pd_buffered_0/tapered_buf_2/in1 pd_buffered_0/pd_0/UP 0.19fF
C1367 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1368 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1369 pd_buffered_0/pd_0/R pd_buffered_0/pd_0/UP 0.45fF
C1370 pll_full_buffered1_0/pll_full_0/divider_0/and_0/B pll_full_buffered1_0/pll_full_0/divider_0/and_0/Z1 0.07fF
C1371 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C1372 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C1373 pll_full_buffered2_0/tapered_buf_0/in2 pll_full_buffered2_0/tapered_buf_0/in1 0.37fF
C1374 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z4 pll_full_buffered2_0/pll_full_0/div 0.02fF
C1375 filter_buffered_0/filter_0/v filter_buffered_0/tapered_buf_1/in5 26.29fF
C1376 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/pd_0/R 0.36fF
C1377 div_pd_buffered_0/pd_0/tspc_r_1/Z1 div_pd_buffered_0/pd_0/tspc_r_1/Z2 0.71fF
C1378 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/tspc_r_1/Z4 0.20fF
C1379 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/tspc_r_1/z5 0.04fF
C1380 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z4 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z3 0.65fF
C1381 pll_full_buffered2_0/pll_full_0/divider_0/and_0/OUT pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C1382 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z2 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1383 ro_divider_buffered_0/tapered_buf_4/in2 ro_divider_buffered_0/tapered_buf_4/in5 0.84fF
C1384 ro_divider_buffered_0/tapered_buf_4/in3 ro_divider_buffered_0/tapered_buf_4/in4 4.78fF
C1385 div_pd_buffered_0/divider_0/tspc_1/Z2 div_pd_buffered_0/divider_0/tspc_1/Z4 0.36fF
C1386 div_pd_buffered_0/divider_0/tspc_1/Z3 div_pd_buffered_0/divider_0/tspc_1/Q 0.05fF
C1387 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/nor_1/B 0.35fF
C1388 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/tspc_0/Z2 0.01fF
C1389 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z2 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1390 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z4 divider_buffered_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C1391 div_pd_buffered_0/divider_0/nor_0/B div_pd_buffered_0/divider_0/and_0/B 0.29fF
C1392 pd_buffered_0/pd_0/tspc_r_1/Z3 pd_buffered_0/pd_0/tspc_r_1/Z2 0.25fF
C1393 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z3 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Qbar1 0.38fF
C1394 pd_buffered_0/tapered_buf_2/in4 pd_buffered_0/tapered_buf_2/in3 4.78fF
C1395 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_buffered1_0/pll_full_0/vco 0.12fF
C1396 ro_divider_buffered_0/divider_0/tspc_1/a_630_n680# ro_divider_buffered_0/divider_0/nor_1/B 0.35fF
C1397 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/v 1.45fF
C1398 filter_buffered_0/tapered_buf_1/in3 filter_buffered_0/tapered_buf_1/in5 2.89fF
C1399 div_pd_buffered_0/tapered_buf_0/in3 div_pd_buffered_0/tapered_buf_0/in5 2.89fF
C1400 pll_full_buffered1_0/pll_full_0/pd_0/DOWN pll_full_buffered1_0/pll_full_0/pd_0/R 0.36fF
C1401 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z1 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z2 0.71fF
C1402 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z3 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z4 0.20fF
C1403 divider_buffered_0/tapered_buf_1/in5 divider_buffered_0/tapered_buf_1/in1 0.22fF
C1404 pll_full_buffered2_0/tapered_buf_5/in5 pll_full_buffered2_0/tapered_buf_5/out 26.29fF
C1405 ro_divider_buffered_0/tapered_buf_0/in4 ro_divider_buffered_0/tapered_buf_0/in3 4.78fF
C1406 ro_divider_buffered_0/divider_0/tspc_1/a_630_n680# ro_divider_buffered_0/divider_0/nor_0/B 0.00fF
C1407 ro_divider_buffered_0/divider_0/prescaler_0/Out ro_divider_buffered_0/divider_0/clk 0.51fF
C1408 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 div_pd_buffered_0/divider_0/and_0/OUT 0.05fF
C1409 ro_complete_buffered_0/tapered_buf_4/in2 ro_complete_buffered_0/tapered_buf_4/in3 1.27fF
C1410 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/a3 0.13fF
C1411 divider_buffered_0/divider_0/nor_1/Z1 divider_buffered_0/divider_0/and_0/A 0.80fF
C1412 ro_divider_buffered_0/divider_0/tspc_2/a_630_n680# ro_divider_buffered_0/divider_0/nor_0/B 0.35fF
C1413 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Q ro_divider_buffered_0/divider_0/clk 0.60fF
C1414 pd_buffered_0/pd_0/tspc_r_1/Z3 pd_buffered_0/pd_0/tspc_r_1/z5 0.11fF
C1415 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1416 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C1417 divider_buffered_0/divider_0/tspc_1/Z2 divider_buffered_0/divider_0/tspc_1/Z3 0.16fF
C1418 pll_full_buffered2_0/pll_full_0/cp_0/a_10_n50# pll_full_buffered2_0/pll_full_0/cp_0/a_1710_0# 0.04fF
C1419 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_buffered1_0/pll_full_0/vco 0.60fF
C1420 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C1421 cp_buffered_0/cp_0/a_1710_0# cp_buffered_0/cp_0/out 0.84fF
C1422 cp_buffered_0/tapered_buf_2/in5 cp_buffered_0/cp_0/upbar 26.29fF
C1423 pll_full_buffered2_0/pll_full_0/ro_complete_0/a2 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1424 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1425 ro_divider_buffered_0/divider_0/nor_1/Z1 ro_divider_buffered_0/divider_0/and_0/A 0.80fF
C1426 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_3/vin ro_divider_buffered_0/divider_0/clk 1.30fF
C1427 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1428 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/A pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C1429 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z4 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z2 0.36fF
C1430 div_pd_buffered_0/divider_0/tspc_0/Z4 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# 0.12fF
C1431 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C1432 divider_buffered_0/tapered_buf_0/in2 divider_buffered_0/tapered_buf_0/in1 0.37fF
C1433 pll_full_buffered2_0/pll_full_0/div pll_full_buffered2_0/pll_full_0/vco 2.26fF
C1434 ro_divider_buffered_0/tapered_buf_7/in ro_divider_buffered_0/tapered_buf_7/in1 0.19fF
C1435 div_pd_buffered_0/divider_0/tspc_1/Q div_pd_buffered_0/divider_0/tspc_2/Z2 0.14fF
C1436 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C1437 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/clk 0.01fF
C1438 ro_complete_buffered_0/tapered_buf_3/in5 ro_complete_buffered_0/tapered_buf_3/in2 0.84fF
C1439 ro_complete_buffered_0/tapered_buf_3/in4 ro_complete_buffered_0/tapered_buf_3/in3 4.78fF
C1440 divider_buffered_0/divider_0/and_0/OUT divider_buffered_0/divider_0/and_0/B 0.01fF
C1441 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_1/vin ro_divider_buffered_0/ro_complete_0/a3 0.13fF
C1442 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_1/vin ro_divider_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C1443 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/Z1 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/B 0.06fF
C1444 ashish_0/vop ashish_0/b 8.93fF
C1445 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z1 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z2 1.07fF
C1446 pll_full_buffered1_0/pll_full_0/ro_complete_0/a1 pll_full_buffered1_0/pll_full_0/vco 0.11fF
C1447 ro_complete_buffered_0/tapered_buf_7/in1 ro_complete_buffered_0/tapered_buf_7/in5 0.22fF
C1448 ro_divider_buffered_0/ro_complete_0/cbank_0/v ro_divider_buffered_0/ro_complete_0/cbank_2/v 0.04fF
C1449 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C1450 pd_buffered_0/pd_0/R pd_buffered_0/pd_0/and_pd_0/Out1 0.33fF
C1451 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/tapered_buf_1/in 0.05fF
C1452 cp_buffered_0/tapered_buf_1/in cp_buffered_0/tapered_buf_1/in1 0.19fF
C1453 div_pd_buffered_0/pd_0/tspc_r_0/Qbar div_pd_buffered_0/pd_0/R 0.03fF
C1454 ro_divider_buffered_0/ro_complete_0/cbank_0/v ro_divider_buffered_0/divider_0/clk 1.27fF
C1455 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z3 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z1 0.09fF
C1456 pll_full_buffered1_0/pll_full_0/ref pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z2 0.19fF
C1457 pll_full_buffered2_0/tapered_buf_1/in2 pll_full_buffered2_0/tapered_buf_1/in5 0.84fF
C1458 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/A pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Q 0.55fF
C1459 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_buffered2_0/pll_full_0/vco 1.46fF
C1460 div_pd_buffered_0/divider_0/tspc_1/Z3 div_pd_buffered_0/divider_0/nor_1/B 0.38fF
C1461 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1462 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1463 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C1464 divider_buffered_0/tapered_buf_2/in1 divider_buffered_0/tapered_buf_2/in2 0.37fF
C1465 cp_buffered_0/tapered_buf_2/in cp_buffered_0/tapered_buf_2/in1 0.19fF
C1466 ro_divider_buffered_0/tapered_buf_8/in2 ro_divider_buffered_0/tapered_buf_8/in5 0.84fF
C1467 ro_divider_buffered_0/tapered_buf_8/in3 ro_divider_buffered_0/tapered_buf_8/in4 4.78fF
C1468 div_pd_buffered_0/divider_0/tspc_2/Z1 div_pd_buffered_0/divider_0/tspc_2/Z3 0.06fF
C1469 div_pd_buffered_0/tapered_buf_2/in1 div_pd_buffered_0/tapered_buf_2/in5 0.22fF
C1470 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_5/vin ro_divider_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C1471 pll_full_buffered1_0/pll_full_0/ro_complete_0/a0 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1472 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z1 pll_full_buffered1_0/pll_full_0/div 0.17fF
C1473 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C1474 pll_full_buffered2_0/tapered_buf_3/in1 pll_full_buffered2_0/tapered_buf_3/in 0.19fF
C1475 ro_complete_buffered_0/tapered_buf_0/in5 ro_complete_buffered_0/tapered_buf_0/in1 0.22fF
C1476 ro_complete_buffered_0/tapered_buf_1/in5 ro_complete_buffered_0/tapered_buf_1/in2 0.84fF
C1477 ro_divider_buffered_0/tapered_buf_2/in2 ro_divider_buffered_0/tapered_buf_2/in5 0.84fF
C1478 cp_buffered_0/tapered_buf_0/in2 cp_buffered_0/tapered_buf_0/in5 0.84fF
C1479 cp_buffered_0/tapered_buf_0/in3 cp_buffered_0/tapered_buf_0/in4 4.78fF
C1480 div_pd_buffered_0/pd_0/tspc_r_0/z5 div_pd_buffered_0/pd_0/UP 0.03fF
C1481 divider_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# 0.19fF
C1482 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Qbar pll_full_buffered1_0/pll_full_0/pd_0/R 0.03fF
C1483 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/tspc_1/Q 0.51fF
C1484 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1485 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1486 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/clk 0.51fF
C1487 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C1488 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Q pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z1 0.01fF
C1489 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/B pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Q 0.22fF
C1490 ro_divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# ro_divider_buffered_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C1491 pd_buffered_0/pd_0/DOWN pd_buffered_0/tapered_buf_0/in1 0.19fF
C1492 pll_full_buffered1_0/pll_full_0/ro_complete_0/a2 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C1493 ro_complete_buffered_0/tapered_buf_5/in2 ro_complete_buffered_0/tapered_buf_5/in5 0.84fF
C1494 ro_complete_buffered_0/tapered_buf_5/in3 ro_complete_buffered_0/tapered_buf_5/in4 4.78fF
C1495 ro_divider_buffered_0/divider_0/nor_1/A ro_divider_buffered_0/divider_0/tspc_0/Z1 0.03fF
C1496 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z4 ro_divider_buffered_0/divider_0/clk 0.12fF
C1497 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_buffered1_0/pll_full_0/divider_0/and_0/OUT 0.06fF
C1498 ro_divider_buffered_0/tapered_buf_1/in3 ro_divider_buffered_0/tapered_buf_1/in5 2.89fF
C1499 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z2 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z4 0.14fF
C1500 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Q pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z4 0.15fF
C1501 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_buffered1_0/pll_full_0/vco 0.12fF
C1502 ro_complete_buffered_0/tapered_buf_1/in2 ro_complete_buffered_0/tapered_buf_1/in1 0.37fF
C1503 ro_divider_buffered_0/tapered_buf_1/in5 ro_divider_buffered_0/divider_0/mc2 26.29fF
C1504 ro_divider_buffered_0/tapered_buf_0/in5 ro_divider_buffered_0/divider_0/Out 26.29fF
C1505 filter_buffered_0/tapered_buf_0/in1 filter_buffered_0/tapered_buf_0/in2 0.37fF
C1506 div_pd_buffered_0/pd_0/and_pd_0/Z1 div_pd_buffered_0/pd_0/UP 0.06fF
C1507 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C1508 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/Z1 pll_full_buffered2_0/pll_full_0/divider_0/and_0/A 0.80fF
C1509 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1510 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/z5 pll_full_buffered1_0/pll_full_0/pd_0/UP 0.03fF
C1511 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/tspc_2/Z2 0.20fF
C1512 divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# divider_buffered_0/divider_0/prescaler_0/Out 0.11fF
C1513 divider_buffered_0/divider_0/nor_1/A divider_buffered_0/divider_0/and_0/A 0.01fF
C1514 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z1 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z2 1.07fF
C1515 pll_full_buffered2_0/pll_full_0/divider_0/nor_0/B pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z3 0.38fF
C1516 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z4 0.12fF
C1517 ro_divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# ro_divider_buffered_0/divider_0/clk 0.01fF
C1518 ro_divider_buffered_0/tapered_buf_6/in3 ro_divider_buffered_0/tapered_buf_6/in5 2.89fF
C1519 ro_complete_buffered_0/tapered_buf_2/in1 ro_complete_buffered_0/tapered_buf_2/in 0.19fF
C1520 pd_buffered_0/pd_0/tspc_r_0/Z2 pd_buffered_0/pd_0/R 0.21fF
C1521 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1522 divider_buffered_0/divider_0/prescaler_0/tspc_0/D divider_buffered_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C1523 divider_buffered_0/divider_0/nor_1/B divider_buffered_0/divider_0/and_0/A 0.26fF
C1524 div_pd_buffered_0/tapered_buf_2/in2 div_pd_buffered_0/tapered_buf_2/in3 1.27fF
C1525 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/B pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z2 0.30fF
C1526 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z2 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z4 0.36fF
C1527 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z3 pll_full_buffered1_0/pll_full_0/div 0.05fF
C1528 ro_complete_buffered_0/ro_complete_0/a5 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C1529 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_4/vin ro_complete_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C1530 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.04fF
C1531 div_pd_buffered_0/tapered_buf_0/in3 div_pd_buffered_0/tapered_buf_0/in2 1.27fF
C1532 pll_full_buffered2_0/pll_full_0/cp_0/upbar pll_full_buffered2_0/pll_full_0/pd_0/UP 0.05fF
C1533 pll_full_buffered2_0/tapered_buf_4/in3 pll_full_buffered2_0/tapered_buf_4/in5 2.89fF
C1534 ro_divider_buffered_0/tapered_buf_3/in1 ro_divider_buffered_0/tapered_buf_3/in2 0.37fF
C1535 divider_buffered_0/divider_0/tspc_1/Z3 divider_buffered_0/divider_0/tspc_0/Q 0.45fF
C1536 divider_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# divider_buffered_0/divider_0/clk 0.01fF
C1537 divider_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# divider_buffered_0/divider_0/prescaler_0/Out 0.21fF
C1538 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z4 0.12fF
C1539 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C1540 pll_full_buffered2_0/tapered_buf_1/in3 pll_full_buffered2_0/tapered_buf_1/in5 2.89fF
C1541 pll_full_buffered1_0/pll_full_0/pd_0/and_pd_0/Z1 pll_full_buffered1_0/pll_full_0/pd_0/UP 0.06fF
C1542 pll_full_buffered2_0/pll_full_0/divider_0/and_0/out1 pll_full_buffered2_0/pll_full_0/divider_0/and_0/Z1 0.36fF
C1543 pd_buffered_0/pd_0/REF pd_buffered_0/pd_0/tspc_r_0/Qbar1 0.12fF
C1544 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1545 pll_full_buffered1_0/pll_full_0/ro_complete_0/a2 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1546 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z3 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1547 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/B pll_full_buffered1_0/pll_full_0/divider_0/nor_0/B 0.47fF
C1548 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1549 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_buffered1_0/pll_full_0/vco 0.14fF
C1550 ro_complete_buffered_0/ro_complete_0/a1 ro_complete_buffered_0/tapered_buf_1/in 0.05fF
C1551 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C1552 div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 div_pd_buffered_0/pd_0/tspc_r_1/z5 0.20fF
C1553 ro_divider_buffered_0/divider_0/tspc_1/a_630_n680# ro_divider_buffered_0/divider_0/tspc_1/Q 0.04fF
C1554 ro_divider_buffered_0/divider_0/prescaler_0/Out ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C1555 ro_divider_buffered_0/divider_0/nor_1/B ro_divider_buffered_0/divider_0/nor_1/A 1.21fF
C1556 ro_divider_buffered_0/tapered_buf_4/in4 ro_divider_buffered_0/tapered_buf_4/in5 29.21fF
C1557 divider_buffered_0/divider_0/nor_1/A divider_buffered_0/divider_0/tspc_1/Z4 0.02fF
C1558 pll_full_buffered2_0/pll_full_0/divider_0/and_0/OUT pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C1559 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_buffered2_0/pll_full_0/vco 0.11fF
C1560 pll_full_buffered2_0/pll_full_0/cp_0/upbar pll_full_buffered2_0/pll_full_0/div 0.45fF
C1561 pll_full_buffered2_0/tapered_buf_1/in3 pll_full_buffered2_0/tapered_buf_1/in4 4.78fF
C1562 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C1563 divider_buffered_0/divider_0/nor_1/B divider_buffered_0/divider_0/tspc_1/Z4 0.21fF
C1564 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z2 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C1565 ro_complete_buffered_0/tapered_buf_2/in1 ro_complete_buffered_0/tapered_buf_2/in5 0.22fF
C1566 pd_buffered_0/pd_0/tspc_r_1/Z3 pd_buffered_0/pd_0/R 0.27fF
C1567 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C1568 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/A pll_full_buffered1_0/pll_full_0/divider_0/nor_1/B 1.21fF
C1569 io_clamp_low[0] io_clamp_high[0] 0.53fF
C1570 ro_divider_buffered_0/divider_0/tspc_1/Q ro_divider_buffered_0/divider_0/tspc_2/a_630_n680# 0.01fF
C1571 ro_divider_buffered_0/ro_complete_0/a2 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1572 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1573 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z4 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C1574 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_buffered2_0/tapered_buf_3/in 0.11fF
C1575 pd_buffered_0/tapered_buf_0/in1 pd_buffered_0/tapered_buf_0/in2 0.37fF
C1576 pd_buffered_0/tapered_buf_2/in2 pd_buffered_0/tapered_buf_2/in3 1.27fF
C1577 pll_full_buffered2_0/tapered_buf_0/in2 pll_full_buffered2_0/tapered_buf_0/in3 1.27fF
C1578 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1579 pd_buffered_0/tapered_buf_0/in4 pd_buffered_0/tapered_buf_0/in5 29.21fF
C1580 divider_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# divider_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1581 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/nor_1/B 0.06fF
C1582 div_pd_buffered_0/pd_0/and_pd_0/Out1 div_pd_buffered_0/pd_0/and_pd_0/Z1 0.18fF
C1583 ro_complete_buffered_0/tapered_buf_2/in3 ro_complete_buffered_0/tapered_buf_2/in2 1.27fF
C1584 ro_divider_buffered_0/divider_0/nor_1/B ro_divider_buffered_0/divider_0/nor_0/B 0.47fF
C1585 ro_divider_buffered_0/divider_0/prescaler_0/Out ro_divider_buffered_0/divider_0/tspc_0/Z2 0.11fF
C1586 pd_buffered_0/pd_0/tspc_r_0/Z1 pd_buffered_0/pd_0/REF 0.17fF
C1587 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/z5 0.20fF
C1588 div_pd_buffered_0/tapered_buf_0/in5 div_pd_buffered_0/tapered_buf_0/out 26.29fF
C1589 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C1590 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C1591 divider_buffered_0/tapered_buf_2/in3 divider_buffered_0/tapered_buf_2/in4 4.78fF
C1592 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_buffered2_0/pll_full_0/div 0.03fF
C1593 pll_full_buffered2_0/pll_full_0/divider_0/and_0/OUT pll_full_buffered2_0/pll_full_0/vco 0.06fF
C1594 divider_buffered_0/divider_0/mc2 divider_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.33fF
C1595 ro_complete_buffered_0/tapered_buf_4/in2 ro_complete_buffered_0/tapered_buf_4/in5 0.84fF
C1596 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/B pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/a_630_n680# 0.35fF
C1597 ro_divider_buffered_0/divider_0/and_0/OUT ro_divider_buffered_0/divider_0/and_0/Z1 0.04fF
C1598 ro_divider_buffered_0/divider_0/tspc_2/a_630_n680# ro_divider_buffered_0/divider_0/tspc_2/Z2 0.01fF
C1599 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Q ro_divider_buffered_0/divider_0/clk 0.05fF
C1600 pll_full_buffered2_0/tapered_buf_2/in2 pll_full_buffered2_0/tapered_buf_2/in5 0.84fF
C1601 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_1/vin ro_divider_buffered_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C1602 pll_full_buffered1_0/pll_full_0/divider_0/and_0/OUT pll_full_buffered1_0/pll_full_0/divider_0/and_0/Z1 0.04fF
C1603 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_buffered1_0/pll_full_0/vco 0.05fF
C1604 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/a3 2.04fF
C1605 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C1606 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z3 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1607 div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 div_pd_buffered_0/pd_0/UP 0.11fF
C1608 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z1 0.06fF
C1609 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_buffered2_0/pll_full_0/vco 0.64fF
C1610 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C1611 ro_divider_buffered_0/divider_0/mc2 ro_divider_buffered_0/divider_0/and_0/B 0.20fF
C1612 ro_divider_buffered_0/tapered_buf_7/in1 ro_divider_buffered_0/tapered_buf_7/in2 0.37fF
C1613 pll_full_buffered1_0/pll_full_0/pd_0/and_pd_0/Out1 pll_full_buffered1_0/pll_full_0/pd_0/and_pd_0/Z1 0.18fF
C1614 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/and_0/B 0.31fF
C1615 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C1616 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q div_pd_buffered_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C1617 ro_divider_buffered_0/ro_complete_0/a4 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C1618 pd_buffered_0/pd_0/tspc_r_0/Z3 pd_buffered_0/pd_0/UP 0.03fF
C1619 ro_complete_buffered_0/tapered_buf_7/in3 ro_complete_buffered_0/tapered_buf_7/in5 2.89fF
C1620 ro_divider_buffered_0/divider_0/and_0/out1 ro_divider_buffered_0/divider_0/and_0/B 0.18fF
C1621 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_3/vin ro_divider_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C1622 ro_complete_buffered_0/ro_complete_0/a1 ro_complete_buffered_0/ro_complete_0/a0 3.46fF
C1623 ro_complete_buffered_0/tapered_buf_1/in1 ro_complete_buffered_0/tapered_buf_1/in 0.19fF
C1624 ro_complete_buffered_0/ro_complete_0/a3 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1625 pll_full_buffered2_0/tapered_buf_0/in2 pll_full_buffered2_0/tapered_buf_0/in5 0.84fF
C1626 divider_buffered_0/divider_0/tspc_0/Z2 divider_buffered_0/divider_0/prescaler_0/Out 0.11fF
C1627 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C1628 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1629 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z3 pll_full_buffered2_0/pll_full_0/div 0.65fF
C1630 cp_buffered_0/tapered_buf_1/in1 cp_buffered_0/tapered_buf_1/in2 0.37fF
C1631 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 0.12fF
C1632 divider_buffered_0/divider_0/tspc_0/Z1 divider_buffered_0/divider_0/tspc_0/Z4 0.00fF
C1633 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C1634 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/A pll_full_buffered2_0/pll_full_0/divider_0/and_0/A 0.01fF
C1635 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/nor_1/B 0.01fF
C1636 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C1637 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C1638 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/and_0/B 0.20fF
C1639 ro_divider_buffered_0/tapered_buf_8/in4 ro_divider_buffered_0/tapered_buf_8/in5 29.21fF
C1640 pd_buffered_0/pd_0/DIV pd_buffered_0/pd_0/REF 0.51fF
C1641 div_pd_buffered_0/divider_0/tspc_2/Z1 div_pd_buffered_0/divider_0/tspc_2/Z4 0.00fF
C1642 divider_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# divider_buffered_0/divider_0/clk 0.01fF
C1643 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z2 divider_buffered_0/divider_0/clk 0.11fF
C1644 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z3 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C1645 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1646 divider_buffered_0/divider_0/and_0/out1 divider_buffered_0/divider_0/and_0/A 0.01fF
C1647 ro_divider_buffered_0/divider_0/tspc_0/a_630_n680# ro_divider_buffered_0/divider_0/prescaler_0/Out 0.01fF
C1648 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C1649 ashish_0/vop ashish_0/a 4.11fF
C1650 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/B pll_full_buffered1_0/pll_full_0/divider_0/and_0/B 0.31fF
C1651 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C1652 ro_complete_buffered_0/tapered_buf_1/in5 ro_complete_buffered_0/tapered_buf_1/in3 2.89fF
C1653 io_clamp_high[2] io_analog[6] 0.53fF
C1654 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/tspc_r_0/Z4 0.02fF
C1655 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C1656 ro_divider_buffered_0/divider_0/prescaler_0/Out ro_divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C1657 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z1 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1658 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/A pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z4 0.21fF
C1659 ro_divider_buffered_0/tapered_buf_2/in4 ro_divider_buffered_0/tapered_buf_2/in5 29.21fF
C1660 filter_buffered_0/tapered_buf_1/in1 filter_buffered_0/v 0.19fF
C1661 cp_buffered_0/tapered_buf_0/in4 cp_buffered_0/tapered_buf_0/in5 29.21fF
C1662 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Q pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z3 0.45fF
C1663 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Q 0.04fF
C1664 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/B pll_full_buffered2_0/pll_full_0/divider_0/and_0/A 0.26fF
C1665 pll_full_buffered2_0/tapered_buf_5/in3 pll_full_buffered2_0/tapered_buf_5/in5 2.89fF
C1666 pll_full_buffered2_0/tapered_buf_2/in5 pll_full_buffered2_0/tapered_buf_2/in1 0.22fF
C1667 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 ro_divider_buffered_0/divider_0/and_0/OUT 0.06fF
C1668 ro_divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C1669 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z4 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C1670 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1671 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1672 pll_full_buffered1_0/pll_full_0/ro_complete_0/a2 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C1673 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/a4 0.09fF
C1674 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/a5 0.09fF
C1675 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/B pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Q 0.22fF
C1676 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/A pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z1 0.03fF
C1677 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C1678 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1679 ro_complete_buffered_0/tapered_buf_5/in4 ro_complete_buffered_0/tapered_buf_5/in5 29.21fF
C1680 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C1681 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1682 divider_buffered_0/tapered_buf_1/out divider_buffered_0/tapered_buf_1/in5 26.29fF
C1683 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C1684 pll_full_buffered2_0/tapered_buf_2/in1 pll_full_buffered2_0/pll_full_0/div 0.19fF
C1685 ro_divider_buffered_0/divider_0/tspc_1/a_630_n680# ro_divider_buffered_0/divider_0/tspc_1/Z2 0.01fF
C1686 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z1 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1687 ro_divider_buffered_0/divider_0/tspc_0/a_630_n680# ro_divider_buffered_0/divider_0/tspc_0/Z2 0.01fF
C1688 pll_full_buffered1_0/tapered_buf_2/in pll_full_buffered1_0/tapered_buf_2/in1 0.19fF
C1689 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/A pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z4 0.02fF
C1690 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C1691 ro_divider_buffered_0/tapered_buf_2/in1 ro_divider_buffered_0/tapered_buf_2/in5 0.22fF
C1692 filter_buffered_0/tapered_buf_0/in2 filter_buffered_0/tapered_buf_0/in3 1.27fF
C1693 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C1694 DIGITAL_BUFFER_v1_0/in1 DIGITAL_BUFFER_v1_0/in5 0.22fF
C1695 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z2 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z3 0.16fF
C1696 pll_full_buffered2_0/pll_full_0/divider_0/nor_0/B pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z4 0.22fF
C1697 ro_divider_buffered_0/divider_0/mc2 ro_divider_buffered_0/divider_0/Out 1.14fF
C1698 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_divider_buffered_0/divider_0/clk 0.01fF
C1699 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 div_pd_buffered_0/divider_0/clk 0.11fF
C1700 ro_divider_buffered_0/ro_complete_0/a2 ro_divider_buffered_0/ro_complete_0/a3 3.17fF
C1701 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/Out 0.05fF
C1702 divider_buffered_0/divider_0/tspc_0/Z3 divider_buffered_0/divider_0/tspc_0/Z4 0.65fF
C1703 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/B pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Q 0.51fF
C1704 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z1 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z3 0.06fF
C1705 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C1706 pll_full_buffered1_0/pll_full_0/ro_complete_0/a5 pll_full_buffered1_0/pll_full_0/vco 0.15fF
C1707 div_pd_buffered_0/tapered_buf_2/in3 div_pd_buffered_0/tapered_buf_2/in4 4.78fF
C1708 ro_complete_buffered_0/tapered_buf_2/in5 ro_complete_buffered_0/ro_complete_0/a0 26.29fF
C1709 ro_divider_buffered_0/divider_0/nor_0/Z1 ro_divider_buffered_0/divider_0/nor_1/B 0.18fF
C1710 div_pd_buffered_0/pd_0/tspc_r_0/Z4 div_pd_buffered_0/pd_0/tspc_r_0/z5 0.04fF
C1711 ro_divider_buffered_0/divider_0/nor_0/Z1 ro_divider_buffered_0/divider_0/nor_0/B 0.06fF
C1712 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_2/vin ro_divider_buffered_0/divider_0/clk 1.30fF
C1713 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/B pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z4 0.21fF
C1714 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1715 pll_full_buffered2_0/pll_full_0/ro_complete_0/a0 pll_full_buffered2_0/pll_full_0/vco 0.11fF
C1716 ro_divider_buffered_0/tapered_buf_3/in2 ro_divider_buffered_0/tapered_buf_3/in3 1.27fF
C1717 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1718 divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# divider_buffered_0/divider_0/and_0/OUT 0.14fF
C1719 pll_full_buffered2_0/pll_full_0/divider_0/and_0/A pll_full_buffered2_0/pll_full_0/divider_0/and_0/B 0.18fF
C1720 ro_divider_buffered_0/tapered_buf_4/in5 ro_divider_buffered_0/ro_complete_0/a4 26.29fF
C1721 divider_buffered_0/tapered_buf_1/in3 divider_buffered_0/tapered_buf_1/in2 1.27fF
C1722 ro_divider_buffered_0/ro_complete_0/a1 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_4/vin 0.03fF
C1723 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1724 pll_full_buffered1_0/tapered_buf_1/in5 pll_full_buffered1_0/tapered_buf_1/in3 2.89fF
C1725 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/B pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z2 0.20fF
C1726 ro_complete_buffered_0/tapered_buf_0/in3 ro_complete_buffered_0/tapered_buf_0/in4 4.78fF
C1727 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z2 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z1 1.07fF
C1728 ro_divider_buffered_0/ro_complete_0/a0 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1729 div_pd_buffered_0/tapered_buf_3/in5 div_pd_buffered_0/tapered_buf_3/in2 0.84fF
C1730 divider_buffered_0/tapered_buf_2/in5 divider_buffered_0/tapered_buf_2/in2 0.84fF
C1731 ro_divider_buffered_0/tapered_buf_1/in3 ro_divider_buffered_0/tapered_buf_1/in4 4.78fF
C1732 ro_divider_buffered_0/tapered_buf_2/in2 ro_divider_buffered_0/tapered_buf_2/in1 0.37fF
C1733 filter_buffered_0/tapered_buf_1/in2 filter_buffered_0/tapered_buf_1/in3 1.27fF
C1734 divider_buffered_0/divider_0/tspc_0/Z2 divider_buffered_0/divider_0/tspc_0/a_630_n680# 0.01fF
C1735 pd_buffered_0/tapered_buf_1/in2 pd_buffered_0/tapered_buf_1/in3 1.27fF
C1736 pll_full_buffered1_0/pll_full_0/cp_0/vbias pll_full_buffered1_0/pll_full_0/cp_0/a_10_n50# 0.19fF
C1737 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z4 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C1738 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C1739 ro_divider_buffered_0/divider_0/nor_1/B ro_divider_buffered_0/divider_0/tspc_1/Q 0.51fF
C1740 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z2 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C1741 pd_buffered_0/tapered_buf_1/in2 pd_buffered_0/tapered_buf_1/in1 0.37fF
C1742 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C1743 ro_divider_buffered_0/divider_0/tspc_1/Q ro_divider_buffered_0/divider_0/nor_0/B 0.22fF
C1744 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Q ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C1745 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_divider_buffered_0/divider_0/clk 0.01fF
C1746 pd_buffered_0/pd_0/tspc_r_1/Z3 pd_buffered_0/pd_0/tspc_r_1/Z4 0.20fF
C1747 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/A pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.01fF
C1748 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z4 0.12fF
C1749 pll_full_buffered1_0/pll_full_0/ro_complete_0/a0 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C1750 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/z5 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/z5 0.02fF
C1751 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z3 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z2 0.25fF
C1752 pd_buffered_0/tapered_buf_2/in4 pd_buffered_0/tapered_buf_2/in5 29.21fF
C1753 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C1754 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_buffered1_0/pll_full_0/vco 0.01fF
C1755 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_0/vin ro_complete_buffered_0/ro_complete_0/a4 0.12fF
C1756 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1757 pd_buffered_0/tapered_buf_0/in5 pd_buffered_0/tapered_buf_0/out 26.29fF
C1758 pd_buffered_0/pd_0/and_pd_0/Out1 pd_buffered_0/pd_0/UP 0.33fF
C1759 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/R 0.61fF
C1760 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.33fF
C1761 divider_buffered_0/divider_0/tspc_1/Z2 divider_buffered_0/divider_0/tspc_1/Z4 0.36fF
C1762 divider_buffered_0/divider_0/tspc_1/Z3 divider_buffered_0/divider_0/tspc_1/Q 0.05fF
C1763 divider_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# divider_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1764 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z1 divider_buffered_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C1765 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C1766 divider_buffered_0/divider_0/mc2 divider_buffered_0/divider_0/nor_1/A 0.04fF
C1767 pd_buffered_0/pd_0/tspc_r_0/Z2 pd_buffered_0/pd_0/tspc_r_0/Z3 0.25fF
C1768 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_buffered1_0/pll_full_0/pd_0/UP 0.11fF
C1769 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_buffered2_0/pll_full_0/vco 0.26fF
C1770 ro_divider_buffered_0/divider_0/nor_1/B ro_divider_buffered_0/divider_0/tspc_2/Z2 0.20fF
C1771 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1772 divider_buffered_0/divider_0/mc2 divider_buffered_0/divider_0/nor_1/B 0.06fF
C1773 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1774 divider_buffered_0/divider_0/nor_1/B divider_buffered_0/divider_0/tspc_2/Z4 0.02fF
C1775 ro_divider_buffered_0/divider_0/nor_0/B ro_divider_buffered_0/divider_0/tspc_2/Z2 0.40fF
C1776 ro_divider_buffered_0/divider_0/tspc_2/a_630_n680# ro_divider_buffered_0/divider_0/Out 0.04fF
C1777 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/D ro_divider_buffered_0/divider_0/clk 0.29fF
C1778 pd_buffered_0/tapered_buf_1/in4 pd_buffered_0/tapered_buf_1/in5 29.21fF
C1779 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/B pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C1780 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/A pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z2 0.23fF
C1781 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C1782 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_buffered1_0/pll_full_0/vco 1.46fF
C1783 div_pd_buffered_0/tapered_buf_2/in5 div_pd_buffered_0/tapered_buf_2/in3 2.89fF
C1784 ro_complete_buffered_0/tapered_buf_3/in5 ro_complete_buffered_0/ro_complete_0/a1 26.29fF
C1785 pll_full_buffered2_0/tapered_buf_3/in pll_full_buffered2_0/pll_full_0/pd_0/UP 0.61fF
C1786 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/nor_0/B 0.35fF
C1787 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_buffered1_0/pll_full_0/vco 0.29fF
C1788 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/tspc_r_0/Z3 0.65fF
C1789 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1790 div_pd_buffered_0/tapered_buf_4/in1 div_pd_buffered_0/pd_0/DOWN 0.19fF
C1791 pll_full_buffered2_0/pll_full_0/ro_complete_0/a5 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C1792 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1793 div_pd_buffered_0/tapered_buf_1/in5 div_pd_buffered_0/tapered_buf_1/in3 2.89fF
C1794 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z3 0.45fF
C1795 pll_full_buffered2_0/pll_full_0/ro_complete_0/a3 pll_full_buffered2_0/pll_full_0/vco 0.11fF
C1796 pd_buffered_0/pd_0/tspc_r_1/Qbar1 pd_buffered_0/pd_0/tspc_r_1/Z3 0.38fF
C1797 ro_divider_buffered_0/tapered_buf_7/in2 ro_divider_buffered_0/tapered_buf_7/in3 1.27fF
C1798 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q div_pd_buffered_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C1799 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 div_pd_buffered_0/divider_0/clk 0.11fF
C1800 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z2 divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1801 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.05fF
C1802 divider_buffered_0/divider_0/nor_0/B divider_buffered_0/divider_0/tspc_2/Z1 0.03fF
C1803 divider_buffered_0/divider_0/tspc_2/a_630_n680# divider_buffered_0/divider_0/tspc_2/Z3 0.05fF
C1804 pll_full_buffered2_0/tapered_buf_4/in pll_full_buffered2_0/tapered_buf_4/in1 0.19fF
C1805 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1806 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_3/vin ro_divider_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C1807 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1808 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/v pll_full_buffered1_0/pll_full_0/vco 1.27fF
C1809 div_pd_buffered_0/tapered_buf_3/in1 div_pd_buffered_0/tapered_buf_3/in5 0.22fF
C1810 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z3 divider_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.05fF
C1811 pll_full_buffered1_0/pll_full_0/divider_0/and_0/out1 pll_full_buffered1_0/pll_full_0/divider_0/and_0/A 0.01fF
C1812 ro_complete_buffered_0/ro_complete_0/a5 ro_complete_buffered_0/tapered_buf_1/in 0.10fF
C1813 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_5/vin ro_complete_buffered_0/ro_complete_0/a0 0.09fF
C1814 cp_buffered_0/tapered_buf_1/in2 cp_buffered_0/tapered_buf_1/in3 1.27fF
C1815 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/DOWN 0.03fF
C1816 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z1 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1817 pll_full_buffered2_0/tapered_buf_3/in pll_full_buffered2_0/pll_full_0/div 4.07fF
C1818 pll_full_buffered2_0/tapered_buf_1/in1 pll_full_buffered2_0/tapered_buf_1/in2 0.37fF
C1819 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C1820 pll_full_buffered1_0/pll_full_0/ref pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z4 0.02fF
C1821 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C1822 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C1823 divider_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# divider_buffered_0/divider_0/clk 0.01fF
C1824 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C1825 pd_buffered_0/pd_0/tspc_r_0/Z4 pd_buffered_0/pd_0/tspc_r_0/z5 0.04fF
C1826 div_pd_buffered_0/divider_0/tspc_2/Z3 div_pd_buffered_0/divider_0/tspc_2/Z4 0.65fF
C1827 pll_full_buffered1_0/tapered_buf_0/in2 pll_full_buffered1_0/tapered_buf_0/in5 0.84fF
C1828 ro_complete_buffered_0/tapered_buf_1/in5 ro_complete_buffered_0/tapered_buf_1/in4 29.21fF
C1829 io_clamp_low[1] io_analog[5] 0.53fF
C1830 pll_full_buffered2_0/pll_full_0/ro_complete_0/a2 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1831 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/tspc_r_0/z5 0.11fF
C1832 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z3 divider_buffered_0/divider_0/prescaler_0/Out 0.11fF
C1833 pll_full_buffered2_0/tapered_buf_0/in4 pll_full_buffered2_0/tapered_buf_0/in3 4.78fF
C1834 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z1 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z3 0.06fF
C1835 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z2 0.11fF
C1836 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1837 cp_buffered_0/tapered_buf_0/in5 cp_buffered_0/cp_0/down 26.29fF
C1838 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C1839 div_pd_buffered_0/pd_0/R div_pd_buffered_0/pd_0/and_pd_0/Z1 0.02fF
C1840 ro_divider_buffered_0/divider_0/tspc_1/Z2 ro_divider_buffered_0/divider_0/nor_1/A 0.15fF
C1841 ro_divider_buffered_0/divider_0/mc2 ro_divider_buffered_0/divider_0/and_0/OUT 0.05fF
C1842 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C1843 ro_divider_buffered_0/tapered_buf_5/in1 ro_divider_buffered_0/tapered_buf_5/in5 0.22fF
C1844 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z3 pll_full_buffered1_0/pll_full_0/pd_0/DOWN 0.03fF
C1845 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1846 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1847 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Q pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z4 0.15fF
C1848 divider_buffered_0/divider_0/and_0/OUT divider_buffered_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C1849 divider_buffered_0/divider_0/prescaler_0/Out divider_buffered_0/divider_0/clk 0.51fF
C1850 pll_full_buffered2_0/pll_full_0/ref pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z3 0.65fF
C1851 ro_divider_buffered_0/divider_0/nor_1/A ro_divider_buffered_0/divider_0/and_0/B 0.08fF
C1852 ro_divider_buffered_0/divider_0/and_0/OUT ro_divider_buffered_0/divider_0/and_0/out1 0.31fF
C1853 ro_divider_buffered_0/ro_complete_0/a1 ro_divider_buffered_0/ro_complete_0/a0 3.46fF
C1854 ro_divider_buffered_0/divider_0/tspc_0/Q ro_divider_buffered_0/divider_0/tspc_1/a_630_n680# 0.01fF
C1855 ro_divider_buffered_0/ro_complete_0/a3 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1856 pll_full_buffered2_0/tapered_buf_3/in pll_full_buffered2_0/pll_full_0/pd_0/and_pd_0/Out1 0.12fF
C1857 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Qbar pll_full_buffered2_0/pll_full_0/pd_0/UP 0.21fF
C1858 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_1/vin ro_complete_buffered_0/ro_complete_0/a3 0.13fF
C1859 divider_buffered_0/tapered_buf_2/in5 divider_buffered_0/tapered_buf_2/in3 2.89fF
C1860 pll_full_buffered2_0/tapered_buf_0/in pll_full_buffered2_0/tapered_buf_0/in1 0.19fF
C1861 ro_divider_buffered_0/divider_0/nor_1/B ro_divider_buffered_0/divider_0/tspc_1/Z2 0.30fF
C1862 divider_buffered_0/tapered_buf_1/in5 divider_buffered_0/tapered_buf_1/in4 29.21fF
C1863 divider_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# divider_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C1864 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z4 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/a_630_n680# 0.12fF
C1865 filter_buffered_0/tapered_buf_0/in2 filter_buffered_0/tapered_buf_0/in5 0.84fF
C1866 filter_buffered_0/tapered_buf_0/in3 filter_buffered_0/tapered_buf_0/in4 4.78fF
C1867 pll_full_buffered1_0/tapered_buf_2/in1 pll_full_buffered1_0/tapered_buf_2/in2 0.37fF
C1868 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/and_0/OUT 0.05fF
C1869 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C1870 ro_divider_buffered_0/divider_0/nor_1/B ro_divider_buffered_0/divider_0/and_0/B 0.31fF
C1871 ro_divider_buffered_0/divider_0/tspc_0/Z4 ro_divider_buffered_0/divider_0/tspc_0/Z1 0.00fF
C1872 pll_full_buffered1_0/pll_full_0/pd_0/R pll_full_buffered1_0/pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C1873 ro_complete_buffered_0/tapered_buf_2/in2 ro_complete_buffered_0/tapered_buf_2/in5 0.84fF
C1874 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z2 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z4 0.36fF
C1875 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z3 pll_full_buffered2_0/pll_full_0/div 0.05fF
C1876 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1877 divider_buffered_0/divider_0/tspc_1/Z4 divider_buffered_0/divider_0/tspc_0/Q 0.15fF
C1878 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_3/vin ro_divider_buffered_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1879 ro_divider_buffered_0/ro_complete_0/a4 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C1880 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z1 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z4 0.00fF
C1881 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_buffered1_0/pll_full_0/vco 0.11fF
C1882 pll_full_buffered2_0/tapered_buf_5/in pll_full_buffered2_0/tapered_buf_5/in1 0.19fF
C1883 ro_divider_buffered_0/divider_0/nor_0/B ro_divider_buffered_0/divider_0/and_0/B 0.29fF
C1884 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_1/vin ro_divider_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C1885 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_3/vin ro_complete_buffered_0/tapered_buf_1/in 1.30fF
C1886 pll_full_buffered2_0/tapered_buf_0/in5 pll_full_buffered2_0/tapered_buf_0/in4 29.21fF
C1887 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.33fF
C1888 pll_full_buffered2_0/pll_full_0/ro_complete_0/a3 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1889 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1890 ro_divider_buffered_0/tapered_buf_3/in2 ro_divider_buffered_0/tapered_buf_3/in5 0.84fF
C1891 ro_divider_buffered_0/tapered_buf_3/in3 ro_divider_buffered_0/tapered_buf_3/in4 4.78fF
C1892 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/and_0/B 0.01fF
C1893 divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# divider_buffered_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C1894 divider_buffered_0/divider_0/mc2 divider_buffered_0/divider_0/and_0/out1 0.06fF
C1895 divider_buffered_0/divider_0/nor_1/Z1 divider_buffered_0/divider_0/nor_1/B 0.06fF
C1896 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z2 ro_divider_buffered_0/divider_0/and_0/OUT 0.05fF
C1897 ro_complete_buffered_0/tapered_buf_4/in3 ro_complete_buffered_0/tapered_buf_4/in5 2.89fF
C1898 ro_divider_buffered_0/tapered_buf_8/in5 ro_divider_buffered_0/ro_complete_0/a0 26.29fF
C1899 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_buffered1_0/pll_full_0/divider_0/and_0/OUT 0.05fF
C1900 DIGITAL_BUFFER_v1_0/in3 DIGITAL_BUFFER_v1_0/in4 4.79fF
C1901 ro_complete_buffered_0/tapered_buf_0/in4 ro_complete_buffered_0/tapered_buf_0/in5 29.21fF
C1902 div_pd_buffered_0/tapered_buf_3/in5 div_pd_buffered_0/tapered_buf_3/in4 29.21fF
C1903 ro_complete_buffered_0/ro_complete_0/a0 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1904 ro_complete_buffered_0/ro_complete_0/cbank_0/v ro_complete_buffered_0/tapered_buf_1/in 1.27fF
C1905 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1906 filter_buffered_0/tapered_buf_1/in2 filter_buffered_0/tapered_buf_1/in5 0.84fF
C1907 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/B pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z4 0.02fF
C1908 pll_full_buffered2_0/pll_full_0/divider_0/and_0/OUT pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1909 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_buffered2_0/pll_full_0/vco 0.45fF
C1910 pll_full_buffered2_0/tapered_buf_5/in2 pll_full_buffered2_0/tapered_buf_5/in3 1.27fF
C1911 ro_divider_buffered_0/divider_0/tspc_0/Z4 ro_divider_buffered_0/divider_0/nor_1/A 0.21fF
C1912 pd_buffered_0/pd_0/tspc_r_0/Qbar pd_buffered_0/pd_0/DOWN 0.02fF
C1913 pll_full_buffered1_0/pll_full_0/ref pll_full_buffered1_0/pll_full_0/pd_0/R 0.61fF
C1914 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1915 div_pd_buffered_0/divider_0/nor_0/Z1 div_pd_buffered_0/divider_0/nor_0/B 0.06fF
C1916 ro_complete_buffered_0/tapered_buf_2/in3 ro_complete_buffered_0/tapered_buf_2/in5 2.89fF
C1917 pd_buffered_0/pd_0/tspc_r_0/Qbar pd_buffered_0/pd_0/tspc_r_0/Qbar1 0.01fF
C1918 ro_divider_buffered_0/divider_0/tspc_1/Q ro_divider_buffered_0/divider_0/tspc_2/Z2 0.14fF
C1919 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Q ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C1920 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_divider_buffered_0/divider_0/clk 0.01fF
C1921 pll_full_buffered1_0/pll_full_0/ro_complete_0/a0 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1922 DIGITAL_BUFFER_v1_0/in3 DIGITAL_BUFFER_v1_0/in5 3.73fF
C1923 ro_divider_buffered_0/divider_0/tspc_0/Z3 ro_divider_buffered_0/divider_0/prescaler_0/Out 0.45fF
C1924 pd_buffered_0/tapered_buf_2/in2 pd_buffered_0/tapered_buf_2/in5 0.84fF
C1925 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Q pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C1926 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C1927 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_buffered1_0/pll_full_0/vco 0.01fF
C1928 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C1929 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Qbar pll_full_buffered2_0/pll_full_0/pd_0/and_pd_0/Out1 0.05fF
C1930 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z3 pll_full_buffered2_0/pll_full_0/pd_0/R 0.27fF
C1931 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Qbar 0.01fF
C1932 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1933 ro_divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1934 div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 div_pd_buffered_0/pd_0/R 0.30fF
C1935 div_pd_buffered_0/tapered_buf_4/in1 div_pd_buffered_0/tapered_buf_4/in5 0.22fF
C1936 divider_buffered_0/tapered_buf_2/in1 divider_buffered_0/tapered_buf_2/in 0.19fF
C1937 ro_divider_buffered_0/tapered_buf_1/in2 ro_divider_buffered_0/tapered_buf_1/in1 0.37fF
C1938 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C1939 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.05fF
C1940 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_5/vin ro_divider_buffered_0/divider_0/clk 1.30fF
C1941 ro_divider_buffered_0/tapered_buf_6/in ro_divider_buffered_0/tapered_buf_6/in1 0.19fF
C1942 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_1/vin ro_divider_buffered_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1943 divider_buffered_0/divider_0/tspc_1/Q divider_buffered_0/divider_0/tspc_2/Z1 0.01fF
C1944 pll_full_buffered2_0/tapered_buf_2/in4 pll_full_buffered2_0/tapered_buf_2/in3 4.78fF
C1945 ro_divider_buffered_0/divider_0/nor_0/B ro_divider_buffered_0/divider_0/Out 0.42fF
C1946 ro_divider_buffered_0/divider_0/tspc_2/Z1 ro_divider_buffered_0/divider_0/tspc_2/Z3 0.06fF
C1947 pd_buffered_0/pd_0/DIV pd_buffered_0/tapered_buf_1/in5 26.29fF
C1948 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/A pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z2 0.15fF
C1949 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/Z1 pll_full_buffered1_0/pll_full_0/divider_0/and_0/B 0.18fF
C1950 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1951 ro_complete_buffered_0/tapered_buf_6/in1 ro_complete_buffered_0/tapered_buf_6/in5 0.22fF
C1952 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z2 0.01fF
C1953 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 0.38fF
C1954 ro_divider_buffered_0/divider_0/tspc_0/Z3 ro_divider_buffered_0/divider_0/tspc_0/Z2 0.16fF
C1955 divider_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C1956 divider_buffered_0/tapered_buf_0/in2 divider_buffered_0/tapered_buf_0/in3 1.27fF
C1957 ro_divider_buffered_0/tapered_buf_7/in2 ro_divider_buffered_0/tapered_buf_7/in5 0.84fF
C1958 ro_divider_buffered_0/tapered_buf_7/in3 ro_divider_buffered_0/tapered_buf_7/in4 4.78fF
C1959 pd_buffered_0/pd_0/tspc_r_1/Z1 pd_buffered_0/pd_0/DIV 0.17fF
C1960 div_pd_buffered_0/tapered_buf_1/in2 div_pd_buffered_0/tapered_buf_1/in3 1.27fF
C1961 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D div_pd_buffered_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C1962 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1963 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1964 pll_full_buffered1_0/pll_full_0/divider_0/nor_0/Z1 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/B 0.18fF
C1965 pll_full_buffered1_0/pll_full_0/ro_complete_0/a4 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C1966 divider_buffered_0/tapered_buf_1/in1 divider_buffered_0/divider_0/Out 0.20fF
C1967 divider_buffered_0/divider_0/tspc_2/Z1 divider_buffered_0/divider_0/tspc_2/Z2 1.07fF
C1968 divider_buffered_0/divider_0/nor_0/B divider_buffered_0/divider_0/tspc_2/Z3 0.38fF
C1969 divider_buffered_0/divider_0/tspc_2/a_630_n680# divider_buffered_0/divider_0/tspc_2/Z4 0.12fF
C1970 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z2 0.01fF
C1971 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z2 0.01fF
C1972 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1973 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1974 ashish_0/b ashish_0/a 7.46fF
C1975 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C1976 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z1 1.07fF
C1977 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z4 divider_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.12fF
C1978 div_pd_buffered_0/tapered_buf_1/in5 div_pd_buffered_0/tapered_buf_1/in1 0.22fF
C1979 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/tspc_r_1/Z1 0.09fF
C1980 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/tspc_r_1/Z2 0.19fF
C1981 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z1 pll_full_buffered2_0/pll_full_0/div 0.17fF
C1982 cp_buffered_0/tapered_buf_1/in2 cp_buffered_0/tapered_buf_1/in5 0.84fF
C1983 cp_buffered_0/tapered_buf_1/in3 cp_buffered_0/tapered_buf_1/in4 4.78fF
C1984 ro_divider_buffered_0/divider_0/nor_0/Z1 ro_divider_buffered_0/divider_0/and_0/B 0.78fF
C1985 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z3 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/z5 0.11fF
C1986 divider_buffered_0/divider_0/nor_1/A divider_buffered_0/divider_0/nor_1/B 1.21fF
C1987 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z1 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Q 0.01fF
C1988 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C1989 div_pd_buffered_0/tapered_buf_1/in1 div_pd_buffered_0/tapered_buf_1/in 0.19fF
C1990 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 divider_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.05fF
C1991 divider_buffered_0/divider_0/prescaler_0/Out divider_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C1992 divider_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# divider_buffered_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C1993 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z2 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1994 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C1995 pll_full_buffered1_0/pll_full_0/ro_complete_0/a3 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1996 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/z5 pll_full_buffered1_0/pll_full_0/div 0.04fF
C1997 divider_buffered_0/divider_0/and_0/out1 divider_buffered_0/divider_0/and_0/Z1 0.36fF
C1998 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_buffered2_0/pll_full_0/pd_0/UP 0.11fF
C1999 pd_buffered_0/tapered_buf_0/in1 pd_buffered_0/tapered_buf_0/in5 0.22fF
C2000 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_buffered1_0/pll_full_0/divider_0/nor_0/B 0.00fF
C2001 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_0/vin ro_complete_buffered_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C2002 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/a4 0.12fF
C2003 pll_full_buffered2_0/pll_full_0/ro_complete_0/a2 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C2004 ro_divider_buffered_0/ro_complete_0/a0 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C2005 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z1 pll_full_buffered2_0/pll_full_0/ref 0.17fF
C2006 ro_divider_buffered_0/divider_0/tspc_0/Q ro_divider_buffered_0/divider_0/nor_1/A 0.55fF
C2007 div_pd_buffered_0/tapered_buf_1/in5 div_pd_buffered_0/tapered_buf_1/in4 29.21fF
C2008 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z4 divider_buffered_0/divider_0/prescaler_0/Out 0.28fF
C2009 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z3 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z1 0.09fF
C2010 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_buffered2_0/pll_full_0/vco 0.45fF
C2011 ro_divider_buffered_0/divider_0/tspc_1/Z1 ro_divider_buffered_0/divider_0/tspc_1/Z4 0.00fF
C2012 ro_divider_buffered_0/tapered_buf_5/in3 ro_divider_buffered_0/tapered_buf_5/in5 2.89fF
C2013 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C2014 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C2015 divider_buffered_0/divider_0/prescaler_0/Out divider_buffered_0/divider_0/tspc_0/Z4 0.12fF
C2016 divider_buffered_0/divider_0/and_0/OUT divider_buffered_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C2017 ro_divider_buffered_0/divider_0/tspc_0/a_630_n680# ro_divider_buffered_0/divider_0/tspc_0/Z3 0.05fF
C2018 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z3 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Qbar1 0.38fF
C2019 ashish_0/vop ashish_0/von 7.97fF
C2020 pd_buffered_0/pd_0/DOWN pd_buffered_0/pd_0/and_pd_0/Z1 0.07fF
C2021 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C2022 ro_divider_buffered_0/divider_0/tspc_0/Q ro_divider_buffered_0/divider_0/nor_1/B 0.22fF
C2023 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_2/vin 0.22fF
C2024 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C2025 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C2026 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z1 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C2027 pll_full_buffered1_0/tapered_buf_2/in2 pll_full_buffered1_0/tapered_buf_2/in3 1.27fF
C2028 div_pd_buffered_0/tapered_buf_0/in2 div_pd_buffered_0/tapered_buf_0/in5 0.84fF
C2029 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C2030 pll_full_buffered2_0/pll_full_0/ro_complete_0/a4 pll_full_buffered2_0/pll_full_0/vco 0.01fF
C2031 filter_buffered_0/tapered_buf_0/in4 filter_buffered_0/tapered_buf_0/in5 29.21fF
C2032 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 ro_divider_buffered_0/divider_0/clk 0.11fF
C2033 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/tspc_0/Q 0.55fF
C2034 divider_buffered_0/divider_0/and_0/OUT divider_buffered_0/divider_0/clk 0.04fF
C2035 ro_divider_buffered_0/ro_complete_0/a2 ro_divider_buffered_0/ro_complete_0/a1 3.18fF
C2036 pll_full_buffered1_0/tapered_buf_1/in1 pll_full_buffered1_0/tapered_buf_1/in5 0.22fF
C2037 pll_full_buffered1_0/pll_full_0/ro_complete_0/a3 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C2038 pll_full_buffered2_0/pll_full_0/ref pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z4 0.02fF
C2039 cp_buffered_0/tapered_buf_2/in1 cp_buffered_0/tapered_buf_2/in5 0.22fF
C2040 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Q pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z2 0.14fF
C2041 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z1 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z4 0.00fF
C2042 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_buffered1_0/pll_full_0/divider_0/and_0/OUT 0.14fF
C2043 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/Out pll_full_buffered1_0/pll_full_0/vco 0.51fF
Xpll_full_buffered1_0 vssa1 vdda1 pll_full_buffered1
Xpd_buffered_0 vdd vssa1 pd_buffered
Xashish_0 ashish_0/von ashish_0/vop ashish_0/a ashish_0/b ashish_0/cm vssa1 vdd ashish
Xcp_buffered_0 vssa1 vdda1 cp_buffered
Xfilter_buffered_0 vssa1 filter_buffered_0/v filter_buffered
Xro_divider_buffered_0 vssa1 vdda1 ro_divider_buffered
Xpll_full_buffered2_0 vssa1 vdda1 pll_full_buffered2
Xdivider_buffered_0 vssa1 vdda1 divider_buffered
Xro_complete_buffered_0 vssa1 ro_complete_buffered
XDIGITAL_BUFFER_v1_0 DIGITAL_BUFFER_v1_0/in1 DIGITAL_BUFFER_v1_0/in3 DIGITAL_BUFFER_v1_0/in4
+ DIGITAL_BUFFER_v1_0/in5 DIGITAL_BUFFER_v1_0/in DIGITAL_BUFFER_v1_0/out DIGITAL_BUFFER_v1
Xdiv_pd_buffered_0 vdda1 vssa1 div_pd_buffered
C2044 io_analog[4] DIGITAL_BUFFER_v1_0/vdd 43.96fF
C2045 io_analog[5] DIGITAL_BUFFER_v1_0/vdd 44.13fF
C2046 io_analog[6] DIGITAL_BUFFER_v1_0/vdd 43.46fF
C2047 io_in_3v3[0] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2048 io_oeb[26] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2049 io_in[0] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2050 io_out[26] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2051 io_out[0] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2052 io_in[26] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2053 io_oeb[0] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2054 io_in_3v3[26] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2055 io_in_3v3[1] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2056 io_oeb[25] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2057 io_in[1] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2058 io_out[25] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2059 io_out[1] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2060 io_in[25] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2061 io_oeb[1] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2062 io_in_3v3[25] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2063 io_in_3v3[2] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2064 io_oeb[24] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2065 io_in[2] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2066 io_out[24] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2067 io_out[2] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2068 io_in[24] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2069 io_oeb[2] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2070 io_in_3v3[24] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2071 io_in_3v3[3] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2072 gpio_noesd[17] DIGITAL_BUFFER_v1_0/vdd 2.32fF
C2073 io_in[3] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2074 gpio_analog[17] DIGITAL_BUFFER_v1_0/vdd 2.30fF
C2075 io_out[3] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2076 io_oeb[3] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2077 io_in_3v3[4] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2078 io_in[4] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2079 io_out[4] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2080 io_oeb[4] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2081 io_oeb[23] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2082 io_out[23] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2083 io_in[23] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2084 io_in_3v3[23] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2085 gpio_noesd[16] DIGITAL_BUFFER_v1_0/vdd 2.30fF
C2086 gpio_analog[16] DIGITAL_BUFFER_v1_0/vdd 2.30fF
C2087 io_in_3v3[5] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2088 io_in[5] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2089 io_out[5] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2090 io_oeb[5] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2091 io_oeb[22] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2092 io_out[22] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2093 io_in[22] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2094 io_in_3v3[22] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2095 gpio_noesd[15] DIGITAL_BUFFER_v1_0/vdd 2.31fF
C2096 gpio_analog[15] DIGITAL_BUFFER_v1_0/vdd 2.30fF
C2097 io_in_3v3[6] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2098 io_in[6] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2099 io_out[6] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2100 io_oeb[6] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2101 io_oeb[21] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2102 io_out[21] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2103 io_in[21] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2104 io_in_3v3[21] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2105 gpio_noesd[14] DIGITAL_BUFFER_v1_0/vdd 2.30fF
C2106 gpio_analog[14] DIGITAL_BUFFER_v1_0/vdd 2.29fF
C2107 vssd2 DIGITAL_BUFFER_v1_0/vdd 38.54fF
C2108 vssd1 DIGITAL_BUFFER_v1_0/vdd 13.04fF
C2109 vdda2 DIGITAL_BUFFER_v1_0/vdd 38.30fF
C2110 io_oeb[20] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2111 io_out[20] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2112 io_in[20] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2113 io_in_3v3[20] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2114 gpio_noesd[13] DIGITAL_BUFFER_v1_0/vdd 2.31fF
C2115 gpio_analog[13] DIGITAL_BUFFER_v1_0/vdd 2.30fF
C2116 gpio_analog[0] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2117 gpio_noesd[0] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2118 io_in_3v3[7] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2119 io_in[7] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2120 io_out[7] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2121 io_oeb[7] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2122 io_oeb[19] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2123 io_out[19] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2124 io_in[19] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2125 io_in_3v3[19] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2126 gpio_noesd[12] DIGITAL_BUFFER_v1_0/vdd 2.32fF
C2127 gpio_analog[12] DIGITAL_BUFFER_v1_0/vdd 2.30fF
C2128 gpio_analog[1] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2129 gpio_noesd[1] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2130 io_in_3v3[8] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2131 io_in[8] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2132 io_out[8] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2133 io_oeb[8] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2134 io_oeb[18] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2135 io_out[18] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2136 io_in[18] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2137 io_in_3v3[18] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2138 gpio_noesd[11] DIGITAL_BUFFER_v1_0/vdd 2.30fF
C2139 gpio_analog[11] DIGITAL_BUFFER_v1_0/vdd 2.29fF
C2140 gpio_analog[2] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2141 gpio_noesd[2] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2142 io_in_3v3[9] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2143 io_in[9] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2144 io_out[9] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2145 io_oeb[9] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2146 io_oeb[17] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2147 io_out[17] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2148 io_in[17] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2149 io_in_3v3[17] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2150 gpio_noesd[10] DIGITAL_BUFFER_v1_0/vdd 2.31fF
C2151 gpio_analog[10] DIGITAL_BUFFER_v1_0/vdd 2.29fF
C2152 gpio_analog[3] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2153 gpio_noesd[3] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2154 io_in_3v3[10] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2155 io_in[10] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2156 io_out[10] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2157 io_oeb[10] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2158 io_oeb[16] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2159 io_out[16] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2160 io_in[16] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2161 io_in_3v3[16] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2162 gpio_noesd[9] DIGITAL_BUFFER_v1_0/vdd 2.28fF
C2163 gpio_analog[9] DIGITAL_BUFFER_v1_0/vdd 2.28fF
C2164 gpio_analog[4] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2165 gpio_noesd[4] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2166 io_in_3v3[11] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2167 io_in[11] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2168 io_out[11] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2169 io_oeb[11] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2170 io_oeb[15] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2171 io_out[15] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2172 io_in[15] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2173 io_in_3v3[15] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2174 gpio_noesd[8] DIGITAL_BUFFER_v1_0/vdd 2.28fF
C2175 gpio_analog[8] DIGITAL_BUFFER_v1_0/vdd 2.26fF
C2176 gpio_analog[5] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2177 gpio_noesd[5] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2178 io_in_3v3[12] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2179 io_in[12] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2180 io_out[12] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2181 io_oeb[12] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2182 io_oeb[14] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2183 io_out[14] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2184 io_in[14] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2185 io_in_3v3[14] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2186 gpio_noesd[7] DIGITAL_BUFFER_v1_0/vdd 2.30fF
C2187 gpio_analog[7] DIGITAL_BUFFER_v1_0/vdd 2.28fF
C2188 vssa2 DIGITAL_BUFFER_v1_0/vdd 38.35fF
C2189 gpio_analog[6] DIGITAL_BUFFER_v1_0/vdd 5.71fF
C2190 gpio_noesd[6] DIGITAL_BUFFER_v1_0/vdd 5.70fF
C2191 io_in_3v3[13] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2192 io_in[13] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2193 io_out[13] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2194 io_oeb[13] DIGITAL_BUFFER_v1_0/vdd 0.61fF
C2195 vccd1 DIGITAL_BUFFER_v1_0/vdd 39.84fF
C2196 vccd2 DIGITAL_BUFFER_v1_0/vdd 38.46fF
C2197 io_analog[0] DIGITAL_BUFFER_v1_0/vdd 19.99fF
C2198 io_analog[10] DIGITAL_BUFFER_v1_0/vdd 19.36fF
C2199 io_analog[1] DIGITAL_BUFFER_v1_0/vdd 13.17fF
C2200 io_analog[2] DIGITAL_BUFFER_v1_0/vdd 12.57fF
C2201 io_analog[3] DIGITAL_BUFFER_v1_0/vdd 12.83fF
C2202 io_clamp_high[0] DIGITAL_BUFFER_v1_0/vdd 3.58fF
C2203 io_clamp_low[0] DIGITAL_BUFFER_v1_0/vdd 3.58fF
C2204 io_clamp_high[1] DIGITAL_BUFFER_v1_0/vdd 3.58fF
C2205 io_clamp_low[1] DIGITAL_BUFFER_v1_0/vdd 3.58fF
C2206 io_clamp_high[2] DIGITAL_BUFFER_v1_0/vdd 3.58fF
C2207 io_clamp_low[2] DIGITAL_BUFFER_v1_0/vdd 3.58fF
C2208 io_analog[7] DIGITAL_BUFFER_v1_0/vdd 12.74fF
C2209 io_analog[8] DIGITAL_BUFFER_v1_0/vdd 13.08fF
C2210 io_analog[9] DIGITAL_BUFFER_v1_0/vdd 13.08fF
C2211 user_irq[2] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2212 user_irq[1] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2213 user_irq[0] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2214 user_clock2 DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2215 la_oenb[127] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2216 la_data_out[127] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2217 la_data_in[127] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2218 la_oenb[126] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2219 la_data_out[126] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2220 la_data_in[126] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2221 la_oenb[125] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2222 la_data_out[125] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2223 la_data_in[125] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2224 la_oenb[124] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2225 la_data_out[124] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2226 la_data_in[124] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2227 la_oenb[123] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2228 la_data_out[123] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2229 la_data_in[123] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2230 la_oenb[122] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2231 la_data_out[122] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2232 la_data_in[122] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2233 la_oenb[121] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2234 la_data_out[121] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2235 la_data_in[121] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2236 la_oenb[120] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2237 la_data_out[120] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2238 la_data_in[120] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2239 la_oenb[119] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2240 la_data_out[119] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2241 la_data_in[119] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2242 la_oenb[118] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2243 la_data_out[118] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2244 la_data_in[118] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2245 la_oenb[117] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2246 la_data_out[117] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2247 la_data_in[117] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2248 la_oenb[116] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2249 la_data_out[116] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2250 la_data_in[116] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2251 la_oenb[115] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2252 la_data_out[115] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2253 la_data_in[115] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2254 la_oenb[114] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2255 la_data_out[114] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2256 la_data_in[114] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2257 la_oenb[113] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2258 la_data_out[113] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2259 la_data_in[113] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2260 la_oenb[112] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2261 la_data_out[112] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2262 la_data_in[112] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2263 la_oenb[111] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2264 la_data_out[111] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2265 la_data_in[111] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2266 la_oenb[110] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2267 la_data_out[110] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2268 la_data_in[110] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2269 la_oenb[109] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2270 la_data_out[109] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2271 la_data_in[109] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2272 la_oenb[108] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2273 la_data_out[108] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2274 la_data_in[108] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2275 la_oenb[107] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2276 la_data_out[107] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2277 la_data_in[107] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2278 la_oenb[106] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2279 la_data_out[106] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2280 la_data_in[106] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2281 la_oenb[105] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2282 la_data_out[105] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2283 la_data_in[105] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2284 la_oenb[104] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2285 la_data_out[104] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2286 la_data_in[104] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2287 la_oenb[103] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2288 la_data_out[103] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2289 la_data_in[103] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2290 la_oenb[102] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2291 la_data_out[102] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2292 la_data_in[102] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2293 la_oenb[101] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2294 la_data_out[101] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2295 la_data_in[101] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2296 la_oenb[100] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2297 la_data_out[100] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2298 la_data_in[100] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2299 la_oenb[99] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2300 la_data_out[99] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2301 la_data_in[99] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2302 la_oenb[98] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2303 la_data_out[98] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2304 la_data_in[98] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2305 la_oenb[97] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2306 la_data_out[97] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2307 la_data_in[97] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2308 la_oenb[96] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2309 la_data_out[96] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2310 la_data_in[96] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2311 la_oenb[95] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2312 la_data_out[95] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2313 la_data_in[95] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2314 la_oenb[94] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2315 la_data_out[94] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2316 la_data_in[94] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2317 la_oenb[93] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2318 la_data_out[93] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2319 la_data_in[93] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2320 la_oenb[92] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2321 la_data_out[92] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2322 la_data_in[92] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2323 la_oenb[91] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2324 la_data_out[91] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2325 la_data_in[91] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2326 la_oenb[90] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2327 la_data_out[90] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2328 la_data_in[90] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2329 la_oenb[89] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2330 la_data_out[89] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2331 la_data_in[89] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2332 la_oenb[88] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2333 la_data_out[88] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2334 la_data_in[88] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2335 la_oenb[87] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2336 la_data_out[87] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2337 la_data_in[87] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2338 la_oenb[86] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2339 la_data_out[86] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2340 la_data_in[86] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2341 la_oenb[85] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2342 la_data_out[85] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2343 la_data_in[85] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2344 la_oenb[84] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2345 la_data_out[84] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2346 la_data_in[84] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2347 la_oenb[83] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2348 la_data_out[83] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2349 la_data_in[83] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2350 la_oenb[82] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2351 la_data_out[82] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2352 la_data_in[82] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2353 la_oenb[81] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2354 la_data_out[81] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2355 la_data_in[81] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2356 la_oenb[80] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2357 la_data_out[80] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2358 la_data_in[80] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2359 la_oenb[79] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2360 la_data_out[79] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2361 la_data_in[79] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2362 la_oenb[78] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2363 la_data_out[78] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2364 la_data_in[78] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2365 la_oenb[77] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2366 la_data_out[77] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2367 la_data_in[77] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2368 la_oenb[76] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2369 la_data_out[76] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2370 la_data_in[76] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2371 la_oenb[75] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2372 la_data_out[75] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2373 la_data_in[75] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2374 la_oenb[74] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2375 la_data_out[74] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2376 la_data_in[74] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2377 la_oenb[73] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2378 la_data_out[73] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2379 la_data_in[73] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2380 la_oenb[72] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2381 la_data_out[72] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2382 la_data_in[72] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2383 la_oenb[71] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2384 la_data_out[71] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2385 la_data_in[71] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2386 la_oenb[70] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2387 la_data_out[70] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2388 la_data_in[70] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2389 la_oenb[69] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2390 la_data_out[69] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2391 la_data_in[69] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2392 la_oenb[68] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2393 la_data_out[68] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2394 la_data_in[68] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2395 la_oenb[67] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2396 la_data_out[67] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2397 la_data_in[67] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2398 la_oenb[66] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2399 la_data_out[66] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2400 la_data_in[66] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2401 la_oenb[65] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2402 la_data_out[65] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2403 la_data_in[65] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2404 la_oenb[64] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2405 la_data_out[64] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2406 la_data_in[64] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2407 la_oenb[63] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2408 la_data_out[63] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2409 la_data_in[63] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2410 la_oenb[62] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2411 la_data_out[62] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2412 la_data_in[62] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2413 la_oenb[61] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2414 la_data_out[61] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2415 la_data_in[61] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2416 la_oenb[60] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2417 la_data_out[60] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2418 la_data_in[60] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2419 la_oenb[59] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2420 la_data_out[59] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2421 la_data_in[59] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2422 la_oenb[58] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2423 la_data_out[58] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2424 la_data_in[58] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2425 la_oenb[57] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2426 la_data_out[57] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2427 la_data_in[57] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2428 la_oenb[56] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2429 la_data_out[56] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2430 la_data_in[56] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2431 la_oenb[55] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2432 la_data_out[55] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2433 la_data_in[55] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2434 la_oenb[54] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2435 la_data_out[54] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2436 la_data_in[54] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2437 la_oenb[53] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2438 la_data_out[53] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2439 la_data_in[53] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2440 la_oenb[52] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2441 la_data_out[52] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2442 la_data_in[52] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2443 la_oenb[51] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2444 la_data_out[51] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2445 la_data_in[51] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2446 la_oenb[50] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2447 la_data_out[50] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2448 la_data_in[50] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2449 la_oenb[49] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2450 la_data_out[49] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2451 la_data_in[49] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2452 la_oenb[48] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2453 la_data_out[48] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2454 la_data_in[48] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2455 la_oenb[47] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2456 la_data_out[47] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2457 la_data_in[47] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2458 la_oenb[46] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2459 la_data_out[46] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2460 la_data_in[46] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2461 la_oenb[45] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2462 la_data_out[45] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2463 la_data_in[45] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2464 la_oenb[44] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2465 la_data_out[44] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2466 la_data_in[44] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2467 la_oenb[43] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2468 la_data_out[43] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2469 la_data_in[43] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2470 la_oenb[42] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2471 la_data_out[42] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2472 la_data_in[42] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2473 la_oenb[41] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2474 la_data_out[41] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2475 la_data_in[41] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2476 la_oenb[40] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2477 la_data_out[40] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2478 la_data_in[40] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2479 la_oenb[39] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2480 la_data_out[39] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2481 la_data_in[39] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2482 la_oenb[38] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2483 la_data_out[38] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2484 la_data_in[38] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2485 la_oenb[37] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2486 la_data_out[37] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2487 la_data_in[37] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2488 la_oenb[36] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2489 la_data_out[36] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2490 la_data_in[36] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2491 la_oenb[35] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2492 la_data_out[35] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2493 la_data_in[35] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2494 la_oenb[34] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2495 la_data_out[34] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2496 la_data_in[34] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2497 la_oenb[33] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2498 la_data_out[33] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2499 la_data_in[33] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2500 la_oenb[32] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2501 la_data_out[32] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2502 la_data_in[32] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2503 la_oenb[31] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2504 la_data_out[31] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2505 la_data_in[31] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2506 la_oenb[30] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2507 la_data_out[30] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2508 la_data_in[30] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2509 la_oenb[29] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2510 la_data_out[29] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2511 la_data_in[29] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2512 la_oenb[28] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2513 la_data_out[28] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2514 la_data_in[28] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2515 la_oenb[27] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2516 la_data_out[27] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2517 la_data_in[27] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2518 la_oenb[26] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2519 la_data_out[26] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2520 la_data_in[26] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2521 la_oenb[25] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2522 la_data_out[25] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2523 la_data_in[25] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2524 la_oenb[24] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2525 la_data_out[24] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2526 la_data_in[24] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2527 la_oenb[23] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2528 la_data_out[23] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2529 la_data_in[23] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2530 la_oenb[22] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2531 la_data_out[22] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2532 la_data_in[22] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2533 la_oenb[21] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2534 la_data_out[21] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2535 la_data_in[21] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2536 la_oenb[20] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2537 la_data_out[20] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2538 la_data_in[20] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2539 la_oenb[19] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2540 la_data_out[19] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2541 la_data_in[19] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2542 la_oenb[18] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2543 la_data_out[18] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2544 la_data_in[18] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2545 la_oenb[17] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2546 la_data_out[17] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2547 la_data_in[17] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2548 la_oenb[16] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2549 la_data_out[16] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2550 la_data_in[16] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2551 la_oenb[15] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2552 la_data_out[15] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2553 la_data_in[15] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2554 la_oenb[14] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2555 la_data_out[14] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2556 la_data_in[14] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2557 la_oenb[13] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2558 la_data_out[13] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2559 la_data_in[13] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2560 la_oenb[12] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2561 la_data_out[12] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2562 la_data_in[12] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2563 la_oenb[11] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2564 la_data_out[11] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2565 la_data_in[11] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2566 la_oenb[10] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2567 la_data_out[10] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2568 la_data_in[10] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2569 la_oenb[9] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2570 la_data_out[9] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2571 la_data_in[9] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2572 la_oenb[8] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2573 la_data_out[8] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2574 la_data_in[8] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2575 la_oenb[7] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2576 la_data_out[7] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2577 la_data_in[7] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2578 la_oenb[6] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2579 la_data_out[6] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2580 la_data_in[6] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2581 la_oenb[5] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2582 la_data_out[5] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2583 la_data_in[5] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2584 la_oenb[4] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2585 la_data_out[4] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2586 la_data_in[4] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2587 la_oenb[3] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2588 la_data_out[3] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2589 la_data_in[3] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2590 la_oenb[2] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2591 la_data_out[2] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2592 la_data_in[2] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2593 la_oenb[1] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2594 la_data_out[1] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2595 la_data_in[1] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2596 la_oenb[0] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2597 la_data_out[0] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2598 la_data_in[0] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2599 wbs_dat_o[31] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2600 wbs_dat_i[31] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2601 wbs_adr_i[31] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2602 wbs_dat_o[30] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2603 wbs_dat_i[30] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2604 wbs_adr_i[30] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2605 wbs_dat_o[29] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2606 wbs_dat_i[29] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2607 wbs_adr_i[29] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2608 wbs_dat_o[28] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2609 wbs_dat_i[28] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2610 wbs_adr_i[28] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2611 wbs_dat_o[27] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2612 wbs_dat_i[27] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2613 wbs_adr_i[27] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2614 wbs_dat_o[26] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2615 wbs_dat_i[26] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2616 wbs_adr_i[26] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2617 wbs_dat_o[25] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2618 wbs_dat_i[25] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2619 wbs_adr_i[25] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2620 wbs_dat_o[24] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2621 wbs_dat_i[24] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2622 wbs_adr_i[24] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2623 wbs_dat_o[23] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2624 wbs_dat_i[23] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2625 wbs_adr_i[23] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2626 wbs_dat_o[22] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2627 wbs_dat_i[22] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2628 wbs_adr_i[22] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2629 wbs_dat_o[21] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2630 wbs_dat_i[21] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2631 wbs_adr_i[21] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2632 wbs_dat_o[20] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2633 wbs_dat_i[20] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2634 wbs_adr_i[20] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2635 wbs_dat_o[19] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2636 wbs_dat_i[19] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2637 wbs_adr_i[19] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2638 wbs_dat_o[18] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2639 wbs_dat_i[18] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2640 wbs_adr_i[18] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2641 wbs_dat_o[17] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2642 wbs_dat_i[17] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2643 wbs_adr_i[17] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2644 wbs_dat_o[16] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2645 wbs_dat_i[16] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2646 wbs_adr_i[16] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2647 wbs_dat_o[15] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2648 wbs_dat_i[15] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2649 wbs_adr_i[15] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2650 wbs_dat_o[14] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2651 wbs_dat_i[14] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2652 wbs_adr_i[14] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2653 wbs_dat_o[13] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2654 wbs_dat_i[13] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2655 wbs_adr_i[13] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2656 wbs_dat_o[12] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2657 wbs_dat_i[12] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2658 wbs_adr_i[12] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2659 wbs_dat_o[11] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2660 wbs_dat_i[11] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2661 wbs_adr_i[11] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2662 wbs_dat_o[10] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2663 wbs_dat_i[10] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2664 wbs_adr_i[10] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2665 wbs_dat_o[9] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2666 wbs_dat_i[9] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2667 wbs_adr_i[9] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2668 wbs_dat_o[8] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2669 wbs_dat_i[8] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2670 wbs_adr_i[8] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2671 wbs_dat_o[7] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2672 wbs_dat_i[7] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2673 wbs_adr_i[7] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2674 wbs_dat_o[6] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2675 wbs_dat_i[6] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2676 wbs_adr_i[6] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2677 wbs_dat_o[5] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2678 wbs_dat_i[5] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2679 wbs_adr_i[5] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2680 wbs_dat_o[4] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2681 wbs_dat_i[4] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2682 wbs_adr_i[4] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2683 wbs_sel_i[3] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2684 wbs_dat_o[3] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2685 wbs_dat_i[3] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2686 wbs_adr_i[3] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2687 wbs_sel_i[2] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2688 wbs_dat_o[2] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2689 wbs_dat_i[2] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2690 wbs_adr_i[2] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2691 wbs_sel_i[1] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2692 wbs_dat_o[1] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2693 wbs_dat_i[1] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2694 wbs_adr_i[1] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2695 wbs_sel_i[0] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2696 wbs_dat_o[0] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2697 wbs_dat_i[0] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2698 wbs_adr_i[0] DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2699 wbs_we_i DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2700 wbs_stb_i DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2701 wbs_cyc_i DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2702 wbs_ack_o DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2703 wb_rst_i DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2704 wb_clk_i DIGITAL_BUFFER_v1_0/vdd 0.63fF
C2705 div_pd_buffered_0/tapered_buf_0/out DIGITAL_BUFFER_v1_0/vdd 385.99fF
C2706 div_pd_buffered_0/tapered_buf_0/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C2707 div_pd_buffered_0/tapered_buf_0/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C2708 div_pd_buffered_0/tapered_buf_0/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C2709 div_pd_buffered_0/tapered_buf_0/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C2710 div_pd_buffered_0/tapered_buf_0/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C2711 div_pd_buffered_0/tapered_buf_1/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C2712 div_pd_buffered_0/tapered_buf_1/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C2713 div_pd_buffered_0/tapered_buf_1/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C2714 div_pd_buffered_0/tapered_buf_1/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C2715 div_pd_buffered_0/tapered_buf_1/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C2716 div_pd_buffered_0/tapered_buf_1/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C2717 div_pd_buffered_0/divider_0/and_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.74fF
C2718 div_pd_buffered_0/divider_0/and_0/B DIGITAL_BUFFER_v1_0/vdd 2.25fF
C2719 div_pd_buffered_0/divider_0/and_0/A DIGITAL_BUFFER_v1_0/vdd 2.19fF
C2720 div_pd_buffered_0/divider_0/and_0/out1 DIGITAL_BUFFER_v1_0/vdd 2.93fF
C2721 div_pd_buffered_0/divider_0/tspc_2/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C2722 div_pd_buffered_0/divider_0/tspc_2/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C2723 div_pd_buffered_0/divider_0/tspc_2/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C2724 div_pd_buffered_0/divider_0/tspc_2/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C2725 div_pd_buffered_0/divider_0/nor_0/B DIGITAL_BUFFER_v1_0/vdd 6.37fF
C2726 div_pd_buffered_0/divider_0/tspc_2/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.14fF **FLOATING
C2727 div_pd_buffered_0/divider_0/tspc_1/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C2728 div_pd_buffered_0/divider_0/tspc_1/Q DIGITAL_BUFFER_v1_0/vdd 3.12fF
C2729 div_pd_buffered_0/divider_0/tspc_1/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C2730 div_pd_buffered_0/divider_0/tspc_1/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C2731 div_pd_buffered_0/divider_0/tspc_1/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C2732 div_pd_buffered_0/divider_0/nor_1/B DIGITAL_BUFFER_v1_0/vdd 7.05fF
C2733 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.15fF **FLOATING
C2734 div_pd_buffered_0/divider_0/tspc_0/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C2735 div_pd_buffered_0/divider_0/tspc_0/Q DIGITAL_BUFFER_v1_0/vdd 3.14fF
C2736 div_pd_buffered_0/divider_0/tspc_0/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C2737 div_pd_buffered_0/divider_0/tspc_0/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C2738 div_pd_buffered_0/divider_0/tspc_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C2739 div_pd_buffered_0/divider_0/nor_1/A DIGITAL_BUFFER_v1_0/vdd 7.04fF
C2740 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.15fF **FLOATING
C2741 div_pd_buffered_0/divider_0/clk DIGITAL_BUFFER_v1_0/vdd 399.62fF
C2742 div_pd_buffered_0/divider_0/prescaler_0/nand_1/z1 DIGITAL_BUFFER_v1_0/vdd 0.36fF
C2743 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D DIGITAL_BUFFER_v1_0/vdd 2.64fF
C2744 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q DIGITAL_BUFFER_v1_0/vdd 3.64fF
C2745 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q DIGITAL_BUFFER_v1_0/vdd 3.61fF
C2746 div_pd_buffered_0/divider_0/prescaler_0/nand_0/z1 DIGITAL_BUFFER_v1_0/vdd 0.36fF
C2747 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D DIGITAL_BUFFER_v1_0/vdd 3.12fF
C2748 div_pd_buffered_0/divider_0/and_0/OUT DIGITAL_BUFFER_v1_0/vdd 5.62fF
C2749 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C2750 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C2751 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C2752 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C2753 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.14fF **FLOATING
C2754 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# DIGITAL_BUFFER_v1_0/vdd 2.11fF **FLOATING
C2755 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C2756 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C2757 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 DIGITAL_BUFFER_v1_0/vdd 1.48fF
C2758 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C2759 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.14fF **FLOATING
C2760 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# DIGITAL_BUFFER_v1_0/vdd 4.22fF **FLOATING
C2761 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C2762 div_pd_buffered_0/divider_0/prescaler_0/Out DIGITAL_BUFFER_v1_0/vdd 4.59fF
C2763 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C2764 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C2765 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C2766 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.16fF **FLOATING
C2767 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# DIGITAL_BUFFER_v1_0/vdd 2.11fF **FLOATING
C2768 div_pd_buffered_0/divider_0/nor_1/Z1 DIGITAL_BUFFER_v1_0/vdd 1.34fF
C2769 div_pd_buffered_0/divider_0/nor_0/Z1 DIGITAL_BUFFER_v1_0/vdd 1.34fF
C2770 div_pd_buffered_0/divider_0/mc2 DIGITAL_BUFFER_v1_0/vdd 393.39fF
C2771 div_pd_buffered_0/pd_0/UP DIGITAL_BUFFER_v1_0/vdd 6.33fF
C2772 div_pd_buffered_0/pd_0/and_pd_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.39fF
C2773 div_pd_buffered_0/pd_0/and_pd_0/Out1 DIGITAL_BUFFER_v1_0/vdd 2.22fF
C2774 div_pd_buffered_0/pd_0/tspc_r_1/z5 DIGITAL_BUFFER_v1_0/vdd 1.10fF
C2775 div_pd_buffered_0/pd_0/tspc_r_1/Z4 DIGITAL_BUFFER_v1_0/vdd 1.07fF
C2776 div_pd_buffered_0/pd_0/R DIGITAL_BUFFER_v1_0/vdd 3.05fF
C2777 div_pd_buffered_0/pd_0/tspc_r_1/Qbar DIGITAL_BUFFER_v1_0/vdd 0.79fF
C2778 div_pd_buffered_0/pd_0/tspc_r_1/Z2 DIGITAL_BUFFER_v1_0/vdd 1.22fF
C2779 div_pd_buffered_0/pd_0/tspc_r_1/Z1 DIGITAL_BUFFER_v1_0/vdd 0.67fF
C2780 div_pd_buffered_0/pd_0/DOWN DIGITAL_BUFFER_v1_0/vdd 9.05fF
C2781 div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 DIGITAL_BUFFER_v1_0/vdd 1.34fF
C2782 div_pd_buffered_0/pd_0/tspc_r_1/Z3 DIGITAL_BUFFER_v1_0/vdd 2.12fF
C2783 div_pd_buffered_0/pd_0/DIV DIGITAL_BUFFER_v1_0/vdd 6.57fF
C2784 div_pd_buffered_0/pd_0/tspc_r_0/z5 DIGITAL_BUFFER_v1_0/vdd 1.10fF
C2785 div_pd_buffered_0/pd_0/tspc_r_0/Z4 DIGITAL_BUFFER_v1_0/vdd 1.07fF
C2786 div_pd_buffered_0/pd_0/tspc_r_0/Qbar DIGITAL_BUFFER_v1_0/vdd 0.88fF
C2787 div_pd_buffered_0/pd_0/tspc_r_0/Z2 DIGITAL_BUFFER_v1_0/vdd 1.22fF
C2788 div_pd_buffered_0/pd_0/tspc_r_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.67fF
C2789 div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 DIGITAL_BUFFER_v1_0/vdd 1.34fF
C2790 div_pd_buffered_0/pd_0/tspc_r_0/Z3 DIGITAL_BUFFER_v1_0/vdd 2.12fF
C2791 div_pd_buffered_0/pd_0/REF DIGITAL_BUFFER_v1_0/vdd 392.16fF
C2792 div_pd_buffered_0/tapered_buf_4/out DIGITAL_BUFFER_v1_0/vdd 385.93fF
C2793 div_pd_buffered_0/tapered_buf_4/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C2794 div_pd_buffered_0/tapered_buf_4/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C2795 div_pd_buffered_0/tapered_buf_4/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C2796 div_pd_buffered_0/tapered_buf_4/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C2797 div_pd_buffered_0/tapered_buf_4/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C2798 div_pd_buffered_0/tapered_buf_3/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C2799 div_pd_buffered_0/tapered_buf_3/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C2800 div_pd_buffered_0/tapered_buf_3/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C2801 div_pd_buffered_0/tapered_buf_3/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C2802 div_pd_buffered_0/tapered_buf_3/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C2803 div_pd_buffered_0/tapered_buf_3/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C2804 div_pd_buffered_0/tapered_buf_2/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C2805 div_pd_buffered_0/tapered_buf_2/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C2806 div_pd_buffered_0/tapered_buf_2/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C2807 div_pd_buffered_0/tapered_buf_2/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C2808 div_pd_buffered_0/tapered_buf_2/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C2809 div_pd_buffered_0/tapered_buf_2/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C2810 DIGITAL_BUFFER_v1_0/out DIGITAL_BUFFER_v1_0/vdd 385.60fF
C2811 DIGITAL_BUFFER_v1_0/in5 DIGITAL_BUFFER_v1_0/vdd 589.56fF
C2812 DIGITAL_BUFFER_v1_0/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C2813 DIGITAL_BUFFER_v1_0/in4 DIGITAL_BUFFER_v1_0/vdd 251.79fF
C2814 DIGITAL_BUFFER_v1_0/in3 DIGITAL_BUFFER_v1_0/vdd 81.89fF
C2815 DIGITAL_BUFFER_v1_0/in1 DIGITAL_BUFFER_v1_0/vdd 5.32fF
C2816 ro_complete_buffered_0/tapered_buf_0/in5 DIGITAL_BUFFER_v1_0/vdd 619.27fF
C2817 ro_complete_buffered_0/tapered_buf_0/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C2818 ro_complete_buffered_0/tapered_buf_0/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C2819 ro_complete_buffered_0/tapered_buf_0/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C2820 ro_complete_buffered_0/tapered_buf_0/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C2821 ro_complete_buffered_0/tapered_buf_0/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C2822 ro_complete_buffered_0/tapered_buf_1/out DIGITAL_BUFFER_v1_0/vdd 385.87fF
C2823 ro_complete_buffered_0/tapered_buf_1/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C2824 ro_complete_buffered_0/tapered_buf_1/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C2825 ro_complete_buffered_0/tapered_buf_1/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C2826 ro_complete_buffered_0/tapered_buf_1/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C2827 ro_complete_buffered_0/tapered_buf_1/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C2828 ro_complete_buffered_0/ro_complete_0/cbank_2/v DIGITAL_BUFFER_v1_0/vdd 16.53fF
C2829 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_5/vin DIGITAL_BUFFER_v1_0/vdd 0.78fF
C2830 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_4/vin DIGITAL_BUFFER_v1_0/vdd 1.50fF
C2831 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_2/vin DIGITAL_BUFFER_v1_0/vdd 1.30fF
C2832 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_3/vin DIGITAL_BUFFER_v1_0/vdd 0.56fF
C2833 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_1/vin DIGITAL_BUFFER_v1_0/vdd 1.14fF
C2834 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_0/vin DIGITAL_BUFFER_v1_0/vdd 1.02fF
C2835 ro_complete_buffered_0/tapered_buf_1/in DIGITAL_BUFFER_v1_0/vdd 26.79fF
C2836 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_5/vin DIGITAL_BUFFER_v1_0/vdd 0.78fF
C2837 ro_complete_buffered_0/ro_complete_0/a0 DIGITAL_BUFFER_v1_0/vdd 416.45fF
C2838 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_4/vin DIGITAL_BUFFER_v1_0/vdd 1.50fF
C2839 ro_complete_buffered_0/ro_complete_0/a1 DIGITAL_BUFFER_v1_0/vdd 412.13fF
C2840 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_2/vin DIGITAL_BUFFER_v1_0/vdd 1.30fF
C2841 ro_complete_buffered_0/ro_complete_0/a3 DIGITAL_BUFFER_v1_0/vdd 402.70fF
C2842 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_3/vin DIGITAL_BUFFER_v1_0/vdd 0.56fF
C2843 ro_complete_buffered_0/ro_complete_0/a2 DIGITAL_BUFFER_v1_0/vdd 407.26fF
C2844 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_1/vin DIGITAL_BUFFER_v1_0/vdd 1.14fF
C2845 ro_complete_buffered_0/ro_complete_0/a4 DIGITAL_BUFFER_v1_0/vdd 398.93fF
C2846 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_0/vin DIGITAL_BUFFER_v1_0/vdd 1.02fF
C2847 ro_complete_buffered_0/ro_complete_0/a5 DIGITAL_BUFFER_v1_0/vdd 395.79fF
C2848 ro_complete_buffered_0/ro_complete_0/cbank_0/v DIGITAL_BUFFER_v1_0/vdd 15.13fF
C2849 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_5/vin DIGITAL_BUFFER_v1_0/vdd 0.78fF
C2850 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_4/vin DIGITAL_BUFFER_v1_0/vdd 1.50fF
C2851 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_2/vin DIGITAL_BUFFER_v1_0/vdd 1.30fF
C2852 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_3/vin DIGITAL_BUFFER_v1_0/vdd 0.56fF
C2853 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_1/vin DIGITAL_BUFFER_v1_0/vdd 1.14fF
C2854 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_0/vin DIGITAL_BUFFER_v1_0/vdd 1.02fF
C2855 ro_complete_buffered_0/tapered_buf_7/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C2856 ro_complete_buffered_0/tapered_buf_7/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C2857 ro_complete_buffered_0/tapered_buf_7/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C2858 ro_complete_buffered_0/tapered_buf_7/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C2859 ro_complete_buffered_0/tapered_buf_7/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C2860 ro_complete_buffered_0/tapered_buf_7/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C2861 ro_complete_buffered_0/tapered_buf_6/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C2862 ro_complete_buffered_0/tapered_buf_6/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C2863 ro_complete_buffered_0/tapered_buf_6/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C2864 ro_complete_buffered_0/tapered_buf_6/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C2865 ro_complete_buffered_0/tapered_buf_6/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C2866 ro_complete_buffered_0/tapered_buf_6/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C2867 ro_complete_buffered_0/tapered_buf_5/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C2868 ro_complete_buffered_0/tapered_buf_5/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C2869 ro_complete_buffered_0/tapered_buf_5/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C2870 ro_complete_buffered_0/tapered_buf_5/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C2871 ro_complete_buffered_0/tapered_buf_5/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C2872 ro_complete_buffered_0/tapered_buf_5/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C2873 ro_complete_buffered_0/tapered_buf_4/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C2874 ro_complete_buffered_0/tapered_buf_4/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C2875 ro_complete_buffered_0/tapered_buf_4/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C2876 ro_complete_buffered_0/tapered_buf_4/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C2877 ro_complete_buffered_0/tapered_buf_4/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C2878 ro_complete_buffered_0/tapered_buf_4/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C2879 ro_complete_buffered_0/tapered_buf_3/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C2880 ro_complete_buffered_0/tapered_buf_3/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C2881 ro_complete_buffered_0/tapered_buf_3/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C2882 ro_complete_buffered_0/tapered_buf_3/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C2883 ro_complete_buffered_0/tapered_buf_3/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C2884 ro_complete_buffered_0/tapered_buf_3/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C2885 ro_complete_buffered_0/tapered_buf_2/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C2886 ro_complete_buffered_0/tapered_buf_2/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C2887 ro_complete_buffered_0/tapered_buf_2/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C2888 ro_complete_buffered_0/tapered_buf_2/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C2889 ro_complete_buffered_0/tapered_buf_2/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C2890 ro_complete_buffered_0/tapered_buf_2/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C2891 divider_buffered_0/tapered_buf_0/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C2892 divider_buffered_0/tapered_buf_0/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C2893 divider_buffered_0/tapered_buf_0/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C2894 divider_buffered_0/tapered_buf_0/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C2895 divider_buffered_0/tapered_buf_0/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C2896 divider_buffered_0/tapered_buf_0/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C2897 divider_buffered_0/tapered_buf_1/out DIGITAL_BUFFER_v1_0/vdd 385.89fF
C2898 divider_buffered_0/tapered_buf_1/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C2899 divider_buffered_0/tapered_buf_1/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C2900 divider_buffered_0/tapered_buf_1/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C2901 divider_buffered_0/tapered_buf_1/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C2902 divider_buffered_0/tapered_buf_1/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C2903 divider_buffered_0/divider_0/and_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.74fF
C2904 divider_buffered_0/divider_0/and_0/B DIGITAL_BUFFER_v1_0/vdd 2.25fF
C2905 divider_buffered_0/divider_0/and_0/A DIGITAL_BUFFER_v1_0/vdd 2.19fF
C2906 divider_buffered_0/divider_0/and_0/out1 DIGITAL_BUFFER_v1_0/vdd 2.93fF
C2907 divider_buffered_0/divider_0/tspc_2/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C2908 divider_buffered_0/divider_0/Out DIGITAL_BUFFER_v1_0/vdd 7.61fF
C2909 divider_buffered_0/divider_0/tspc_2/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C2910 divider_buffered_0/divider_0/tspc_2/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C2911 divider_buffered_0/divider_0/tspc_2/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C2912 divider_buffered_0/divider_0/nor_0/B DIGITAL_BUFFER_v1_0/vdd 6.33fF
C2913 divider_buffered_0/divider_0/tspc_2/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.14fF **FLOATING
C2914 divider_buffered_0/divider_0/tspc_1/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C2915 divider_buffered_0/divider_0/tspc_1/Q DIGITAL_BUFFER_v1_0/vdd 3.12fF
C2916 divider_buffered_0/divider_0/tspc_1/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C2917 divider_buffered_0/divider_0/tspc_1/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C2918 divider_buffered_0/divider_0/tspc_1/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C2919 divider_buffered_0/divider_0/nor_1/B DIGITAL_BUFFER_v1_0/vdd 7.05fF
C2920 divider_buffered_0/divider_0/tspc_1/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.15fF **FLOATING
C2921 divider_buffered_0/divider_0/tspc_0/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C2922 divider_buffered_0/divider_0/tspc_0/Q DIGITAL_BUFFER_v1_0/vdd 3.14fF
C2923 divider_buffered_0/divider_0/tspc_0/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C2924 divider_buffered_0/divider_0/tspc_0/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C2925 divider_buffered_0/divider_0/tspc_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C2926 divider_buffered_0/divider_0/nor_1/A DIGITAL_BUFFER_v1_0/vdd 7.04fF
C2927 divider_buffered_0/divider_0/tspc_0/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.15fF **FLOATING
C2928 divider_buffered_0/divider_0/clk DIGITAL_BUFFER_v1_0/vdd 396.07fF
C2929 divider_buffered_0/divider_0/prescaler_0/nand_1/z1 DIGITAL_BUFFER_v1_0/vdd 0.36fF
C2930 divider_buffered_0/divider_0/prescaler_0/tspc_0/D DIGITAL_BUFFER_v1_0/vdd 2.64fF
C2931 divider_buffered_0/divider_0/prescaler_0/tspc_2/Q DIGITAL_BUFFER_v1_0/vdd 3.70fF
C2932 divider_buffered_0/divider_0/prescaler_0/tspc_1/Q DIGITAL_BUFFER_v1_0/vdd 3.61fF
C2933 divider_buffered_0/divider_0/prescaler_0/nand_0/z1 DIGITAL_BUFFER_v1_0/vdd 0.36fF
C2934 divider_buffered_0/divider_0/prescaler_0/tspc_2/D DIGITAL_BUFFER_v1_0/vdd 3.12fF
C2935 divider_buffered_0/divider_0/and_0/OUT DIGITAL_BUFFER_v1_0/vdd 5.62fF
C2936 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C2937 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C2938 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C2939 divider_buffered_0/divider_0/prescaler_0/tspc_2/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C2940 divider_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.14fF **FLOATING
C2941 divider_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# DIGITAL_BUFFER_v1_0/vdd 2.11fF **FLOATING
C2942 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C2943 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C2944 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 DIGITAL_BUFFER_v1_0/vdd 1.48fF
C2945 divider_buffered_0/divider_0/prescaler_0/tspc_1/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C2946 divider_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.14fF **FLOATING
C2947 divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# DIGITAL_BUFFER_v1_0/vdd 4.22fF **FLOATING
C2948 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C2949 divider_buffered_0/divider_0/prescaler_0/Out DIGITAL_BUFFER_v1_0/vdd 4.59fF
C2950 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C2951 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C2952 divider_buffered_0/divider_0/prescaler_0/tspc_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C2953 divider_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.16fF **FLOATING
C2954 divider_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# DIGITAL_BUFFER_v1_0/vdd 2.11fF **FLOATING
C2955 divider_buffered_0/divider_0/nor_1/Z1 DIGITAL_BUFFER_v1_0/vdd 1.34fF
C2956 divider_buffered_0/divider_0/nor_0/Z1 DIGITAL_BUFFER_v1_0/vdd 1.34fF
C2957 divider_buffered_0/divider_0/mc2 DIGITAL_BUFFER_v1_0/vdd 393.27fF
C2958 divider_buffered_0/tapered_buf_2/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C2959 divider_buffered_0/tapered_buf_2/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C2960 divider_buffered_0/tapered_buf_2/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C2961 divider_buffered_0/tapered_buf_2/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C2962 divider_buffered_0/tapered_buf_2/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C2963 divider_buffered_0/tapered_buf_2/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C2964 pll_full_buffered2_0/tapered_buf_0/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C2965 pll_full_buffered2_0/tapered_buf_0/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C2966 pll_full_buffered2_0/tapered_buf_0/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C2967 pll_full_buffered2_0/tapered_buf_0/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C2968 pll_full_buffered2_0/tapered_buf_0/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C2969 pll_full_buffered2_0/tapered_buf_0/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C2970 pll_full_buffered2_0/tapered_buf_1/in5 DIGITAL_BUFFER_v1_0/vdd 619.27fF
C2971 pll_full_buffered2_0/tapered_buf_1/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C2972 pll_full_buffered2_0/tapered_buf_1/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C2973 pll_full_buffered2_0/tapered_buf_1/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C2974 pll_full_buffered2_0/tapered_buf_1/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C2975 pll_full_buffered2_0/tapered_buf_1/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C2976 pll_full_buffered2_0/pll_full_0/divider_0/and_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.65fF
C2977 pll_full_buffered2_0/pll_full_0/divider_0/and_0/B DIGITAL_BUFFER_v1_0/vdd 2.45fF
C2978 pll_full_buffered2_0/pll_full_0/divider_0/and_0/A DIGITAL_BUFFER_v1_0/vdd 2.35fF
C2979 pll_full_buffered2_0/pll_full_0/divider_0/and_0/out1 DIGITAL_BUFFER_v1_0/vdd 2.99fF
C2980 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C2981 pll_full_buffered2_0/pll_full_0/div DIGITAL_BUFFER_v1_0/vdd 33.25fF
C2982 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C2983 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C2984 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C2985 pll_full_buffered2_0/pll_full_0/divider_0/nor_0/B DIGITAL_BUFFER_v1_0/vdd 6.48fF
C2986 pll_full_buffered2_0/pll_full_0/divider_0/tspc_2/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.14fF **FLOATING
C2987 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C2988 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Q DIGITAL_BUFFER_v1_0/vdd 3.12fF
C2989 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C2990 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C2991 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C2992 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/B DIGITAL_BUFFER_v1_0/vdd 7.12fF
C2993 pll_full_buffered2_0/pll_full_0/divider_0/tspc_1/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.15fF **FLOATING
C2994 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C2995 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Q DIGITAL_BUFFER_v1_0/vdd 3.14fF
C2996 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C2997 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C2998 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C2999 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/A DIGITAL_BUFFER_v1_0/vdd 7.08fF
C3000 pll_full_buffered2_0/pll_full_0/divider_0/tspc_0/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.15fF **FLOATING
C3001 pll_full_buffered2_0/pll_full_0/vco DIGITAL_BUFFER_v1_0/vdd 35.58fF
C3002 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/nand_1/z1 DIGITAL_BUFFER_v1_0/vdd 0.36fF
C3003 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/D DIGITAL_BUFFER_v1_0/vdd 2.64fF
C3004 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Q DIGITAL_BUFFER_v1_0/vdd 3.72fF
C3005 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q DIGITAL_BUFFER_v1_0/vdd 3.61fF
C3006 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/nand_0/z1 DIGITAL_BUFFER_v1_0/vdd 0.36fF
C3007 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/D DIGITAL_BUFFER_v1_0/vdd 3.12fF
C3008 pll_full_buffered2_0/pll_full_0/divider_0/and_0/OUT DIGITAL_BUFFER_v1_0/vdd 5.67fF
C3009 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C3010 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C3011 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z2 DIGITAL_BUFFER_v1_0/vdd 1.19fF
C3012 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C3013 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.47fF **FLOATING
C3014 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# DIGITAL_BUFFER_v1_0/vdd 2.11fF **FLOATING
C3015 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C3016 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C3017 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 DIGITAL_BUFFER_v1_0/vdd 1.48fF
C3018 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C3019 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.14fF **FLOATING
C3020 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# DIGITAL_BUFFER_v1_0/vdd 4.22fF **FLOATING
C3021 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C3022 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/Out DIGITAL_BUFFER_v1_0/vdd 4.59fF
C3023 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C3024 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C3025 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C3026 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.16fF **FLOATING
C3027 pll_full_buffered2_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# DIGITAL_BUFFER_v1_0/vdd 2.11fF **FLOATING
C3028 pll_full_buffered2_0/pll_full_0/divider_0/nor_1/Z1 DIGITAL_BUFFER_v1_0/vdd 1.34fF
C3029 pll_full_buffered2_0/pll_full_0/divider_0/nor_0/Z1 DIGITAL_BUFFER_v1_0/vdd 1.34fF
C3030 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/v DIGITAL_BUFFER_v1_0/vdd 16.43fF
C3031 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_5/vin DIGITAL_BUFFER_v1_0/vdd 0.78fF
C3032 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_4/vin DIGITAL_BUFFER_v1_0/vdd 1.50fF
C3033 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_2/vin DIGITAL_BUFFER_v1_0/vdd 1.30fF
C3034 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_3/vin DIGITAL_BUFFER_v1_0/vdd 0.56fF
C3035 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_1/vin DIGITAL_BUFFER_v1_0/vdd 1.14fF
C3036 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_2/switch_0/vin DIGITAL_BUFFER_v1_0/vdd 1.02fF
C3037 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_5/vin DIGITAL_BUFFER_v1_0/vdd 0.78fF
C3038 pll_full_buffered2_0/pll_full_0/ro_complete_0/a0 DIGITAL_BUFFER_v1_0/vdd 5.35fF
C3039 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_4/vin DIGITAL_BUFFER_v1_0/vdd 1.50fF
C3040 pll_full_buffered2_0/pll_full_0/ro_complete_0/a1 DIGITAL_BUFFER_v1_0/vdd 6.54fF
C3041 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_2/vin DIGITAL_BUFFER_v1_0/vdd 1.30fF
C3042 pll_full_buffered2_0/pll_full_0/ro_complete_0/a3 DIGITAL_BUFFER_v1_0/vdd 5.96fF
C3043 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_3/vin DIGITAL_BUFFER_v1_0/vdd 0.56fF
C3044 pll_full_buffered2_0/pll_full_0/ro_complete_0/a2 DIGITAL_BUFFER_v1_0/vdd 5.21fF
C3045 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_1/vin DIGITAL_BUFFER_v1_0/vdd 1.14fF
C3046 pll_full_buffered2_0/pll_full_0/ro_complete_0/a4 DIGITAL_BUFFER_v1_0/vdd 5.81fF
C3047 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_1/switch_0/vin DIGITAL_BUFFER_v1_0/vdd 1.02fF
C3048 pll_full_buffered2_0/pll_full_0/ro_complete_0/a5 DIGITAL_BUFFER_v1_0/vdd 6.74fF
C3049 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/v DIGITAL_BUFFER_v1_0/vdd 15.12fF
C3050 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_5/vin DIGITAL_BUFFER_v1_0/vdd 0.78fF
C3051 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_4/vin DIGITAL_BUFFER_v1_0/vdd 1.50fF
C3052 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_2/vin DIGITAL_BUFFER_v1_0/vdd 1.30fF
C3053 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_3/vin DIGITAL_BUFFER_v1_0/vdd 0.56fF
C3054 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_1/vin DIGITAL_BUFFER_v1_0/vdd 1.14fF
C3055 pll_full_buffered2_0/pll_full_0/ro_complete_0/cbank_0/switch_0/vin DIGITAL_BUFFER_v1_0/vdd 1.02fF
C3056 pll_full_buffered2_0/pll_full_0/filter_0/a_4216_n5230# DIGITAL_BUFFER_v1_0/vdd 418.90fF **FLOATING
C3057 pll_full_buffered2_0/pll_full_0/filter_0/a_4216_n2998# DIGITAL_BUFFER_v1_0/vdd 1.39fF **FLOATING
C3058 pll_full_buffered2_0/pll_full_0/cp_0/vbias DIGITAL_BUFFER_v1_0/vdd 2.41fF
C3059 pll_full_buffered2_0/pll_full_0/cp_0/a_7110_n2840# DIGITAL_BUFFER_v1_0/vdd 0.17fF **FLOATING
C3060 pll_full_buffered2_0/pll_full_0/cp_0/a_3060_n2840# DIGITAL_BUFFER_v1_0/vdd 1.71fF **FLOATING
C3061 pll_full_buffered2_0/pll_full_0/cp_0/a_7110_0# DIGITAL_BUFFER_v1_0/vdd 0.17fF **FLOATING
C3062 pll_full_buffered2_0/pll_full_0/cp_0/a_6370_0# DIGITAL_BUFFER_v1_0/vdd 0.40fF **FLOATING
C3063 pll_full_buffered2_0/pll_full_0/cp_0/a_3060_0# DIGITAL_BUFFER_v1_0/vdd 2.50fF **FLOATING
C3064 pll_full_buffered2_0/pll_full_0/cp_0/a_1710_0# DIGITAL_BUFFER_v1_0/vdd 7.47fF **FLOATING
C3065 pll_full_buffered2_0/pll_full_0/cp_0/a_10_n50# DIGITAL_BUFFER_v1_0/vdd 2.96fF **FLOATING
C3066 pll_full_buffered2_0/pll_full_0/pd_0/UP DIGITAL_BUFFER_v1_0/vdd 4.55fF
C3067 pll_full_buffered2_0/pll_full_0/pd_0/and_pd_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.39fF
C3068 pll_full_buffered2_0/pll_full_0/pd_0/and_pd_0/Out1 DIGITAL_BUFFER_v1_0/vdd 2.22fF
C3069 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/z5 DIGITAL_BUFFER_v1_0/vdd 1.10fF
C3070 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z4 DIGITAL_BUFFER_v1_0/vdd 1.07fF
C3071 pll_full_buffered2_0/pll_full_0/pd_0/R DIGITAL_BUFFER_v1_0/vdd 3.05fF
C3072 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Qbar DIGITAL_BUFFER_v1_0/vdd 0.79fF
C3073 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z2 DIGITAL_BUFFER_v1_0/vdd 1.22fF
C3074 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z1 DIGITAL_BUFFER_v1_0/vdd 0.67fF
C3075 pll_full_buffered2_0/tapered_buf_3/in DIGITAL_BUFFER_v1_0/vdd 25.17fF
C3076 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Qbar1 DIGITAL_BUFFER_v1_0/vdd 1.34fF
C3077 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_1/Z3 DIGITAL_BUFFER_v1_0/vdd 2.12fF
C3078 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/z5 DIGITAL_BUFFER_v1_0/vdd 1.10fF
C3079 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z4 DIGITAL_BUFFER_v1_0/vdd 1.07fF
C3080 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Qbar DIGITAL_BUFFER_v1_0/vdd 0.88fF
C3081 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z2 DIGITAL_BUFFER_v1_0/vdd 1.22fF
C3082 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.67fF
C3083 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Qbar1 DIGITAL_BUFFER_v1_0/vdd 1.34fF
C3084 pll_full_buffered2_0/pll_full_0/pd_0/tspc_r_0/Z3 DIGITAL_BUFFER_v1_0/vdd 2.12fF
C3085 pll_full_buffered2_0/pll_full_0/ref DIGITAL_BUFFER_v1_0/vdd 390.59fF
C3086 pll_full_buffered2_0/pll_full_0/cp_0/upbar DIGITAL_BUFFER_v1_0/vdd 35.09fF
C3087 pll_full_buffered2_0/tapered_buf_5/out DIGITAL_BUFFER_v1_0/vdd 385.87fF
C3088 pll_full_buffered2_0/tapered_buf_5/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3089 pll_full_buffered2_0/tapered_buf_5/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3090 pll_full_buffered2_0/tapered_buf_5/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3091 pll_full_buffered2_0/tapered_buf_5/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3092 pll_full_buffered2_0/tapered_buf_5/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3093 pll_full_buffered2_0/tapered_buf_5/in DIGITAL_BUFFER_v1_0/vdd 4.76fF
C3094 pll_full_buffered2_0/tapered_buf_4/out DIGITAL_BUFFER_v1_0/vdd 385.89fF
C3095 pll_full_buffered2_0/tapered_buf_4/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3096 pll_full_buffered2_0/tapered_buf_4/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3097 pll_full_buffered2_0/tapered_buf_4/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3098 pll_full_buffered2_0/tapered_buf_4/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3099 pll_full_buffered2_0/tapered_buf_4/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3100 pll_full_buffered2_0/tapered_buf_4/in DIGITAL_BUFFER_v1_0/vdd 2.90fF
C3101 pll_full_buffered2_0/tapered_buf_3/out DIGITAL_BUFFER_v1_0/vdd 385.95fF
C3102 pll_full_buffered2_0/tapered_buf_3/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3103 pll_full_buffered2_0/tapered_buf_3/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3104 pll_full_buffered2_0/tapered_buf_3/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3105 pll_full_buffered2_0/tapered_buf_3/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3106 pll_full_buffered2_0/tapered_buf_3/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3107 pll_full_buffered2_0/tapered_buf_2/out DIGITAL_BUFFER_v1_0/vdd 385.90fF
C3108 pll_full_buffered2_0/tapered_buf_2/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3109 pll_full_buffered2_0/tapered_buf_2/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3110 pll_full_buffered2_0/tapered_buf_2/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3111 pll_full_buffered2_0/tapered_buf_2/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3112 pll_full_buffered2_0/tapered_buf_2/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3113 ro_divider_buffered_0/tapered_buf_1/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3114 ro_divider_buffered_0/tapered_buf_1/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3115 ro_divider_buffered_0/tapered_buf_1/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3116 ro_divider_buffered_0/tapered_buf_1/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3117 ro_divider_buffered_0/tapered_buf_1/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3118 ro_divider_buffered_0/tapered_buf_1/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C3119 ro_divider_buffered_0/tapered_buf_0/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3120 ro_divider_buffered_0/tapered_buf_0/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3121 ro_divider_buffered_0/tapered_buf_0/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3122 ro_divider_buffered_0/tapered_buf_0/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3123 ro_divider_buffered_0/tapered_buf_0/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3124 ro_divider_buffered_0/tapered_buf_0/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C3125 ro_divider_buffered_0/divider_0/and_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.74fF
C3126 ro_divider_buffered_0/divider_0/and_0/B DIGITAL_BUFFER_v1_0/vdd 2.25fF
C3127 ro_divider_buffered_0/divider_0/and_0/A DIGITAL_BUFFER_v1_0/vdd 2.19fF
C3128 ro_divider_buffered_0/divider_0/and_0/out1 DIGITAL_BUFFER_v1_0/vdd 2.93fF
C3129 ro_divider_buffered_0/divider_0/tspc_2/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C3130 ro_divider_buffered_0/divider_0/Out DIGITAL_BUFFER_v1_0/vdd 399.57fF
C3131 ro_divider_buffered_0/divider_0/tspc_2/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C3132 ro_divider_buffered_0/divider_0/tspc_2/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C3133 ro_divider_buffered_0/divider_0/tspc_2/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C3134 ro_divider_buffered_0/divider_0/nor_0/B DIGITAL_BUFFER_v1_0/vdd 6.33fF
C3135 ro_divider_buffered_0/divider_0/tspc_2/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.14fF **FLOATING
C3136 ro_divider_buffered_0/divider_0/tspc_1/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C3137 ro_divider_buffered_0/divider_0/tspc_1/Q DIGITAL_BUFFER_v1_0/vdd 3.12fF
C3138 ro_divider_buffered_0/divider_0/tspc_1/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C3139 ro_divider_buffered_0/divider_0/tspc_1/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C3140 ro_divider_buffered_0/divider_0/tspc_1/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C3141 ro_divider_buffered_0/divider_0/nor_1/B DIGITAL_BUFFER_v1_0/vdd 7.05fF
C3142 ro_divider_buffered_0/divider_0/tspc_1/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.15fF **FLOATING
C3143 ro_divider_buffered_0/divider_0/tspc_0/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C3144 ro_divider_buffered_0/divider_0/tspc_0/Q DIGITAL_BUFFER_v1_0/vdd 3.14fF
C3145 ro_divider_buffered_0/divider_0/tspc_0/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C3146 ro_divider_buffered_0/divider_0/tspc_0/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C3147 ro_divider_buffered_0/divider_0/tspc_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C3148 ro_divider_buffered_0/divider_0/nor_1/A DIGITAL_BUFFER_v1_0/vdd 7.04fF
C3149 ro_divider_buffered_0/divider_0/tspc_0/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.15fF **FLOATING
C3150 ro_divider_buffered_0/divider_0/clk DIGITAL_BUFFER_v1_0/vdd 23.46fF
C3151 ro_divider_buffered_0/divider_0/prescaler_0/nand_1/z1 DIGITAL_BUFFER_v1_0/vdd 0.36fF
C3152 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/D DIGITAL_BUFFER_v1_0/vdd 2.64fF
C3153 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Q DIGITAL_BUFFER_v1_0/vdd 3.69fF
C3154 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Q DIGITAL_BUFFER_v1_0/vdd 3.61fF
C3155 ro_divider_buffered_0/divider_0/prescaler_0/nand_0/z1 DIGITAL_BUFFER_v1_0/vdd 0.36fF
C3156 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/D DIGITAL_BUFFER_v1_0/vdd 3.12fF
C3157 ro_divider_buffered_0/divider_0/and_0/OUT DIGITAL_BUFFER_v1_0/vdd 5.62fF
C3158 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C3159 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C3160 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C3161 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C3162 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.14fF **FLOATING
C3163 ro_divider_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# DIGITAL_BUFFER_v1_0/vdd 2.11fF **FLOATING
C3164 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C3165 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C3166 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z2 DIGITAL_BUFFER_v1_0/vdd 1.48fF
C3167 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C3168 ro_divider_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.14fF **FLOATING
C3169 ro_divider_buffered_0/divider_0/prescaler_0/m1_2700_2190# DIGITAL_BUFFER_v1_0/vdd 4.22fF **FLOATING
C3170 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C3171 ro_divider_buffered_0/divider_0/prescaler_0/Out DIGITAL_BUFFER_v1_0/vdd 4.59fF
C3172 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C3173 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C3174 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C3175 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.16fF **FLOATING
C3176 ro_divider_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# DIGITAL_BUFFER_v1_0/vdd 2.11fF **FLOATING
C3177 ro_divider_buffered_0/divider_0/nor_1/Z1 DIGITAL_BUFFER_v1_0/vdd 1.34fF
C3178 ro_divider_buffered_0/divider_0/nor_0/Z1 DIGITAL_BUFFER_v1_0/vdd 1.34fF
C3179 ro_divider_buffered_0/divider_0/mc2 DIGITAL_BUFFER_v1_0/vdd 397.55fF
C3180 ro_divider_buffered_0/ro_complete_0/cbank_2/v DIGITAL_BUFFER_v1_0/vdd 16.53fF
C3181 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_5/vin DIGITAL_BUFFER_v1_0/vdd 0.78fF
C3182 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_4/vin DIGITAL_BUFFER_v1_0/vdd 1.50fF
C3183 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_2/vin DIGITAL_BUFFER_v1_0/vdd 1.30fF
C3184 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_3/vin DIGITAL_BUFFER_v1_0/vdd 0.56fF
C3185 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_1/vin DIGITAL_BUFFER_v1_0/vdd 1.14fF
C3186 ro_divider_buffered_0/ro_complete_0/cbank_2/switch_0/vin DIGITAL_BUFFER_v1_0/vdd 1.02fF
C3187 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_5/vin DIGITAL_BUFFER_v1_0/vdd 0.78fF
C3188 ro_divider_buffered_0/ro_complete_0/a0 DIGITAL_BUFFER_v1_0/vdd 416.44fF
C3189 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_4/vin DIGITAL_BUFFER_v1_0/vdd 1.50fF
C3190 ro_divider_buffered_0/ro_complete_0/a1 DIGITAL_BUFFER_v1_0/vdd 412.08fF
C3191 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_2/vin DIGITAL_BUFFER_v1_0/vdd 1.30fF
C3192 ro_divider_buffered_0/ro_complete_0/a3 DIGITAL_BUFFER_v1_0/vdd 402.75fF
C3193 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_3/vin DIGITAL_BUFFER_v1_0/vdd 0.56fF
C3194 ro_divider_buffered_0/ro_complete_0/a2 DIGITAL_BUFFER_v1_0/vdd 407.13fF
C3195 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_1/vin DIGITAL_BUFFER_v1_0/vdd 1.14fF
C3196 ro_divider_buffered_0/ro_complete_0/a4 DIGITAL_BUFFER_v1_0/vdd 398.91fF
C3197 ro_divider_buffered_0/ro_complete_0/cbank_1/switch_0/vin DIGITAL_BUFFER_v1_0/vdd 1.02fF
C3198 ro_divider_buffered_0/ro_complete_0/a5 DIGITAL_BUFFER_v1_0/vdd 395.69fF
C3199 ro_divider_buffered_0/ro_complete_0/cbank_0/v DIGITAL_BUFFER_v1_0/vdd 15.13fF
C3200 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_5/vin DIGITAL_BUFFER_v1_0/vdd 0.78fF
C3201 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_4/vin DIGITAL_BUFFER_v1_0/vdd 1.50fF
C3202 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_2/vin DIGITAL_BUFFER_v1_0/vdd 1.30fF
C3203 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_3/vin DIGITAL_BUFFER_v1_0/vdd 0.56fF
C3204 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_1/vin DIGITAL_BUFFER_v1_0/vdd 1.14fF
C3205 ro_divider_buffered_0/ro_complete_0/cbank_0/switch_0/vin DIGITAL_BUFFER_v1_0/vdd 1.02fF
C3206 ro_divider_buffered_0/tapered_buf_8/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3207 ro_divider_buffered_0/tapered_buf_8/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3208 ro_divider_buffered_0/tapered_buf_8/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3209 ro_divider_buffered_0/tapered_buf_8/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3210 ro_divider_buffered_0/tapered_buf_8/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3211 ro_divider_buffered_0/tapered_buf_8/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C3212 ro_divider_buffered_0/tapered_buf_7/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3213 ro_divider_buffered_0/tapered_buf_7/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3214 ro_divider_buffered_0/tapered_buf_7/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3215 ro_divider_buffered_0/tapered_buf_7/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3216 ro_divider_buffered_0/tapered_buf_7/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3217 ro_divider_buffered_0/tapered_buf_7/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C3218 ro_divider_buffered_0/tapered_buf_6/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3219 ro_divider_buffered_0/tapered_buf_6/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3220 ro_divider_buffered_0/tapered_buf_6/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3221 ro_divider_buffered_0/tapered_buf_6/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3222 ro_divider_buffered_0/tapered_buf_6/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3223 ro_divider_buffered_0/tapered_buf_6/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C3224 ro_divider_buffered_0/tapered_buf_5/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3225 ro_divider_buffered_0/tapered_buf_5/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3226 ro_divider_buffered_0/tapered_buf_5/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3227 ro_divider_buffered_0/tapered_buf_5/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3228 ro_divider_buffered_0/tapered_buf_5/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3229 ro_divider_buffered_0/tapered_buf_5/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C3230 ro_divider_buffered_0/tapered_buf_4/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3231 ro_divider_buffered_0/tapered_buf_4/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3232 ro_divider_buffered_0/tapered_buf_4/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3233 ro_divider_buffered_0/tapered_buf_4/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3234 ro_divider_buffered_0/tapered_buf_4/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3235 ro_divider_buffered_0/tapered_buf_4/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C3236 ro_divider_buffered_0/tapered_buf_3/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3237 ro_divider_buffered_0/tapered_buf_3/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3238 ro_divider_buffered_0/tapered_buf_3/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3239 ro_divider_buffered_0/tapered_buf_3/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3240 ro_divider_buffered_0/tapered_buf_3/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3241 ro_divider_buffered_0/tapered_buf_3/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C3242 ro_divider_buffered_0/tapered_buf_2/in5 DIGITAL_BUFFER_v1_0/vdd 619.27fF
C3243 ro_divider_buffered_0/tapered_buf_2/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3244 ro_divider_buffered_0/tapered_buf_2/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3245 ro_divider_buffered_0/tapered_buf_2/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3246 ro_divider_buffered_0/tapered_buf_2/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3247 ro_divider_buffered_0/tapered_buf_2/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C3248 filter_buffered_0/v DIGITAL_BUFFER_v1_0/vdd 392.16fF
C3249 filter_buffered_0/tapered_buf_0/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3250 filter_buffered_0/tapered_buf_0/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3251 filter_buffered_0/tapered_buf_0/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3252 filter_buffered_0/tapered_buf_0/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3253 filter_buffered_0/tapered_buf_0/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3254 filter_buffered_0/tapered_buf_1/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3255 filter_buffered_0/tapered_buf_1/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3256 filter_buffered_0/tapered_buf_1/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3257 filter_buffered_0/tapered_buf_1/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3258 filter_buffered_0/tapered_buf_1/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3259 filter_buffered_0/filter_0/v DIGITAL_BUFFER_v1_0/vdd 476.79fF
C3260 filter_buffered_0/filter_0/a_4216_n5230# DIGITAL_BUFFER_v1_0/vdd 418.47fF **FLOATING
C3261 filter_buffered_0/filter_0/a_4216_n2998# DIGITAL_BUFFER_v1_0/vdd 1.03fF **FLOATING
C3262 cp_buffered_0/cp_0/down DIGITAL_BUFFER_v1_0/vdd 397.14fF
C3263 cp_buffered_0/tapered_buf_0/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3264 cp_buffered_0/tapered_buf_0/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3265 cp_buffered_0/tapered_buf_0/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3266 cp_buffered_0/tapered_buf_0/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3267 cp_buffered_0/tapered_buf_0/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3268 cp_buffered_0/tapered_buf_0/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C3269 cp_buffered_0/cp_0/out DIGITAL_BUFFER_v1_0/vdd 397.36fF
C3270 cp_buffered_0/tapered_buf_1/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3271 cp_buffered_0/tapered_buf_1/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3272 cp_buffered_0/tapered_buf_1/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3273 cp_buffered_0/tapered_buf_1/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3274 cp_buffered_0/tapered_buf_1/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3275 cp_buffered_0/tapered_buf_1/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C3276 cp_buffered_0/cp_0/upbar DIGITAL_BUFFER_v1_0/vdd 393.41fF
C3277 cp_buffered_0/cp_0/a_7110_n2840# DIGITAL_BUFFER_v1_0/vdd 0.17fF **FLOATING
C3278 cp_buffered_0/cp_0/a_3060_n2840# DIGITAL_BUFFER_v1_0/vdd 1.71fF **FLOATING
C3279 cp_buffered_0/cp_0/a_7110_0# DIGITAL_BUFFER_v1_0/vdd 0.17fF **FLOATING
C3280 cp_buffered_0/cp_0/a_6370_0# DIGITAL_BUFFER_v1_0/vdd 0.40fF **FLOATING
C3281 cp_buffered_0/cp_0/a_3060_0# DIGITAL_BUFFER_v1_0/vdd 1.65fF **FLOATING
C3282 cp_buffered_0/cp_0/a_1710_0# DIGITAL_BUFFER_v1_0/vdd 5.76fF **FLOATING
C3283 cp_buffered_0/cp_0/a_1710_n2840# DIGITAL_BUFFER_v1_0/vdd 5.24fF **FLOATING
C3284 cp_buffered_0/cp_0/a_10_n50# DIGITAL_BUFFER_v1_0/vdd 3.19fF **FLOATING
C3285 cp_buffered_0/tapered_buf_2/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3286 cp_buffered_0/tapered_buf_2/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3287 cp_buffered_0/tapered_buf_2/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3288 cp_buffered_0/tapered_buf_2/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3289 cp_buffered_0/tapered_buf_2/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3290 cp_buffered_0/tapered_buf_2/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C3291 ashish_0/b DIGITAL_BUFFER_v1_0/vdd 3.70fF
C3292 ashish_0/a DIGITAL_BUFFER_v1_0/vdd 1.62fF
C3293 ashish_0/vop DIGITAL_BUFFER_v1_0/vdd 24.86fF
C3294 ashish_0/von DIGITAL_BUFFER_v1_0/vdd 23.36fF
C3295 ashish_0/cm DIGITAL_BUFFER_v1_0/vdd 25.70fF
C3296 pd_buffered_0/tapered_buf_0/out DIGITAL_BUFFER_v1_0/vdd 385.93fF
C3297 pd_buffered_0/tapered_buf_0/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3298 pd_buffered_0/tapered_buf_0/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3299 pd_buffered_0/tapered_buf_0/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3300 pd_buffered_0/tapered_buf_0/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3301 pd_buffered_0/tapered_buf_0/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3302 pd_buffered_0/tapered_buf_1/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3303 pd_buffered_0/tapered_buf_1/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3304 pd_buffered_0/tapered_buf_1/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3305 pd_buffered_0/tapered_buf_1/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3306 pd_buffered_0/tapered_buf_1/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3307 pd_buffered_0/tapered_buf_1/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C3308 pd_buffered_0/pd_0/UP DIGITAL_BUFFER_v1_0/vdd 5.76fF
C3309 pd_buffered_0/pd_0/and_pd_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.39fF
C3310 pd_buffered_0/pd_0/and_pd_0/Out1 DIGITAL_BUFFER_v1_0/vdd 2.22fF
C3311 pd_buffered_0/pd_0/tspc_r_1/z5 DIGITAL_BUFFER_v1_0/vdd 1.10fF
C3312 pd_buffered_0/pd_0/tspc_r_1/Z4 DIGITAL_BUFFER_v1_0/vdd 1.07fF
C3313 pd_buffered_0/pd_0/R DIGITAL_BUFFER_v1_0/vdd 3.05fF
C3314 pd_buffered_0/pd_0/tspc_r_1/Qbar DIGITAL_BUFFER_v1_0/vdd 0.79fF
C3315 pd_buffered_0/pd_0/tspc_r_1/Z2 DIGITAL_BUFFER_v1_0/vdd 1.22fF
C3316 pd_buffered_0/pd_0/tspc_r_1/Z1 DIGITAL_BUFFER_v1_0/vdd 0.67fF
C3317 pd_buffered_0/pd_0/DOWN DIGITAL_BUFFER_v1_0/vdd 8.46fF
C3318 pd_buffered_0/pd_0/tspc_r_1/Qbar1 DIGITAL_BUFFER_v1_0/vdd 1.34fF
C3319 pd_buffered_0/pd_0/tspc_r_1/Z3 DIGITAL_BUFFER_v1_0/vdd 2.12fF
C3320 pd_buffered_0/pd_0/DIV DIGITAL_BUFFER_v1_0/vdd 390.67fF
C3321 pd_buffered_0/pd_0/tspc_r_0/z5 DIGITAL_BUFFER_v1_0/vdd 1.10fF
C3322 pd_buffered_0/pd_0/tspc_r_0/Z4 DIGITAL_BUFFER_v1_0/vdd 1.07fF
C3323 pd_buffered_0/pd_0/tspc_r_0/Qbar DIGITAL_BUFFER_v1_0/vdd 0.88fF
C3324 pd_buffered_0/pd_0/tspc_r_0/Z2 DIGITAL_BUFFER_v1_0/vdd 1.22fF
C3325 pd_buffered_0/pd_0/tspc_r_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.67fF
C3326 pd_buffered_0/pd_0/tspc_r_0/Qbar1 DIGITAL_BUFFER_v1_0/vdd 1.34fF
C3327 pd_buffered_0/pd_0/tspc_r_0/Z3 DIGITAL_BUFFER_v1_0/vdd 2.12fF
C3328 pd_buffered_0/pd_0/REF DIGITAL_BUFFER_v1_0/vdd 388.56fF
C3329 pd_buffered_0/tapered_buf_3/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3330 pd_buffered_0/tapered_buf_3/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3331 pd_buffered_0/tapered_buf_3/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3332 pd_buffered_0/tapered_buf_3/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3333 pd_buffered_0/tapered_buf_3/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3334 pd_buffered_0/tapered_buf_3/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C3335 pd_buffered_0/tapered_buf_2/out DIGITAL_BUFFER_v1_0/vdd 385.91fF
C3336 pd_buffered_0/tapered_buf_2/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3337 pd_buffered_0/tapered_buf_2/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3338 pd_buffered_0/tapered_buf_2/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3339 pd_buffered_0/tapered_buf_2/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3340 pd_buffered_0/tapered_buf_2/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3341 pll_full_buffered1_0/tapered_buf_0/out DIGITAL_BUFFER_v1_0/vdd 385.90fF
C3342 pll_full_buffered1_0/tapered_buf_0/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3343 pll_full_buffered1_0/tapered_buf_0/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3344 pll_full_buffered1_0/tapered_buf_0/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3345 pll_full_buffered1_0/tapered_buf_0/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3346 pll_full_buffered1_0/tapered_buf_0/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3347 pll_full_buffered1_0/tapered_buf_1/in5 DIGITAL_BUFFER_v1_0/vdd 619.27fF
C3348 pll_full_buffered1_0/tapered_buf_1/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3349 pll_full_buffered1_0/tapered_buf_1/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3350 pll_full_buffered1_0/tapered_buf_1/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3351 pll_full_buffered1_0/tapered_buf_1/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3352 pll_full_buffered1_0/tapered_buf_1/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
C3353 pll_full_buffered1_0/pll_full_0/divider_0/and_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.65fF
C3354 pll_full_buffered1_0/pll_full_0/divider_0/and_0/B DIGITAL_BUFFER_v1_0/vdd 2.45fF
C3355 pll_full_buffered1_0/pll_full_0/divider_0/and_0/A DIGITAL_BUFFER_v1_0/vdd 2.35fF
C3356 pll_full_buffered1_0/pll_full_0/divider_0/and_0/out1 DIGITAL_BUFFER_v1_0/vdd 2.99fF
C3357 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C3358 pll_full_buffered1_0/pll_full_0/div DIGITAL_BUFFER_v1_0/vdd 15.26fF
C3359 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C3360 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C3361 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C3362 pll_full_buffered1_0/pll_full_0/divider_0/nor_0/B DIGITAL_BUFFER_v1_0/vdd 6.48fF
C3363 pll_full_buffered1_0/pll_full_0/divider_0/tspc_2/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.14fF **FLOATING
C3364 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C3365 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Q DIGITAL_BUFFER_v1_0/vdd 3.12fF
C3366 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C3367 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C3368 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C3369 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/B DIGITAL_BUFFER_v1_0/vdd 7.12fF
C3370 pll_full_buffered1_0/pll_full_0/divider_0/tspc_1/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.15fF **FLOATING
C3371 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C3372 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Q DIGITAL_BUFFER_v1_0/vdd 3.14fF
C3373 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C3374 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C3375 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C3376 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/A DIGITAL_BUFFER_v1_0/vdd 7.08fF
C3377 pll_full_buffered1_0/pll_full_0/divider_0/tspc_0/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.15fF **FLOATING
C3378 pll_full_buffered1_0/pll_full_0/vco DIGITAL_BUFFER_v1_0/vdd 45.05fF
C3379 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/nand_1/z1 DIGITAL_BUFFER_v1_0/vdd 0.36fF
C3380 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/D DIGITAL_BUFFER_v1_0/vdd 2.64fF
C3381 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Q DIGITAL_BUFFER_v1_0/vdd 3.72fF
C3382 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Q DIGITAL_BUFFER_v1_0/vdd 3.61fF
C3383 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/nand_0/z1 DIGITAL_BUFFER_v1_0/vdd 0.36fF
C3384 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/D DIGITAL_BUFFER_v1_0/vdd 3.12fF
C3385 pll_full_buffered1_0/pll_full_0/divider_0/and_0/OUT DIGITAL_BUFFER_v1_0/vdd 5.67fF
C3386 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C3387 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C3388 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z2 DIGITAL_BUFFER_v1_0/vdd 1.19fF
C3389 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C3390 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.47fF **FLOATING
C3391 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# DIGITAL_BUFFER_v1_0/vdd 2.11fF **FLOATING
C3392 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C3393 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C3394 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z2 DIGITAL_BUFFER_v1_0/vdd 1.48fF
C3395 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C3396 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.14fF **FLOATING
C3397 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/m1_2700_2190# DIGITAL_BUFFER_v1_0/vdd 4.22fF **FLOATING
C3398 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z4 DIGITAL_BUFFER_v1_0/vdd 0.86fF
C3399 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/Out DIGITAL_BUFFER_v1_0/vdd 4.59fF
C3400 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z3 DIGITAL_BUFFER_v1_0/vdd 2.26fF
C3401 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z2 DIGITAL_BUFFER_v1_0/vdd 1.46fF
C3402 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.99fF
C3403 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# DIGITAL_BUFFER_v1_0/vdd 1.16fF **FLOATING
C3404 pll_full_buffered1_0/pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# DIGITAL_BUFFER_v1_0/vdd 2.11fF **FLOATING
C3405 pll_full_buffered1_0/pll_full_0/divider_0/nor_1/Z1 DIGITAL_BUFFER_v1_0/vdd 1.34fF
C3406 pll_full_buffered1_0/pll_full_0/divider_0/nor_0/Z1 DIGITAL_BUFFER_v1_0/vdd 1.34fF
C3407 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/v DIGITAL_BUFFER_v1_0/vdd 16.43fF
C3408 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_5/vin DIGITAL_BUFFER_v1_0/vdd 0.78fF
C3409 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_4/vin DIGITAL_BUFFER_v1_0/vdd 1.50fF
C3410 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_2/vin DIGITAL_BUFFER_v1_0/vdd 1.30fF
C3411 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_3/vin DIGITAL_BUFFER_v1_0/vdd 0.56fF
C3412 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_1/vin DIGITAL_BUFFER_v1_0/vdd 1.14fF
C3413 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_2/switch_0/vin DIGITAL_BUFFER_v1_0/vdd 1.02fF
C3414 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_5/vin DIGITAL_BUFFER_v1_0/vdd 0.78fF
C3415 pll_full_buffered1_0/pll_full_0/ro_complete_0/a0 DIGITAL_BUFFER_v1_0/vdd 5.35fF
C3416 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_4/vin DIGITAL_BUFFER_v1_0/vdd 1.50fF
C3417 pll_full_buffered1_0/pll_full_0/ro_complete_0/a1 DIGITAL_BUFFER_v1_0/vdd 6.54fF
C3418 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_2/vin DIGITAL_BUFFER_v1_0/vdd 1.30fF
C3419 pll_full_buffered1_0/pll_full_0/ro_complete_0/a3 DIGITAL_BUFFER_v1_0/vdd 5.96fF
C3420 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_3/vin DIGITAL_BUFFER_v1_0/vdd 0.56fF
C3421 pll_full_buffered1_0/pll_full_0/ro_complete_0/a2 DIGITAL_BUFFER_v1_0/vdd 5.21fF
C3422 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_1/vin DIGITAL_BUFFER_v1_0/vdd 1.14fF
C3423 pll_full_buffered1_0/pll_full_0/ro_complete_0/a4 DIGITAL_BUFFER_v1_0/vdd 5.81fF
C3424 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_1/switch_0/vin DIGITAL_BUFFER_v1_0/vdd 1.02fF
C3425 pll_full_buffered1_0/pll_full_0/ro_complete_0/a5 DIGITAL_BUFFER_v1_0/vdd 6.74fF
C3426 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/v DIGITAL_BUFFER_v1_0/vdd 15.12fF
C3427 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_5/vin DIGITAL_BUFFER_v1_0/vdd 0.78fF
C3428 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_4/vin DIGITAL_BUFFER_v1_0/vdd 1.50fF
C3429 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_2/vin DIGITAL_BUFFER_v1_0/vdd 1.30fF
C3430 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_3/vin DIGITAL_BUFFER_v1_0/vdd 0.56fF
C3431 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_1/vin DIGITAL_BUFFER_v1_0/vdd 1.14fF
C3432 pll_full_buffered1_0/pll_full_0/ro_complete_0/cbank_0/switch_0/vin DIGITAL_BUFFER_v1_0/vdd 1.02fF
C3433 pll_full_buffered1_0/pll_full_0/filter_0/a_4216_n5230# DIGITAL_BUFFER_v1_0/vdd 418.90fF **FLOATING
C3434 pll_full_buffered1_0/pll_full_0/filter_0/a_4216_n2998# DIGITAL_BUFFER_v1_0/vdd 1.39fF **FLOATING
C3435 pll_full_buffered1_0/pll_full_0/cp_0/vbias DIGITAL_BUFFER_v1_0/vdd 2.41fF
C3436 pll_full_buffered1_0/pll_full_0/cp_0/a_7110_n2840# DIGITAL_BUFFER_v1_0/vdd 0.17fF **FLOATING
C3437 pll_full_buffered1_0/pll_full_0/cp_0/a_3060_n2840# DIGITAL_BUFFER_v1_0/vdd 1.71fF **FLOATING
C3438 pll_full_buffered1_0/pll_full_0/cp_0/a_7110_0# DIGITAL_BUFFER_v1_0/vdd 0.17fF **FLOATING
C3439 pll_full_buffered1_0/pll_full_0/cp_0/a_6370_0# DIGITAL_BUFFER_v1_0/vdd 0.40fF **FLOATING
C3440 pll_full_buffered1_0/pll_full_0/cp_0/a_3060_0# DIGITAL_BUFFER_v1_0/vdd 2.50fF **FLOATING
C3441 pll_full_buffered1_0/pll_full_0/cp_0/a_1710_0# DIGITAL_BUFFER_v1_0/vdd 7.47fF **FLOATING
C3442 pll_full_buffered1_0/pll_full_0/cp_0/a_10_n50# DIGITAL_BUFFER_v1_0/vdd 2.96fF **FLOATING
C3443 pll_full_buffered1_0/pll_full_0/pd_0/UP DIGITAL_BUFFER_v1_0/vdd 4.55fF
C3444 pll_full_buffered1_0/pll_full_0/pd_0/and_pd_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.39fF
C3445 pll_full_buffered1_0/pll_full_0/pd_0/and_pd_0/Out1 DIGITAL_BUFFER_v1_0/vdd 2.22fF
C3446 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/z5 DIGITAL_BUFFER_v1_0/vdd 1.10fF
C3447 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z4 DIGITAL_BUFFER_v1_0/vdd 1.07fF
C3448 pll_full_buffered1_0/pll_full_0/pd_0/R DIGITAL_BUFFER_v1_0/vdd 3.05fF
C3449 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Qbar DIGITAL_BUFFER_v1_0/vdd 0.79fF
C3450 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z2 DIGITAL_BUFFER_v1_0/vdd 1.22fF
C3451 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z1 DIGITAL_BUFFER_v1_0/vdd 0.67fF
C3452 pll_full_buffered1_0/pll_full_0/pd_0/DOWN DIGITAL_BUFFER_v1_0/vdd 7.30fF
C3453 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Qbar1 DIGITAL_BUFFER_v1_0/vdd 1.34fF
C3454 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_1/Z3 DIGITAL_BUFFER_v1_0/vdd 2.12fF
C3455 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/z5 DIGITAL_BUFFER_v1_0/vdd 1.10fF
C3456 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z4 DIGITAL_BUFFER_v1_0/vdd 1.07fF
C3457 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Qbar DIGITAL_BUFFER_v1_0/vdd 0.88fF
C3458 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z2 DIGITAL_BUFFER_v1_0/vdd 1.22fF
C3459 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z1 DIGITAL_BUFFER_v1_0/vdd 0.67fF
C3460 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Qbar1 DIGITAL_BUFFER_v1_0/vdd 1.34fF
C3461 pll_full_buffered1_0/pll_full_0/pd_0/tspc_r_0/Z3 DIGITAL_BUFFER_v1_0/vdd 2.12fF
C3462 pll_full_buffered1_0/pll_full_0/ref DIGITAL_BUFFER_v1_0/vdd 391.17fF
C3463 pll_full_buffered1_0/pll_full_0/cp_0/upbar DIGITAL_BUFFER_v1_0/vdd 14.90fF
C3464 pll_full_buffered1_0/tapered_buf_2/in5 DIGITAL_BUFFER_v1_0/vdd 592.97fF
C3465 pll_full_buffered1_0/tapered_buf_2/in4 DIGITAL_BUFFER_v1_0/vdd 252.41fF
C3466 pll_full_buffered1_0/tapered_buf_2/in3 DIGITAL_BUFFER_v1_0/vdd 63.61fF
C3467 pll_full_buffered1_0/tapered_buf_2/in2 DIGITAL_BUFFER_v1_0/vdd 16.76fF
C3468 pll_full_buffered1_0/tapered_buf_2/in1 DIGITAL_BUFFER_v1_0/vdd 4.58fF
C3469 pll_full_buffered1_0/tapered_buf_2/in DIGITAL_BUFFER_v1_0/vdd 1.38fF
.ends
