* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[5] io_analog[6] io_analog[7]
+ io_analog[8] io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
C0 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C1 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C2 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C3 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C4 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/a_630_n680# 0.12fF
C5 divider_1/nor_1/B divider_1/and_0/B 0.29fF
C6 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/tspc_r_1/Qbar 0.01fF
C7 pd_1/R pd_1/DOWN 0.36fF
C8 pd_0/DOWN pd_0/and_pd_0/Z1 0.07fF
C9 divbuf_12/IN divbuf_12/OUT5 0.00fF
C10 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.15fF
C11 pll_full_1/ro_complete_0/a0 pll_full_1/divider_0/clk 0.11fF
C12 pd_1/and_pd_0/Out1 pd_1/UP 0.33fF
C13 ro_complete_0/cbank_1/switch_4/vin divbuf_7/OUT 0.13fF
C14 divider_0/nor_0/B divider_0/tspc_1/Z4 0.21fF
C15 divider_0/tspc_0/Z3 divider_0/nor_1/B 0.38fF
C16 divbuf_1/OUT2 divbuf_1/a_492_n240# 0.42fF
C17 divbuf_2/OUT ro_complete_0/cbank_2/switch_0/vin 0.09fF
C18 divbuf_1/OUT divbuf_1/OUT3 0.26fF
C19 divider_0/nor_0/A divider_0/and_0/B 0.08fF
C20 divbuf_6/OUT3 divbuf_6/OUT5 0.01fF
C21 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C22 divider_1/tspc_1/Z1 divider_1/tspc_1/Z2 1.07fF
C23 divider_1/nor_0/B divider_1/tspc_1/Z3 0.38fF
C24 divider_1/tspc_1/Q divider_1/nor_1/B 0.22fF
C25 divbuf_18/OUT2 divbuf_18/OUT5 0.02fF
C26 pd_1/tspc_r_0/z5 pd_1/DIV 0.04fF
C27 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/Z3 0.20fF
C28 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/DOWN 0.03fF
C29 divbuf_19/OUT5 divbuf_19/OUT3 0.01fF
C30 divider_2/nor_0/B divider_2/tspc_2/a_630_n680# 0.01fF
C31 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/D 0.03fF
C32 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C33 pll_full_0/pd_0/DOWN pll_full_0/pd_0/UP 4.58fF
C34 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Q 0.20fF
C35 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/D 0.09fF
C36 divider_0/prescaler_0/tspc_0/Z2 divider_0/clk 0.11fF
C37 divbuf_6/OUT ro_complete_0/cbank_2/v 0.05fF
C38 pll_full_1/divbuf_1/OUT3 pll_full_1/divbuf_1/OUT4 5.16fF
C39 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C40 divider_2/tspc_0/Z4 divider_2/nor_0/B 0.02fF
C41 divbuf_19/OUT2 divbuf_19/OUT 0.06fF
C42 divider_1/prescaler_0/tspc_2/Z2 divider_1/and_0/OUT 0.05fF
C43 divbuf_22/OUT2 divbuf_22/OUT5 0.02fF
C44 divbuf_22/OUT3 divbuf_22/OUT4 5.16fF
C45 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Qbar1 0.38fF
C46 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C47 divider_2/tspc_0/Z2 divider_2/tspc_0/Z3 0.16fF
C48 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/Z4 0.65fF
C49 pd_1/REF pd_1/tspc_r_1/z5 0.04fF
C50 pd_1/tspc_r_1/Z1 pd_1/tspc_r_1/Z2 0.71fF
C51 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z4 0.20fF
C52 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/R 0.27fF
C53 divider_2/prescaler_0/tspc_1/Q divider_2/nor_0/A 0.03fF
C54 divbuf_13/a_492_n240# divbuf_13/OUT2 0.42fF
C55 pll_full_1/divbuf_1/OUT2 pll_full_1/divbuf_1/OUT5 0.02fF
C56 divider_0/tspc_0/a_630_n680# divider_0/tspc_1/Q 0.01fF
C57 divider_0/tspc_0/Z2 divider_0/tspc_0/Z3 0.16fF
C58 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z4 0.36fF
C59 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/Out 0.05fF
C60 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/IN 5.26fF
C61 pll_full_0/pd_0/R pll_full_0/pd_0/UP 0.46fF
C62 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C63 divider_1/mc2 divider_1/prescaler_0/tspc_2/a_630_n680# 0.33fF
C64 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/tspc_0/D 0.04fF
C65 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/nand_1/z1 0.22fF
C66 divbuf_5/OUT divbuf_5/OUT3 0.26fF
C67 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT5 0.01fF
C68 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT 0.06fF
C69 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C70 divider_1/tspc_0/Z2 divider_1/tspc_1/Q 0.14fF
C71 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z3 0.16fF
C72 divider_2/prescaler_0/Out divider_2/nor_0/A 0.15fF
C73 divider_1/tspc_1/Z2 divider_1/nor_0/A 0.15fF
C74 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_0/D 0.32fF
C75 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/clk 0.01fF
C76 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C77 pll_full_1/ro_complete_0/a3 pll_full_1/divider_0/clk 0.11fF
C78 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Qbar1 0.12fF
C79 pll_full_0/pd_0/DOWN pll_full_0/pd_0/R 0.36fF
C80 divbuf_24/IN divbuf_24/OUT5 0.00fF
C81 divbuf_2/IN divbuf_2/a_492_n240# 0.13fF
C82 divbuf_5/OUT ro_complete_0/cbank_1/v 0.05fF
C83 ro_complete_0/cbank_0/switch_4/vin divbuf_7/OUT 0.13fF
C84 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z4 0.08fF
C85 divider_0/tspc_1/Q divider_0/tspc_1/a_630_n680# 0.04fF
C86 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z3 0.16fF
C87 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/UP 0.33fF
C88 divider_0/nor_0/A divider_0/tspc_2/Z2 0.23fF
C89 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_1/Qbar 0.02fF
C90 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C91 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C92 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z4 0.12fF
C93 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z2 1.07fF
C94 divbuf_7/OUT3 divbuf_7/OUT5 0.01fF
C95 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C96 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z2 0.01fF
C97 pd_1/R pd_1/REF 0.61fF
C98 pd_0/R pd_0/UP 0.45fF
C99 pd_0/tspc_r_1/Z4 pd_0/tspc_r_1/z5 0.04fF
C100 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.09fF
C101 divider_2/nor_0/Z1 divider_2/and_0/B 0.18fF
C102 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Z4 0.02fF
C103 pll_full_1/pd_0/tspc_r_0/Qbar pll_full_1/pd_0/tspc_r_0/Qbar1 0.01fF
C104 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Out1 0.12fF
C105 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/A 0.01fF
C106 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_0/Z2 1.07fF
C107 divbuf_1/OUT5 divbuf_1/OUT4 20.26fF
C108 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/v 1.43fF
C109 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C110 divider_0/tspc_2/Q divider_0/tspc_1/Z4 0.15fF
C111 divider_0/tspc_0/Z4 divider_0/nor_1/B 0.22fF
C112 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z4 0.12fF
C113 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z2 1.07fF
C114 divider_2/Out divider_2/tspc_0/a_630_n680# 0.04fF
C115 divider_0/and_0/out1 divider_0/and_0/Z1 0.36fF
C116 pll_full_1/pd_0/R pll_full_1/pd_0/UP 0.46fF
C117 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z2 0.01fF
C118 divider_1/tspc_2/Q divider_1/tspc_1/Z3 0.45fF
C119 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z3 0.05fF
C120 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z4 0.08fF
C121 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Q 0.04fF
C122 divbuf_10/a_492_n240# divbuf_10/OUT5 0.01fF
C123 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT4 1.11fF
C124 pll_full_1/divbuf_0/IN pll_full_1/divider_0/tspc_0/a_630_n680# 0.04fF
C125 divider_2/tspc_2/Q divider_2/nor_0/B 0.22fF
C126 divbuf_9/OUT2 divbuf_9/OUT5 0.02fF
C127 divbuf_9/OUT3 divbuf_9/OUT4 5.16fF
C128 pd_1/REF pd_1/tspc_r_1/Z3 0.65fF
C129 pd_0/and_pd_0/Out1 pd_0/UP 0.33fF
C130 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C131 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C132 divbuf_3/OUT divbuf_3/a_492_n240# 0.00fF
C133 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/switch_5/vin 0.20fF
C134 divbuf_25/a_492_n240# divbuf_25/OUT2 0.42fF
C135 divider_0/tspc_2/Q divider_0/tspc_2/Z3 0.05fF
C136 divider_0/prescaler_0/tspc_1/Z2 divider_0/clk 0.11fF
C137 io_clamp_low[0] io_clamp_high[0] 0.53fF
C138 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/a_630_n680# 0.19fF
C139 divbuf_7/OUT divbuf_7/OUT2 0.06fF
C140 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/D 0.05fF
C141 divbuf_20/OUT4 divbuf_20/OUT5 20.26fF
C142 divbuf_20/OUT3 divbuf_20/OUT 0.26fF
C143 pd_0/tspc_r_0/Z2 pd_0/tspc_r_0/Z4 0.14fF
C144 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z2 1.07fF
C145 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C146 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/Z2 0.25fF
C147 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/divider_0/clk 1.46fF
C148 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/nor_0/A 0.03fF
C149 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_0/Z2 0.40fF
C150 divbuf_4/OUT ro_complete_0/cbank_2/switch_1/vin 0.09fF
C151 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/v 1.30fF
C152 divider_0/tspc_0/Z2 divider_0/tspc_0/Z4 0.36fF
C153 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C154 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z3 0.11fF
C155 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/switch_5/vin 0.20fF
C156 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C157 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/a0 0.13fF
C158 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z2 0.16fF
C159 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z1 0.08fF
C160 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/A 0.01fF
C161 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z2 1.07fF
C162 divider_2/tspc_2/Q divider_2/tspc_1/a_630_n680# 0.01fF
C163 pll_full_1/divbuf_0/a_492_n240# pll_full_1/divbuf_0/IN 0.13fF
C164 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/OUT2 0.42fF
C165 divbuf_12/OUT3 divbuf_12/OUT5 0.01fF
C166 divbuf_12/OUT2 divbuf_12/OUT 0.06fF
C167 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z4 0.14fF
C168 pd_0/R pd_0/and_pd_0/Out1 0.33fF
C169 pd_0/REF pd_0/tspc_r_1/Z4 0.02fF
C170 divider_2/mc2 divider_2/nor_0/A 0.04fF
C171 divider_2/nor_0/B divider_2/tspc_1/Z2 0.30fF
C172 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z2 0.01fF
C173 divider_2/and_0/out1 divider_2/and_0/B 0.18fF
C174 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C175 divider_0/mc2 divider_0/nor_0/A 0.04fF
C176 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C177 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/v 1.30fF
C178 divbuf_17/OUT2 divbuf_17/OUT3 1.37fF
C179 divider_1/nor_0/B divider_1/tspc_1/Z4 0.21fF
C180 divider_1/tspc_0/Z3 divider_1/nor_1/B 0.38fF
C181 filter_0/v divbuf_25/OUT4 1.11fF
C182 divider_1/nor_0/A divider_1/and_0/B 0.08fF
C183 divbuf_11/a_492_n240# divbuf_11/OUT5 0.01fF
C184 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/nor_0/B 0.06fF
C185 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/R 0.29fF
C186 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/nor_0/A 0.15fF
C187 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/Z3 0.45fF
C188 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z1 0.09fF
C189 divbuf_19/OUT divbuf_19/OUT4 1.11fF
C190 divider_2/and_0/OUT divider_2/prescaler_0/nand_0/z1 0.01fF
C191 divider_2/nor_0/B divider_2/nor_0/A 1.21fF
C192 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/a4 0.12fF
C193 divbuf_15/OUT5 divbuf_15/IN 0.00fF
C194 divbuf_25/OUT3 divbuf_25/OUT4 5.16fF
C195 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z2 0.21fF
C196 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a4 0.12fF
C197 ro_complete_0/cbank_1/switch_5/vin ro_complete_0/cbank_1/v 1.30fF
C198 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z2 1.07fF
C199 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C200 divider_0/tspc_1/Z3 divider_0/tspc_1/Z4 0.65fF
C201 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Q 0.04fF
C202 divider_0/prescaler_0/Out divider_0/clk 0.51fF
C203 ro_complete_1/a0 ro_complete_1/cbank_2/switch_5/vin 0.09fF
C204 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/nor_0/A 0.03fF
C205 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_0/Z2 0.40fF
C206 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Q 0.20fF
C207 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/D 0.09fF
C208 divider_1/prescaler_0/tspc_0/Z2 divider_1/clk 0.11fF
C209 pll_full_1/divbuf_1/a_492_n240# pll_full_1/divbuf_1/OUT5 0.01fF
C210 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C211 pd_0/DIV pd_0/tspc_r_0/Z1 0.17fF
C212 pd_0/tspc_r_0/Qbar1 pd_0/DOWN 0.11fF
C213 io_clamp_high[2] io_analog[6] 0.53fF
C214 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z2 0.01fF
C215 divider_2/tspc_2/Q divider_2/tspc_1/Z3 0.45fF
C216 divider_2/tspc_0/Z2 divider_2/tspc_0/a_630_n680# 0.01fF
C217 divbuf_22/OUT4 divbuf_22/OUT5 20.26fF
C218 divbuf_22/OUT3 divbuf_22/OUT 0.26fF
C219 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/Out 0.04fF
C220 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/z5 0.20fF
C221 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z4 0.20fF
C222 divider_2/and_0/OUT divider_2/clk 0.04fF
C223 divbuf_5/OUT divbuf_3/OUT 3.09fF
C224 pll_full_1/divbuf_1/OUT4 pll_full_1/divbuf_1/OUT5 20.26fF
C225 pll_full_1/divbuf_1/OUT3 pll_full_1/divbuf_1/OUT 0.26fF
C226 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z3 0.05fF
C227 divbuf_4/OUT ro_complete_0/cbank_1/switch_1/vin 0.09fF
C228 divbuf_5/OUT divbuf_5/OUT5 43.38fF
C229 divbuf_1/OUT divbuf_1/a_492_n240# 0.00fF
C230 pll_full_0/divbuf_1/OUT4 pll_full_0/divbuf_1/OUT 1.11fF
C231 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C232 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C233 divbuf_14/OUT divbuf_14/OUT5 43.38fF
C234 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/nand_1/z1 0.01fF
C235 divider_0/prescaler_0/tspc_2/Z2 divider_0/clk 0.11fF
C236 divider_1/tspc_0/a_630_n680# divider_1/tspc_1/Q 0.01fF
C237 divider_1/tspc_0/Z2 divider_1/tspc_0/Z3 0.16fF
C238 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z4 0.36fF
C239 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/Out 0.05fF
C240 divider_2/prescaler_0/Out divider_2/tspc_2/Z2 0.11fF
C241 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/tspc_0/D 0.04fF
C242 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/nand_1/z1 0.22fF
C243 divbuf_21/a_492_n240# divbuf_21/OUT 0.00fF
C244 pd_0/R pd_0/tspc_r_1/Z2 0.21fF
C245 divider_2/nor_0/B divider_2/tspc_1/Z1 0.03fF
C246 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/and_0/B 0.18fF
C247 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/a_630_n680# 0.01fF
C248 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C249 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/divider_0/clk 1.46fF
C250 divbuf_24/OUT3 divbuf_24/OUT5 0.01fF
C251 divbuf_24/OUT2 divbuf_24/OUT 0.06fF
C252 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z3 0.05fF
C253 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z1 0.03fF
C254 divider_2/nor_0/A divider_2/and_0/A 0.01fF
C255 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z4 0.36fF
C256 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C257 ro_complete_1/a4 ro_complete_1/cbank_1/v 0.05fF
C258 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_0/A 0.15fF
C259 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z3 0.45fF
C260 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C261 divider_0/tspc_2/Z1 divider_0/tspc_2/Z3 0.06fF
C262 divbuf_6/a_492_n240# divbuf_6/IN 0.13fF
C263 divider_1/tspc_1/Q divider_1/tspc_1/a_630_n680# 0.04fF
C264 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z3 0.16fF
C265 divider_1/nor_0/A divider_1/tspc_2/Z2 0.23fF
C266 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C267 pd_1/R pd_1/tspc_r_1/Qbar1 0.30fF
C268 pd_1/DOWN pd_1/tspc_r_0/z5 0.03fF
C269 pd_1/tspc_r_0/Z1 pd_1/tspc_r_0/Z3 0.09fF
C270 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z2 0.19fF
C271 divbuf_19/OUT divbuf_19/a_492_n240# 0.00fF
C272 divider_2/prescaler_0/m1_2700_2190# divider_2/nor_0/A 0.01fF
C273 divider_2/tspc_1/Z2 divider_2/tspc_1/Z3 0.16fF
C274 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/D 0.15fF
C275 divider_2/mc2 divider_2/and_0/B 0.20fF
C276 divbuf_23/a_492_n240# divbuf_23/OUT5 0.01fF
C277 divbuf_15/OUT5 divbuf_15/OUT2 0.02fF
C278 divbuf_15/OUT4 divbuf_15/OUT3 5.16fF
C279 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C280 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z3 0.16fF
C281 divider_0/mc2 divider_0/and_0/B 0.20fF
C282 divbuf_2/OUT ro_complete_0/cbank_2/v 0.08fF
C283 divbuf_7/OUT ro_complete_0/cbank_1/switch_5/vin 0.09fF
C284 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/Out 0.04fF
C285 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT3 1.37fF
C286 divbuf_3/OUT3 divbuf_3/OUT5 0.01fF
C287 divbuf_10/OUT2 divbuf_10/OUT3 1.37fF
C288 divider_1/tspc_2/Q divider_1/tspc_1/Z4 0.15fF
C289 divider_1/tspc_0/Z4 divider_1/nor_1/B 0.22fF
C290 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z4 0.12fF
C291 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z2 1.07fF
C292 divider_1/and_0/out1 divider_1/and_0/Z1 0.36fF
C293 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C294 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/and_pd_0/Z1 0.18fF
C295 cp_0/a_1710_n2840# cp_0/out 0.61fF
C296 cp_0/a_10_n50# cp_0/vbias 0.19fF
C297 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Qbar1 0.38fF
C298 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C299 divider_2/nor_0/B divider_2/and_0/B 0.31fF
C300 divbuf_9/OUT4 divbuf_9/OUT5 20.26fF
C301 divbuf_9/OUT3 divbuf_9/OUT 0.26fF
C302 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/tspc_2/D 0.03fF
C303 pll_full_1/divbuf_0/OUT3 pll_full_1/divbuf_0/OUT2 1.37fF
C304 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/a3 0.13fF
C305 divider_0/nor_1/Z1 divider_0/nor_0/B 0.18fF
C306 divbuf_0/OUT4 divbuf_0/OUT5 20.26fF
C307 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C308 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/z5 0.11fF
C309 divbuf_4/OUT divbuf_4/a_492_n240# 0.00fF
C310 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/v 1.30fF
C311 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C312 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C313 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C314 divbuf_7/OUT divbuf_7/OUT4 1.11fF
C315 divbuf_4/IN divbuf_4/OUT5 0.00fF
C316 ro_complete_1/cbank_1/v ro_complete_1/cbank_2/v 1.36fF
C317 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z3 0.05fF
C318 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z1 0.03fF
C319 divbuf_20/OUT5 divbuf_20/OUT 43.38fF
C320 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C321 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/D 0.11fF
C322 divider_1/tspc_2/Q divider_1/tspc_2/Z3 0.05fF
C323 divider_1/prescaler_0/tspc_1/Z2 divider_1/clk 0.11fF
C324 divider_2/tspc_0/Z2 divider_2/tspc_1/Q 0.14fF
C325 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z3 0.06fF
C326 divbuf_8/a_492_n240# divbuf_8/OUT 0.00fF
C327 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/Z3 0.16fF
C328 pll_full_1/ro_complete_0/a4 pll_full_1/divider_0/clk 0.01fF
C329 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_1/B 0.06fF
C330 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z3 0.05fF
C331 divider_2/nor_0/A divider_2/tspc_2/Z1 0.03fF
C332 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z4 0.12fF
C333 divider_0/tspc_1/Q divider_0/tspc_0/Z3 0.45fF
C334 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z4 0.28fF
C335 divbuf_2/OUT2 divbuf_2/OUT3 1.37fF
C336 divider_0/and_0/OUT divider_0/and_0/B 0.01fF
C337 ro_complete_1/a5 ro_complete_1/cbank_1/switch_0/vin 0.09fF
C338 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/v 1.30fF
C339 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C340 divbuf_5/IN divbuf_5/OUT5 0.00fF
C341 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/a_492_n240# 0.00fF
C342 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/Z2 0.36fF
C343 divider_1/tspc_0/Z2 divider_1/tspc_0/Z4 0.36fF
C344 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/a_630_n680# 0.19fF
C345 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z3 0.11fF
C346 divbuf_7/a_492_n240# divbuf_7/IN 0.13fF
C347 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C348 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C349 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/z5 0.11fF
C350 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z4 0.00fF
C351 divider_2/tspc_1/Z1 divider_2/tspc_1/Z3 0.06fF
C352 divbuf_12/OUT4 divbuf_12/OUT 1.11fF
C353 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Z3 0.65fF
C354 divider_2/and_0/A divider_2/and_0/B 0.18fF
C355 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/and_0/A 0.01fF
C356 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Q 0.91fF
C357 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C358 ro_complete_1/a2 ro_complete_1/cbank_0/switch_3/vin 0.09fF
C359 ro_complete_1/cbank_1/switch_2/vin ro_complete_1/cbank_1/v 1.30fF
C360 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C361 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C362 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C363 divbuf_11/OUT2 divbuf_11/OUT3 1.37fF
C364 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_0/Z3 0.20fF
C365 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/nor_0/A 0.01fF
C366 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/Z4 0.12fF
C367 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Z2 0.01fF
C368 divider_2/prescaler_0/tspc_2/D divider_2/prescaler_0/nand_0/z1 0.24fF
C369 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z3 0.65fF
C370 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z3 0.16fF
C371 divbuf_2/OUT5 divbuf_2/a_492_n240# 0.01fF
C372 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/v 1.30fF
C373 ro_complete_0/cbank_0/v ro_complete_0/cbank_2/v 0.04fF
C374 pll_full_0/divbuf_0/OUT4 pll_full_0/divbuf_0/OUT5 20.26fF
C375 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C376 ro_complete_1/a0 ro_complete_1/cbank_2/v 0.05fF
C377 filter_0/v divbuf_25/a_492_n240# 0.00fF
C378 divbuf_20/a_492_n240# divbuf_20/OUT2 0.42fF
C379 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C380 divider_1/tspc_1/Z3 divider_1/tspc_1/Z4 0.65fF
C381 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Q 0.04fF
C382 divider_1/prescaler_0/Out divider_1/clk 0.51fF
C383 divbuf_22/OUT5 divbuf_22/OUT 43.38fF
C384 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z2 0.25fF
C385 io_clamp_low[1] io_analog[5] 0.53fF
C386 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C387 divider_2/tspc_2/Q divider_2/tspc_1/Z4 0.15fF
C388 pll_full_0/ro_complete_0/a2 pll_full_0/divider_0/clk 0.11fF
C389 pd_1/DOWN pd_1/UP 0.46fF
C390 pll_full_1/divider_0/tspc_1/Z4 pll_full_1/divider_0/nor_0/A 0.02fF
C391 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_0/Z2 0.20fF
C392 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/z5 0.20fF
C393 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/Qbar 0.21fF
C394 divider_2/and_0/OUT divider_2/and_0/out1 0.31fF
C395 divider_2/prescaler_0/tspc_2/D divider_2/clk 0.26fF
C396 divbuf_13/a_492_n240# divbuf_13/OUT 0.00fF
C397 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C398 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C399 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z4 0.00fF
C400 divbuf_14/a_492_n240# divbuf_14/OUT5 0.01fF
C401 divider_0/prescaler_0/tspc_0/D divider_0/prescaler_0/nand_1/z1 0.21fF
C402 divider_1/tspc_0/a_630_n680# divider_1/tspc_0/Z3 0.05fF
C403 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/A 0.01fF
C404 divbuf_21/IN divbuf_21/OUT5 0.00fF
C405 pll_full_1/divbuf_1/OUT5 pll_full_1/divbuf_1/OUT 43.38fF
C406 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/IN 0.00fF
C407 pll_full_1/ro_complete_0/cbank_1/switch_4/vin pll_full_1/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C408 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/nand_1/z1 0.01fF
C409 divider_1/prescaler_0/tspc_2/Z2 divider_1/clk 0.11fF
C410 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/R 0.30fF
C411 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT2 1.37fF
C412 divbuf_12/a_492_n240# divbuf_12/IN 0.13fF
C413 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z1 0.71fF
C414 pd_0/REF pd_0/tspc_r_1/Z3 0.65fF
C415 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/nor_0/B 0.30fF
C416 pll_full_1/ro_complete_0/a1 pll_full_1/divider_0/clk 0.11fF
C417 divider_2/tspc_2/Q divider_2/tspc_2/Z3 0.05fF
C418 divider_2/nor_0/B divider_2/tspc_1/Q 0.51fF
C419 pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_0/divider_0/clk 1.58fF
C420 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z4 0.12fF
C421 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z2 1.07fF
C422 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z3 0.38fF
C423 divbuf_24/OUT4 divbuf_24/OUT 1.11fF
C424 divider_0/tspc_1/Q divider_0/tspc_0/Z4 0.15fF
C425 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_0/z5 0.03fF
C426 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/nor_0/A 0.01fF
C427 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z4 0.12fF
C428 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z2 0.01fF
C429 divider_0/tspc_2/Z1 divider_0/tspc_2/Z4 0.00fF
C430 divbuf_3/OUT2 divbuf_3/a_492_n240# 0.42fF
C431 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z4 0.36fF
C432 divider_1/tspc_2/Z1 divider_1/tspc_2/Z3 0.06fF
C433 divbuf_23/OUT2 divbuf_23/OUT3 1.37fF
C434 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_2/a_630_n680# 0.04fF
C435 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_1/Z4 0.12fF
C436 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C437 divider_2/tspc_1/Z2 divider_2/tspc_1/Z4 0.36fF
C438 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/D 0.05fF
C439 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/Z1 0.36fF
C440 divbuf_15/OUT divbuf_15/OUT3 0.26fF
C441 divbuf_2/OUT3 divbuf_2/OUT4 5.16fF
C442 divbuf_7/OUT ro_complete_0/cbank_1/v 0.05fF
C443 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C444 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT4 5.16fF
C445 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z4 0.36fF
C446 ro_complete_1/a3 ro_complete_1/cbank_2/v 0.05fF
C447 pll_full_0/divider_0/tspc_1/Z4 pll_full_0/divider_0/nor_0/A 0.02fF
C448 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_0/Z2 0.20fF
C449 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C450 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z3 0.16fF
C451 divbuf_10/OUT2 divbuf_10/OUT5 0.02fF
C452 divbuf_10/OUT3 divbuf_10/OUT4 5.16fF
C453 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/a1 0.14fF
C454 pll_full_1/ro_complete_0/cbank_0/switch_2/vin pll_full_1/ro_complete_0/a3 0.09fF
C455 pll_full_1/pd_0/REF pll_full_1/divbuf_1/a_492_n240# 0.13fF
C456 divbuf_22/a_492_n240# divbuf_22/OUT2 0.42fF
C457 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Q 0.04fF
C458 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C459 divbuf_9/OUT5 divbuf_9/OUT 43.38fF
C460 pd_1/DOWN pd_1/and_pd_0/Out1 0.12fF
C461 pd_1/REF pd_1/tspc_r_1/Z1 0.17fF
C462 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/Z2 0.14fF
C463 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/nand_0/z1 0.01fF
C464 divider_2/tspc_1/Z4 divider_2/nor_0/A 0.02fF
C465 divbuf_0/OUT4 divbuf_0/OUT 1.11fF
C466 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z2 0.01fF
C467 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/Out 0.21fF
C468 divbuf_3/OUT divbuf_3/OUT4 1.11fF
C469 ro_complete_1/a4 ro_complete_1/cbank_1/switch_1/vin 0.09fF
C470 ro_complete_0/cbank_2/switch_0/vin ro_complete_0/cbank_2/v 1.45fF
C471 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_0/B 0.30fF
C472 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C473 divbuf_4/OUT3 divbuf_4/OUT5 0.01fF
C474 pll_full_1/pd_0/UP pll_full_1/pd_0/and_pd_0/Z1 0.06fF
C475 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z4 0.12fF
C476 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z2 1.07fF
C477 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z3 0.38fF
C478 divider_1/nor_1/Z1 divider_1/nor_0/B 0.18fF
C479 pll_full_1/ro_complete_0/cbank_0/switch_5/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C480 divbuf_8/IN divbuf_8/OUT5 0.00fF
C481 divider_2/mc2 divider_2/and_0/OUT 0.05fF
C482 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z4 0.00fF
C483 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/D 0.03fF
C484 divbuf_24/a_492_n240# divbuf_24/IN 0.13fF
C485 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Z1 0.02fF
C486 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/clk 0.06fF
C487 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z4 0.12fF
C488 divider_2/tspc_2/Z1 divider_2/tspc_2/Z2 1.07fF
C489 divider_2/nor_0/A divider_2/tspc_2/Z3 0.38fF
C490 divbuf_4/OUT ro_complete_0/cbank_1/switch_0/vin 0.12fF
C491 pll_full_1/divbuf_0/OUT3 pll_full_1/divbuf_0/OUT4 5.16fF
C492 divbuf_2/OUT2 divbuf_2/OUT5 0.02fF
C493 divbuf_1/OUT2 divbuf_1/OUT 0.06fF
C494 divbuf_5/OUT ro_complete_0/cbank_2/switch_2/vin 0.14fF
C495 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/v 1.30fF
C496 divider_0/mc2 divider_0/and_0/OUT 0.05fF
C497 divider_0/tspc_0/Z1 divider_0/nor_1/B 0.03fF
C498 ro_complete_1/a3 ro_complete_1/cbank_1/switch_2/vin 0.09fF
C499 pll_full_1/pd_0/DOWN pll_full_1/pd_0/R 0.36fF
C500 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/a_630_n680# 0.04fF
C501 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z4 0.12fF
C502 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C503 divbuf_5/OUT3 divbuf_5/OUT5 0.01fF
C504 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/Z1 0.36fF
C505 divider_1/tspc_0/a_630_n680# divider_1/tspc_0/Z4 0.12fF
C506 divider_1/tspc_1/Q divider_1/tspc_0/Z3 0.45fF
C507 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z4 0.28fF
C508 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/Z2 1.07fF
C509 divider_1/and_0/OUT divider_1/and_0/B 0.01fF
C510 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_1/Z4 0.65fF
C511 divider_2/tspc_1/Q divider_2/tspc_1/Z3 0.05fF
C512 divider_2/tspc_1/Z1 divider_2/tspc_1/Z4 0.00fF
C513 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z3 0.06fF
C514 pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_0/divider_0/clk 1.46fF
C515 ro_complete_1/a2 ro_complete_1/cbank_2/switch_3/vin 0.09fF
C516 divbuf_0/OUT5 divbuf_0/OUT2 0.02fF
C517 divbuf_3/OUT ro_complete_0/cbank_1/v 0.05fF
C518 divbuf_15/OUT divbuf_15/a_492_n240# 0.00fF
C519 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/D 0.09fF
C520 divbuf_1/OUT4 divbuf_1/OUT3 5.16fF
C521 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/switch_5/vin 0.20fF
C522 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z2 0.14fF
C523 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C524 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z1 0.08fF
C525 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Q 0.91fF
C526 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/a_630_n680# 0.19fF
C527 divbuf_19/OUT2 divbuf_19/OUT3 1.37fF
C528 divbuf_11/OUT2 divbuf_11/OUT5 0.02fF
C529 divbuf_11/OUT3 divbuf_11/OUT4 5.16fF
C530 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/UP 0.33fF
C531 divbuf_9/a_492_n240# divbuf_9/OUT2 0.42fF
C532 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.15fF
C533 divbuf_18/OUT4 divbuf_18/OUT 1.11fF
C534 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/Q 0.04fF
C535 divider_2/prescaler_0/tspc_1/Z3 divider_2/clk 0.45fF
C536 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/a4 0.09fF
C537 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/a5 0.09fF
C538 divider_0/tspc_0/Z1 divider_0/tspc_0/Z2 1.07fF
C539 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Qbar1 0.38fF
C540 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a5 0.09fF
C541 divbuf_14/IN divbuf_14/OUT5 0.00fF
C542 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/clk 0.06fF
C543 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C544 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C545 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/Qbar 0.01fF
C546 pd_0/tspc_r_0/Z3 pd_0/R 0.27fF
C547 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z1 0.01fF
C548 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C549 pd_1/tspc_r_1/Z2 pd_1/tspc_r_1/Z4 0.14fF
C550 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_0/B 0.18fF
C551 divbuf_13/IN divbuf_13/OUT5 0.00fF
C552 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/and_0/A 0.26fF
C553 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Qbar1 0.12fF
C554 divbuf_5/OUT divbuf_6/OUT 3.23fF
C555 divider_0/prescaler_0/Out divider_0/prescaler_0/m1_2700_2190# 0.11fF
C556 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C557 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C558 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/v 1.30fF
C559 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Z4 0.65fF
C560 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C561 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C562 divider_1/mc2 divider_1/nor_1/B 0.15fF
C563 divbuf_5/a_492_n240# divbuf_5/OUT2 0.42fF
C564 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT5 43.38fF
C565 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C566 divbuf_21/OUT3 divbuf_21/OUT5 0.01fF
C567 divbuf_21/OUT2 divbuf_21/OUT 0.06fF
C568 pll_full_1/pd_0/DIV pll_full_1/divider_0/and_0/OUT 0.01fF
C569 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C570 divider_1/prescaler_0/tspc_0/D divider_1/prescaler_0/nand_1/z1 0.21fF
C571 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Qbar1 0.38fF
C572 divider_2/prescaler_0/m1_2700_2190# divider_2/and_0/OUT 0.14fF
C573 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C574 pll_full_1/divider_0/tspc_2/Z2 pll_full_1/divider_0/tspc_2/Z3 0.16fF
C575 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z4 0.21fF
C576 divider_0/nor_0/B divider_0/nor_1/B 0.47fF
C577 divider_0/tspc_0/Z3 divider_0/tspc_0/Z4 0.65fF
C578 divbuf_2/OUT divbuf_2/OUT3 0.26fF
C579 divbuf_14/OUT5 divbuf_14/OUT4 20.26fF
C580 divider_0/tspc_2/Z3 divider_0/tspc_2/Z4 0.65fF
C581 divbuf_6/OUT divbuf_6/OUT3 0.26fF
C582 ro_complete_1/a5 ro_complete_1/cbank_1/v 0.10fF
C583 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/cbank_0/v 1.30fF
C584 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C585 divbuf_6/a_492_n240# divbuf_6/OUT5 0.01fF
C586 divider_1/tspc_1/Q divider_1/tspc_0/Z4 0.15fF
C587 pll_full_1/ro_complete_0/cbank_2/switch_2/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C588 divbuf_19/IN divbuf_19/a_492_n240# 0.13fF
C589 divider_1/tspc_2/Z1 divider_1/tspc_2/Z4 0.00fF
C590 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/z5 0.04fF
C591 pd_1/tspc_r_0/Qbar1 pd_1/tspc_r_0/Z3 0.38fF
C592 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Z1 0.02fF
C593 divider_2/prescaler_0/tspc_2/Z4 divider_2/prescaler_0/tspc_2/D 0.11fF
C594 divbuf_23/OUT2 divbuf_23/OUT5 0.02fF
C595 divbuf_23/OUT3 divbuf_23/OUT4 5.16fF
C596 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/nor_0/A 0.55fF
C597 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Z4 0.21fF
C598 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/Z2 0.16fF
C599 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/clk 0.14fF
C600 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/B 0.78fF
C601 pll_full_1/divider_0/and_0/A pll_full_1/divider_0/and_0/B 0.18fF
C602 divbuf_14/OUT2 divbuf_14/OUT5 0.02fF
C603 divider_0/nor_0/B divider_0/tspc_2/a_630_n680# 0.01fF
C604 divbuf_2/OUT4 divbuf_2/OUT5 20.26fF
C605 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z1 0.01fF
C606 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C607 divider_1/nor_0/Z1 divider_1/nor_0/B 0.06fF
C608 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/A 0.26fF
C609 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT2 0.06fF
C610 divbuf_10/OUT4 divbuf_10/OUT5 20.26fF
C611 divbuf_10/OUT3 divbuf_10/OUT 0.26fF
C612 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/a1 0.14fF
C613 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z4 0.36fF
C614 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C615 pd_1/REF pd_1/tspc_r_1/Z2 0.19fF
C616 divider_2/prescaler_0/tspc_2/Z3 divider_2/clk 0.45fF
C617 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/tspc_0/Z2 0.36fF
C618 pll_full_1/divider_0/prescaler_0/tspc_2/D pll_full_1/divider_0/prescaler_0/nand_0/z1 0.24fF
C619 divbuf_0/OUT5 divbuf_0/OUT 43.38fF
C620 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C621 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C622 divider_0/tspc_0/Z2 divider_0/nor_0/B 0.20fF
C623 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/Out 0.04fF
C624 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/tspc_r_1/Z4 0.14fF
C625 divbuf_4/OUT divbuf_4/OUT2 0.06fF
C626 ro_complete_1/a2 ro_complete_1/cbank_1/v 0.05fF
C627 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/Z4 0.20fF
C628 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C629 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z2 0.01fF
C630 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/Out 0.21fF
C631 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z3 0.16fF
C632 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z4 0.21fF
C633 pll_full_1/pd_0/REF pll_full_1/pd_0/DOWN 1.48fF
C634 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C635 divider_2/nor_1/Z1 divider_2/nor_1/B 0.06fF
C636 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C637 divbuf_8/OUT3 divbuf_8/OUT5 0.01fF
C638 divbuf_8/OUT2 divbuf_8/OUT 0.06fF
C639 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/a_630_n680# 0.01fF
C640 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C641 pll_full_1/ro_complete_0/a5 pll_full_1/divider_0/clk 0.15fF
C642 divbuf_18/OUT3 divbuf_18/OUT4 5.16fF
C643 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Z4 0.65fF
C644 pll_full_0/divbuf_0/IN pll_full_0/divider_0/nor_1/B 0.27fF
C645 pd_1/tspc_r_1/Qbar1 pd_1/UP 0.11fF
C646 divider_2/tspc_2/Z2 divider_2/tspc_2/Z3 0.16fF
C647 divider_2/nor_0/A divider_2/tspc_2/Z4 0.21fF
C648 pll_full_1/divider_0/prescaler_0/tspc_2/D pll_full_1/divider_0/clk 0.26fF
C649 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_5/vin 0.20fF
C650 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C651 ro_complete_1/a3 ro_complete_1/cbank_2/switch_1/vin 0.13fF
C652 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/DIV 0.65fF
C653 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/nor_0/A 0.55fF
C654 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z4 0.21fF
C655 divider_1/tspc_0/Z1 divider_1/nor_1/B 0.03fF
C656 pll_full_0/divider_0/and_0/A pll_full_0/divider_0/and_0/B 0.18fF
C657 divbuf_7/a_492_n240# divbuf_7/OUT5 0.01fF
C658 pll_full_1/ro_complete_0/a1 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C659 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z3 0.25fF
C660 pd_0/DOWN pd_0/UP 0.46fF
C661 pd_0/tspc_r_1/Z2 pd_0/tspc_r_1/Z4 0.14fF
C662 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z4 0.00fF
C663 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Q 0.21fF
C664 divbuf_19/OUT3 divbuf_19/OUT4 5.16fF
C665 divider_2/and_0/B divider_2/and_0/Z1 0.07fF
C666 ro_complete_1/a2 ro_complete_1/cbank_0/switch_2/vin 0.14fF
C667 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/a4 0.09fF
C668 divbuf_0/OUT divbuf_0/OUT2 0.06fF
C669 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_0/vin 0.19fF
C670 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/v 1.30fF
C671 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/v 1.30fF
C672 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z2 0.36fF
C673 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C674 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z3 0.11fF
C675 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/D 0.09fF
C676 divbuf_11/OUT4 divbuf_11/OUT5 20.26fF
C677 divbuf_11/OUT3 divbuf_11/OUT 0.26fF
C678 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.05fF
C679 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/clk 0.64fF
C680 divider_2/prescaler_0/tspc_1/Z4 divider_2/clk 0.12fF
C681 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C682 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z1 0.17fF
C683 divbuf_1/OUT5 divbuf_1/IN 0.00fF
C684 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C685 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C686 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C687 divider_0/tspc_2/Q divider_0/tspc_2/a_630_n680# 0.04fF
C688 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/D 0.03fF
C689 divider_1/tspc_0/Z1 divider_1/tspc_0/Z2 1.07fF
C690 divbuf_4/a_492_n240# divbuf_4/IN 0.13fF
C691 ro_complete_1/cbank_2/switch_2/vin ro_complete_1/cbank_2/v 1.30fF
C692 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/clk 0.26fF
C693 divbuf_16/OUT2 divbuf_16/OUT 0.06fF
C694 divbuf_20/a_492_n240# divbuf_20/OUT 0.00fF
C695 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/a0 0.13fF
C696 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/DOWN 0.11fF
C697 pd_0/DOWN pd_0/R 0.36fF
C698 pd_0/DIV pd_0/tspc_r_0/z5 0.04fF
C699 pd_0/tspc_r_0/Z1 pd_0/tspc_r_0/Z2 0.71fF
C700 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z4 0.20fF
C701 io_clamp_high[0] io_analog[4] 0.53fF
C702 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z3 0.45fF
C703 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C704 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C705 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/divider_0/clk 1.46fF
C706 divider_2/prescaler_0/tspc_0/Z2 divider_2/and_0/OUT 0.06fF
C707 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/DIV 0.02fF
C708 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C709 divbuf_13/OUT3 divbuf_13/OUT5 0.01fF
C710 divbuf_13/OUT2 divbuf_13/OUT 0.06fF
C711 divider_2/prescaler_0/tspc_1/Q divider_2/clk 0.60fF
C712 divbuf_0/OUT5 divbuf_0/a_492_n240# 0.01fF
C713 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_4/vin 0.20fF
C714 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/UP 0.03fF
C715 divider_0/nor_0/B divider_0/tspc_1/Z1 0.03fF
C716 pll_full_1/cp_0/a_1710_0# pll_full_1/cp_0/down 0.32fF
C717 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C718 divider_0/prescaler_0/tspc_1/Q divider_0/nor_0/A 0.03fF
C719 divider_1/prescaler_0/Out divider_1/prescaler_0/m1_2700_2190# 0.11fF
C720 divider_2/prescaler_0/Out divider_2/clk 0.51fF
C721 divbuf_21/OUT4 divbuf_21/OUT 1.11fF
C722 divbuf_12/a_492_n240# divbuf_12/OUT5 0.01fF
C723 pd_0/tspc_r_0/Z4 pd_0/tspc_r_1/Z4 0.02fF
C724 pd_0/DOWN pd_0/and_pd_0/Out1 0.12fF
C725 pd_0/REF pd_0/tspc_r_1/Z1 0.17fF
C726 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C727 pll_full_1/ro_complete_0/cbank_0/v pll_full_1/divider_0/clk 1.27fF
C728 divider_2/nor_1/B divider_2/tspc_0/Z1 0.03fF
C729 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_2/D 0.16fF
C730 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/clk 0.01fF
C731 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C732 pll_full_0/ro_complete_0/a0 pll_full_0/divider_0/clk 0.11fF
C733 pll_full_1/divider_0/tspc_2/Z2 pll_full_1/divider_0/tspc_2/Z4 0.36fF
C734 divbuf_2/OUT divbuf_2/OUT5 43.38fF
C735 divbuf_4/OUT ro_complete_0/cbank_1/v 0.05fF
C736 divider_0/nor_0/B divider_0/tspc_1/Z2 0.30fF
C737 divbuf_6/OUT divbuf_6/OUT5 43.38fF
C738 divbuf_3/IN divbuf_3/OUT5 0.00fF
C739 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C740 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/clk 0.64fF
C741 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C742 divider_1/mc2 divider_1/nor_0/A 0.04fF
C743 divbuf_14/OUT5 divbuf_14/OUT3 0.01fF
C744 divider_1/nor_0/B divider_1/nor_1/B 0.47fF
C745 divider_1/tspc_0/Z3 divider_1/tspc_0/Z4 0.65fF
C746 divider_1/nor_0/Z1 divider_1/and_0/A 0.80fF
C747 divbuf_6/OUT2 divbuf_6/OUT3 1.37fF
C748 divbuf_16/OUT divbuf_16/OUT5 43.38fF
C749 divider_1/tspc_2/Z3 divider_1/tspc_2/Z4 0.65fF
C750 pll_full_1/ro_complete_0/cbank_2/switch_4/vin pll_full_1/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C751 divbuf_23/OUT4 divbuf_23/OUT5 20.26fF
C752 divbuf_23/OUT3 divbuf_23/OUT 0.26fF
C753 cp_0/a_1710_0# cp_0/out 0.84fF
C754 pd_1/R pd_1/tspc_r_1/Qbar 0.03fF
C755 pd_0/tspc_r_1/Z3 pd_0/UP 0.03fF
C756 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/a_630_n680# 0.01fF
C757 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_0/Z1 0.06fF
C758 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C759 divbuf_18/OUT5 divbuf_18/OUT4 20.26fF
C760 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z3 0.29fF
C761 divbuf_0/a_492_n240# divbuf_0/OUT2 0.42fF
C762 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z3 0.45fF
C763 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C764 divbuf_25/OUT4 divbuf_25/OUT5 20.26fF
C765 divider_0/prescaler_0/Out divider_0/tspc_2/Z3 0.45fF
C766 divider_0/nor_0/B divider_0/nor_0/A 1.21fF
C767 ro_complete_1/a1 ro_complete_1/cbank_2/v 0.05fF
C768 divider_2/tspc_0/Z4 divider_2/nor_1/B 0.22fF
C769 divbuf_16/OUT3 divbuf_16/OUT 0.26fF
C770 divider_1/nor_0/B divider_1/tspc_2/a_630_n680# 0.01fF
C771 divbuf_10/OUT5 divbuf_10/OUT 43.38fF
C772 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C773 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C774 divbuf_22/a_492_n240# divbuf_22/OUT 0.00fF
C775 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/Out 0.21fF
C776 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/UP 0.03fF
C777 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.04fF
C778 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/clk 0.45fF
C779 divider_2/prescaler_0/tspc_2/Z4 divider_2/clk 0.12fF
C780 divider_0/tspc_0/Z1 divider_0/tspc_1/Q 0.01fF
C781 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z3 0.06fF
C782 divbuf_0/OUT4 divbuf_0/OUT3 5.16fF
C783 divbuf_4/OUT divbuf_4/OUT4 1.11fF
C784 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C785 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT 0.00fF
C786 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/a_492_n240# 0.01fF
C787 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C788 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z4 0.36fF
C789 divider_1/tspc_0/Z2 divider_1/nor_0/B 0.20fF
C790 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/Out 0.04fF
C791 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C792 divbuf_21/a_492_n240# divbuf_21/IN 0.13fF
C793 pd_0/R pd_0/tspc_r_1/Z3 0.29fF
C794 divbuf_8/OUT4 divbuf_8/OUT 1.11fF
C795 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/nor_0/B 0.22fF
C796 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/nor_1/B 0.38fF
C797 pll_full_0/ro_complete_0/a3 pll_full_0/divider_0/clk 0.11fF
C798 divbuf_24/a_492_n240# divbuf_24/OUT5 0.01fF
C799 divider_2/tspc_2/Z2 divider_2/tspc_2/Z4 0.36fF
C800 divider_0/tspc_1/Z1 divider_0/tspc_2/Q 0.01fF
C801 divider_0/nor_0/B divider_0/tspc_1/a_630_n680# 0.35fF
C802 divbuf_2/OUT ro_complete_0/cbank_1/switch_0/vin 0.09fF
C803 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/v 1.30fF
C804 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/z5 0.11fF
C805 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C806 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C807 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/clk 0.14fF
C808 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C809 filter_0/v divbuf_25/OUT2 0.06fF
C810 divbuf_7/OUT2 divbuf_7/OUT3 1.37fF
C811 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/pd_0/tspc_r_1/Z2 0.71fF
C812 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C813 pd_1/R pd_1/tspc_r_0/Z3 0.27fF
C814 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Z4 0.65fF
C815 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.13fF
C816 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/and_0/OUT 0.14fF
C817 divbuf_15/OUT4 divbuf_15/OUT5 20.26fF
C818 divbuf_25/OUT3 divbuf_25/OUT2 1.37fF
C819 divider_0/nor_0/Z1 divider_0/and_0/B 0.18fF
C820 divider_0/tspc_2/Q divider_0/tspc_1/Z2 0.14fF
C821 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z2 0.01fF
C822 divbuf_6/OUT ro_complete_0/cbank_1/v 0.05fF
C823 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/cbank_1/v 1.43fF
C824 pll_full_1/pd_0/DOWN pll_full_1/pd_0/and_pd_0/Z1 0.07fF
C825 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C826 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/clk 0.45fF
C827 divider_1/mc2 divider_1/and_0/B 0.20fF
C828 divider_0/and_0/out1 divider_0/and_0/B 0.18fF
C829 divbuf_10/a_492_n240# divbuf_10/OUT2 0.42fF
C830 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/IN 5.26fF
C831 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C832 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z4 0.28fF
C833 pll_full_1/pd_0/tspc_r_0/Qbar pll_full_1/pd_0/DOWN 0.21fF
C834 divbuf_11/OUT5 divbuf_11/OUT 43.38fF
C835 pll_full_0/divbuf_0/IN pll_full_0/divider_0/tspc_0/a_630_n680# 0.04fF
C836 pd_1/R pd_1/and_pd_0/Z1 0.02fF
C837 divbuf_9/a_492_n240# divbuf_9/OUT 0.00fF
C838 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.11fF
C839 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/clk 0.12fF
C840 divbuf_5/OUT ro_complete_0/cbank_1/switch_3/vin 0.09fF
C841 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/tspc_r_1/z5 0.02fF
C842 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z2 0.25fF
C843 divbuf_14/OUT divbuf_14/a_492_n240# 0.00fF
C844 divider_0/nor_0/B divider_0/and_0/B 0.31fF
C845 divider_0/tspc_2/Q divider_0/nor_0/A 0.55fF
C846 divider_0/and_0/OUT divider_0/prescaler_0/nand_0/z1 0.01fF
C847 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C848 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/nor_0/B 0.22fF
C849 pll_full_0/divbuf_0/OUT4 pll_full_0/divbuf_0/OUT3 5.16fF
C850 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/switch_5/vin 0.20fF
C851 divider_2/tspc_0/Z4 divider_2/tspc_0/Z1 0.00fF
C852 divbuf_20/IN divbuf_20/OUT5 0.00fF
C853 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C854 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Q 0.91fF
C855 divider_1/tspc_2/Q divider_1/tspc_2/a_630_n680# 0.04fF
C856 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/D 0.03fF
C857 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/z5 0.20fF
C858 divider_2/tspc_0/Z3 divider_2/nor_1/B 0.38fF
C859 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z3 0.33fF
C860 divbuf_8/a_492_n240# divbuf_8/IN 0.13fF
C861 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_0/z5 0.04fF
C862 divbuf_18/OUT divbuf_18/a_492_n240# 0.00fF
C863 divider_2/and_0/OUT divider_2/and_0/Z1 0.04fF
C864 divider_2/prescaler_0/tspc_2/Q divider_2/clk 0.05fF
C865 divbuf_13/OUT4 divbuf_13/OUT 1.11fF
C866 divbuf_4/OUT divbuf_3/OUT 2.71fF
C867 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/clk 0.45fF
C868 divbuf_0/OUT divbuf_0/a_492_n240# 0.00fF
C869 divider_0/nor_0/B divider_0/tspc_1/Q 0.51fF
C870 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z4 0.65fF
C871 divider_0/and_0/OUT divider_0/clk 0.04fF
C872 divbuf_1/OUT5 divbuf_1/OUT3 0.01fF
C873 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/R 0.27fF
C874 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C875 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/and_0/OUT 0.14fF
C876 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C877 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C878 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_0/a_630_n680# 0.04fF
C879 divider_1/nor_0/B divider_1/tspc_1/Z1 0.03fF
C880 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_2/v 0.08fF
C881 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C882 divider_1/prescaler_0/tspc_1/Q divider_1/nor_0/A 0.03fF
C883 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/DOWN 0.12fF
C884 pd_1/R pd_1/tspc_r_0/Qbar1 0.01fF
C885 pd_1/tspc_r_0/Qbar pd_1/DOWN 0.21fF
C886 pd_0/tspc_r_0/z5 pd_0/tspc_r_1/z5 0.02fF
C887 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z2 0.25fF
C888 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C889 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/nand_0/z1 0.07fF
C890 divbuf_12/OUT2 divbuf_12/OUT3 1.37fF
C891 divbuf_6/OUT divbuf_7/OUT 2.98fF
C892 divbuf_3/OUT ro_complete_0/cbank_2/switch_2/vin 0.09fF
C893 divider_0/tspc_2/Q divider_0/tspc_1/a_630_n680# 0.01fF
C894 divider_0/tspc_1/Z1 divider_0/tspc_1/Z3 0.06fF
C895 divider_0/nor_0/A divider_0/and_0/A 0.01fF
C896 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C897 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C898 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/clk 0.12fF
C899 divbuf_6/OUT2 divbuf_6/OUT5 0.02fF
C900 divbuf_6/OUT3 divbuf_6/OUT4 5.16fF
C901 divider_1/nor_0/B divider_1/tspc_1/Z2 0.30fF
C902 divbuf_11/a_492_n240# divbuf_11/OUT2 0.42fF
C903 pll_full_1/pd_0/DIV pll_full_1/divider_0/clk 2.26fF
C904 pll_full_1/ro_complete_0/cbank_2/switch_4/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C905 divbuf_17/a_492_n240# divbuf_17/OUT5 0.01fF
C906 divbuf_16/OUT divbuf_16/OUT4 1.11fF
C907 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_0/B 0.06fF
C908 pd_1/tspc_r_0/Z4 pd_1/DIV 0.02fF
C909 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/nor_0/A 0.15fF
C910 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C911 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.21fF
C912 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Q 0.05fF
C913 divider_2/prescaler_0/m1_2700_2190# divider_2/clk 0.01fF
C914 divbuf_23/OUT5 divbuf_23/OUT 43.38fF
C915 pll_full_1/divbuf_1/OUT2 pll_full_1/divbuf_1/a_492_n240# 0.42fF
C916 pll_full_1/divbuf_0/OUT3 pll_full_1/divbuf_0/OUT5 0.01fF
C917 pll_full_0/cp_0/a_1710_0# pll_full_0/cp_0/down 0.32fF
C918 pll_full_1/divider_0/and_0/B pll_full_1/divider_0/and_0/Z1 0.07fF
C919 divbuf_3/OUT divbuf_3/OUT2 0.06fF
C920 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C921 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/v 1.30fF
C922 divider_0/prescaler_0/m1_2700_2190# divider_0/nor_0/A 0.01fF
C923 divider_0/prescaler_0/Out divider_0/tspc_2/Z4 0.12fF
C924 divider_0/tspc_1/Z2 divider_0/tspc_1/Z3 0.16fF
C925 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/D 0.15fF
C926 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C927 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z4 0.01fF
C928 ro_complete_1/cbank_1/switch_5/vin ro_complete_1/cbank_1/v 1.30fF
C929 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C930 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/clk 0.45fF
C931 divbuf_19/OUT2 divbuf_19/OUT5 0.02fF
C932 divider_1/prescaler_0/Out divider_1/tspc_2/Z3 0.45fF
C933 divider_1/nor_0/B divider_1/nor_0/A 1.21fF
C934 divbuf_22/IN divbuf_22/OUT5 0.00fF
C935 pd_0/DIV pd_0/tspc_r_0/Qbar1 0.12fF
C936 divider_2/nor_0/Z1 divider_2/nor_0/B 0.06fF
C937 pll_full_1/pd_0/tspc_r_1/z5 pll_full_1/pd_0/tspc_r_0/z5 0.02fF
C938 pd_1/REF pd_1/tspc_r_1/Z4 0.02fF
C939 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 pll_full_1/divider_0/clk 0.12fF
C940 divbuf_13/a_492_n240# divbuf_13/IN 0.13fF
C941 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C942 divbuf_0/OUT5 divbuf_0/OUT3 0.01fF
C943 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_4/vin 0.20fF
C944 divider_0/tspc_0/Z1 divider_0/tspc_0/Z3 0.06fF
C945 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z4 0.00fF
C946 divbuf_5/OUT divbuf_5/OUT2 0.06fF
C947 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C948 divbuf_25/a_492_n240# divbuf_25/OUT5 0.01fF
C949 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT5 0.02fF
C950 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Q 0.15fF
C951 divider_1/tspc_0/Z1 divider_1/tspc_1/Q 0.01fF
C952 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z3 0.06fF
C953 pd_1/tspc_r_0/Z2 pd_1/R 0.21fF
C954 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z3 0.65fF
C955 divbuf_17/a_492_n240# divbuf_17/OUT 0.00fF
C956 divider_2/tspc_2/Q divider_2/tspc_2/a_630_n680# 0.04fF
C957 divider_2/tspc_0/Z3 divider_2/tspc_0/Z1 0.06fF
C958 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/B 0.18fF
C959 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/nor_0/A 0.35fF
C960 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/clk 0.60fF
C961 divbuf_24/OUT2 divbuf_24/OUT3 1.37fF
C962 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/Out 0.21fF
C963 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z3 0.06fF
C964 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/nor_0/A 0.15fF
C965 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C966 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C967 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/a_630_n680# 0.19fF
C968 divbuf_25/IN divbuf_25/OUT5 0.00fF
C969 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z3 0.05fF
C970 divider_0/nor_0/A divider_0/tspc_2/Z1 0.03fF
C971 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C972 divider_1/tspc_1/Z1 divider_1/tspc_2/Q 0.01fF
C973 divider_1/nor_0/B divider_1/tspc_1/a_630_n680# 0.35fF
C974 pll_full_0/divider_0/and_0/B pll_full_0/divider_0/and_0/Z1 0.07fF
C975 divbuf_7/OUT2 divbuf_7/OUT5 0.02fF
C976 divbuf_7/OUT3 divbuf_7/OUT4 5.16fF
C977 pll_full_1/ro_complete_0/cbank_0/v pll_full_1/ro_complete_0/cbank_2/v 0.04fF
C978 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/UP 0.11fF
C979 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C980 divbuf_23/a_492_n240# divbuf_23/OUT2 0.42fF
C981 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.21fF
C982 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_2/D 0.16fF
C983 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.03fF
C984 divider_2/mc2 divider_2/and_0/out1 0.06fF
C985 divider_2/nor_0/Z1 divider_2/and_0/A 0.80fF
C986 divbuf_15/OUT5 divbuf_15/OUT 43.38fF
C987 divbuf_0/OUT3 divbuf_0/OUT2 1.37fF
C988 pll_full_0/pd_0/REF pll_full_0/divbuf_1/OUT5 0.00fF
C989 divider_0/mc2 divider_0/and_0/out1 0.06fF
C990 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z3 0.05fF
C991 divbuf_3/a_492_n240# divbuf_3/OUT5 0.01fF
C992 ro_complete_1/a0 ro_complete_1/cbank_1/switch_5/vin 0.09fF
C993 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/clk 0.12fF
C994 divider_2/tspc_0/Z4 divider_2/tspc_0/Z3 0.65fF
C995 divider_0/and_0/A divider_0/and_0/B 0.18fF
C996 divider_1/tspc_2/Q divider_1/tspc_1/Z2 0.14fF
C997 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z2 0.01fF
C998 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C999 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_0/a_630_n680# 0.05fF
C1000 divider_2/nor_1/Z1 divider_2/and_0/B 0.78fF
C1001 divider_1/and_0/out1 divider_1/and_0/B 0.18fF
C1002 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C1003 divbuf_9/IN divbuf_9/OUT5 0.00fF
C1004 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Z1 0.17fF
C1005 pll_full_0/pd_0/DIV pll_full_0/pd_0/R 0.51fF
C1006 divbuf_17/OUT5 divbuf_17/OUT 43.38fF
C1007 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_2/Q 0.19fF
C1008 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/clk 0.01fF
C1009 divider_2/nor_1/B divider_2/and_0/B 0.29fF
C1010 divider_0/mc2 divider_0/nor_0/B 0.06fF
C1011 ro_complete_0/cbank_0/switch_0/vin divbuf_4/OUT 0.12fF
C1012 divbuf_5/OUT ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1013 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Qbar 0.01fF
C1014 ro_complete_1/a2 ro_complete_1/cbank_2/switch_2/vin 0.14fF
C1015 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/OUT3 0.01fF
C1016 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1017 divider_0/prescaler_0/tspc_2/D divider_0/prescaler_0/nand_0/z1 0.24fF
C1018 divbuf_4/a_492_n240# divbuf_4/OUT5 0.01fF
C1019 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/v 1.30fF
C1020 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/nor_0/A 0.35fF
C1021 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/clk 0.60fF
C1022 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divbuf_0/IN 0.05fF
C1023 divider_1/nor_0/B divider_1/and_0/B 0.31fF
C1024 divider_1/tspc_2/Q divider_1/nor_0/A 0.55fF
C1025 divider_1/and_0/OUT divider_1/prescaler_0/nand_0/z1 0.01fF
C1026 divbuf_20/OUT3 divbuf_20/OUT5 0.01fF
C1027 divbuf_20/OUT2 divbuf_20/OUT 0.06fF
C1028 divider_2/tspc_0/Z2 divider_2/nor_0/B 0.20fF
C1029 divider_2/tspc_0/a_630_n680# divider_2/nor_1/B 0.35fF
C1030 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z3 0.05fF
C1031 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z4 0.08fF
C1032 pll_full_0/ro_complete_0/a4 pll_full_0/divider_0/clk 0.01fF
C1033 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_0/Z1 0.03fF
C1034 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 pll_full_1/divider_0/clk 0.12fF
C1035 divider_2/tspc_2/a_630_n680# divider_2/nor_0/A 0.35fF
C1036 divider_2/prescaler_0/tspc_0/D divider_2/clk 0.29fF
C1037 divider_0/tspc_0/Z1 divider_0/tspc_0/Z4 0.00fF
C1038 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1039 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1040 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/switch_0/vin 0.19fF
C1041 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1042 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C1043 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C1044 divbuf_17/IN divbuf_17/a_492_n240# 0.13fF
C1045 divider_1/mc2 divider_1/and_0/OUT 0.05fF
C1046 divbuf_14/OUT divbuf_14/OUT4 1.11fF
C1047 divider_0/and_0/OUT divider_0/and_0/out1 0.31fF
C1048 divider_0/prescaler_0/tspc_2/D divider_0/clk 0.26fF
C1049 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z1 0.06fF
C1050 divider_1/nor_0/B divider_1/tspc_1/Q 0.51fF
C1051 pll_full_0/pd_0/DIV pll_full_0/divider_0/and_0/OUT 0.01fF
C1052 divider_1/and_0/OUT divider_1/clk 0.04fF
C1053 pll_full_1/pd_0/DIV pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.03fF
C1054 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/Qbar 0.01fF
C1055 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1056 divbuf_12/OUT2 divbuf_12/OUT5 0.02fF
C1057 divbuf_12/OUT3 divbuf_12/OUT4 5.16fF
C1058 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Qbar1 0.38fF
C1059 divider_2/prescaler_0/tspc_1/Z2 divider_2/and_0/OUT 0.06fF
C1060 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z3 0.33fF
C1061 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Q 0.38fF
C1062 divider_2/prescaler_0/tspc_0/Z2 divider_2/clk 0.11fF
C1063 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT4 1.11fF
C1064 divider_2/and_0/out1 divider_2/and_0/A 0.01fF
C1065 divbuf_14/OUT2 divbuf_14/OUT 0.06fF
C1066 divider_0/tspc_1/Q divider_0/tspc_1/Z3 0.05fF
C1067 divider_0/tspc_1/Z1 divider_0/tspc_1/Z4 0.00fF
C1068 divider_0/Out divider_0/nor_1/B 0.22fF
C1069 divbuf_2/OUT ro_complete_0/cbank_1/v 0.10fF
C1070 ro_complete_0/cbank_0/switch_5/vin divbuf_7/OUT 0.09fF
C1071 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/tspc_r_1/Z3 0.38fF
C1072 pll_full_1/pd_0/R pll_full_1/pd_0/tspc_r_1/Qbar 0.03fF
C1073 pll_full_1/pd_0/DOWN pll_full_1/pd_0/UP 4.58fF
C1074 divbuf_16/a_492_n240# divbuf_16/OUT 0.00fF
C1075 filter_0/v divbuf_25/OUT3 0.26fF
C1076 divbuf_6/OUT4 divbuf_6/OUT5 20.26fF
C1077 divider_2/prescaler_0/Out divider_2/prescaler_0/m1_2700_2190# 0.11fF
C1078 divider_1/tspc_2/Q divider_1/tspc_1/a_630_n680# 0.01fF
C1079 divider_1/tspc_1/Z1 divider_1/tspc_1/Z3 0.06fF
C1080 divider_1/nor_0/A divider_1/and_0/A 0.01fF
C1081 pll_full_1/ro_complete_0/cbank_2/switch_0/vin pll_full_1/ro_complete_0/cbank_2/v 1.45fF
C1082 pd_1/tspc_r_0/z5 pd_1/tspc_r_0/Z3 0.11fF
C1083 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/Z2 0.11fF
C1084 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1085 pll_full_1/ro_complete_0/cbank_2/v pll_full_1/divider_0/clk 1.36fF
C1086 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/DOWN 0.11fF
C1087 divbuf_19/OUT5 divbuf_19/OUT4 20.26fF
C1088 divbuf_19/OUT divbuf_19/OUT3 0.26fF
C1089 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/clk 0.01fF
C1090 divbuf_0/IN divbuf_0/OUT5 0.00fF
C1091 divider_0/tspc_1/Z2 divider_0/tspc_1/Z4 0.36fF
C1092 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/D 0.05fF
C1093 divider_0/prescaler_0/tspc_0/Z3 divider_0/clk 0.64fF
C1094 divbuf_1/OUT5 divbuf_1/a_492_n240# 0.01fF
C1095 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/tspc_r_0/Z3 0.25fF
C1096 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a4 0.12fF
C1097 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1098 ro_complete_1/cbank_0/v ro_complete_1/cbank_2/v 0.04fF
C1099 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_0/Z1 0.03fF
C1100 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/clk 0.12fF
C1101 divbuf_17/IN divbuf_17/OUT5 0.00fF
C1102 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1103 pll_full_1/ro_complete_0/cbank_0/switch_2/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1104 divider_1/prescaler_0/m1_2700_2190# divider_1/nor_0/A 0.01fF
C1105 divider_1/prescaler_0/Out divider_1/tspc_2/Z4 0.12fF
C1106 divider_1/tspc_1/Z2 divider_1/tspc_1/Z3 0.16fF
C1107 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/D 0.15fF
C1108 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/tspc_r_0/Z3 0.38fF
C1109 pd_0/tspc_r_0/Z3 pd_0/DOWN 0.03fF
C1110 io_clamp_low[2] io_analog[6] 0.53fF
C1111 divider_2/mc2 divider_2/nor_0/B 0.06fF
C1112 divider_2/tspc_2/Q divider_2/tspc_1/Z2 0.14fF
C1113 divbuf_22/OUT3 divbuf_22/OUT5 0.01fF
C1114 divbuf_22/OUT2 divbuf_22/OUT 0.06fF
C1115 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_1/Q 0.45fF
C1116 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C1117 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/z5 0.11fF
C1118 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/R 0.01fF
C1119 divbuf_18/OUT5 divbuf_18/a_492_n240# 0.01fF
C1120 pll_full_1/divbuf_1/OUT3 pll_full_1/divbuf_1/OUT5 0.01fF
C1121 pll_full_1/divbuf_1/OUT2 pll_full_1/divbuf_1/OUT 0.06fF
C1122 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1123 divbuf_0/OUT divbuf_0/OUT3 0.26fF
C1124 ro_complete_0/cbank_0/switch_1/vin divbuf_3/OUT 0.13fF
C1125 divider_0/tspc_1/Z4 divider_0/nor_0/A 0.02fF
C1126 divbuf_5/OUT divbuf_5/OUT4 1.11fF
C1127 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Z1 0.09fF
C1128 pll_full_0/divbuf_1/OUT4 pll_full_0/divbuf_1/OUT5 20.26fF
C1129 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT 0.26fF
C1130 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1131 divider_1/tspc_0/Z1 divider_1/tspc_0/Z3 0.06fF
C1132 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z4 0.00fF
C1133 divbuf_21/a_492_n240# divbuf_21/OUT5 0.01fF
C1134 divbuf_18/OUT3 divbuf_18/OUT 0.26fF
C1135 divider_2/tspc_2/Q divider_2/nor_0/A 0.55fF
C1136 divider_2/nor_1/B divider_2/tspc_1/Q 0.22fF
C1137 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C1138 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/and_0/A 0.80fF
C1139 pll_full_1/ro_complete_0/cbank_1/switch_2/vin pll_full_1/divider_0/clk 1.46fF
C1140 pd_1/tspc_r_1/Qbar pd_1/UP 0.21fF
C1141 pll_full_0/ro_complete_0/a1 pll_full_0/divider_0/clk 0.11fF
C1142 divbuf_24/OUT2 divbuf_24/OUT5 0.02fF
C1143 divbuf_24/OUT3 divbuf_24/OUT4 5.16fF
C1144 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/Z1 0.04fF
C1145 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z2 0.01fF
C1146 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/clk 0.05fF
C1147 divider_0/nor_0/B divider_0/tspc_0/Z4 0.02fF
C1148 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1149 divbuf_2/OUT2 divbuf_2/a_492_n240# 0.42fF
C1150 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/v 1.30fF
C1151 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z4 0.12fF
C1152 divider_0/tspc_2/Z1 divider_0/tspc_2/Z2 1.07fF
C1153 divider_0/nor_0/A divider_0/tspc_2/Z3 0.38fF
C1154 divbuf_6/OUT divbuf_6/a_492_n240# 0.00fF
C1155 ro_complete_1/a4 ro_complete_1/cbank_2/switch_0/vin 0.12fF
C1156 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z2 0.11fF
C1157 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1158 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/a0 0.09fF
C1159 pll_full_0/ro_complete_0/cbank_2/v pll_full_0/divider_0/clk 1.36fF
C1160 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z3 0.06fF
C1161 divbuf_7/OUT4 divbuf_7/OUT5 20.26fF
C1162 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z3 0.05fF
C1163 divider_1/nor_0/A divider_1/tspc_2/Z1 0.03fF
C1164 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_0/Z2 0.14fF
C1165 pd_1/R pd_1/tspc_r_1/Z3 0.29fF
C1166 pd_1/tspc_r_0/Qbar1 pd_1/tspc_r_0/z5 0.20fF
C1167 pd_1/tspc_r_0/Z1 pd_1/DIV 0.17fF
C1168 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z1 0.17fF
C1169 divbuf_19/OUT5 divbuf_19/a_492_n240# 0.01fF
C1170 divider_2/mc2 divider_2/and_0/A 0.16fF
C1171 divider_2/prescaler_0/tspc_2/Z2 divider_2/and_0/OUT 0.05fF
C1172 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/nor_1/B 0.00fF
C1173 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/nand_0/z1 0.07fF
C1174 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.05fF
C1175 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/z5 0.04fF
C1176 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/B 0.18fF
C1177 divbuf_14/IN divbuf_14/a_492_n240# 0.13fF
C1178 divider_0/mc2 divider_0/and_0/A 0.16fF
C1179 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z4 0.12fF
C1180 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1181 divbuf_7/OUT ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1182 ro_complete_0/cbank_0/v ro_complete_0/cbank_1/v 1.27fF
C1183 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C1184 divider_2/tspc_0/Z4 divider_2/tspc_0/a_630_n680# 0.12fF
C1185 divbuf_3/OUT3 divbuf_3/OUT4 5.16fF
C1186 ro_complete_1/a0 ro_complete_1/cbank_1/v 0.05fF
C1187 pll_full_1/pd_0/DIV pll_full_1/pd_0/tspc_r_0/z5 0.04fF
C1188 divbuf_10/a_492_n240# divbuf_10/OUT 0.00fF
C1189 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z3 0.05fF
C1190 pll_full_1/ro_complete_0/cbank_2/switch_5/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C1191 divider_2/tspc_2/Q divider_2/tspc_1/Z1 0.01fF
C1192 divider_2/tspc_1/a_630_n680# divider_2/nor_0/B 0.35fF
C1193 divider_1/and_0/A divider_1/and_0/B 0.18fF
C1194 cp_0/a_1710_n2840# cp_0/upbar 0.29fF
C1195 pd_1/tspc_r_0/Z4 pd_1/tspc_r_1/Z4 0.02fF
C1196 pd_1/REF pd_1/tspc_r_1/Qbar1 0.12fF
C1197 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z4 0.02fF
C1198 divider_2/tspc_1/Z2 divider_2/nor_0/A 0.15fF
C1199 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_0/D 0.32fF
C1200 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/clk 0.01fF
C1201 divider_2/nor_0/B divider_2/and_0/A 0.26fF
C1202 divbuf_9/OUT3 divbuf_9/OUT5 0.01fF
C1203 divbuf_9/OUT2 divbuf_9/OUT 0.06fF
C1204 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_2/a_630_n680# 0.01fF
C1205 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.05fF
C1206 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/clk 0.01fF
C1207 divbuf_5/OUT ro_complete_0/cbank_2/switch_3/vin 0.09fF
C1208 pll_full_0/cp_0/upbar pll_full_0/cp_0/down 0.02fF
C1209 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C1210 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/pd_0/tspc_r_1/Z2 0.71fF
C1211 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z4 0.20fF
C1212 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/Q 0.04fF
C1213 divider_0/prescaler_0/tspc_1/Z3 divider_0/clk 0.45fF
C1214 divbuf_1/OUT divbuf_1/OUT4 1.11fF
C1215 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_4/vin 0.20fF
C1216 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C1217 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a3 0.13fF
C1218 divbuf_7/OUT divbuf_7/OUT3 0.26fF
C1219 divbuf_4/OUT2 divbuf_4/OUT3 1.37fF
C1220 ro_complete_1/cbank_2/switch_0/vin ro_complete_1/cbank_2/v 1.45fF
C1221 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/Z1 0.04fF
C1222 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z2 0.01fF
C1223 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/clk 0.05fF
C1224 divbuf_20/OUT4 divbuf_20/OUT 1.11fF
C1225 pll_full_1/divbuf_0/a_492_n240# pll_full_1/divbuf_0/OUT2 0.42fF
C1226 divider_1/prescaler_0/tspc_2/D divider_1/prescaler_0/nand_0/z1 0.24fF
C1227 divbuf_8/a_492_n240# divbuf_8/OUT5 0.01fF
C1228 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z3 0.06fF
C1229 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C1230 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z4 0.12fF
C1231 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z2 1.07fF
C1232 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Out1 0.05fF
C1233 pll_full_0/pd_0/DOWN pll_full_0/cp_0/a_1710_0# 0.04fF
C1234 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z2 0.01fF
C1235 ro_complete_1/a2 ro_complete_1/cbank_1/switch_3/vin 0.09fF
C1236 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/UP 0.21fF
C1237 divider_0/nor_1/Z1 divider_0/nor_1/B 0.06fF
C1238 divbuf_14/OUT divbuf_14/OUT3 0.26fF
C1239 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_1/B 0.00fF
C1240 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C1241 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C1242 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/Z1 0.00fF
C1243 divider_1/tspc_0/Z1 divider_1/tspc_0/Z4 0.00fF
C1244 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z2 0.19fF
C1245 divbuf_5/OUT2 divbuf_5/OUT3 1.37fF
C1246 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/B 0.18fF
C1247 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z2 0.01fF
C1248 divider_1/and_0/OUT divider_1/and_0/out1 0.31fF
C1249 divider_1/prescaler_0/tspc_2/D divider_1/clk 0.26fF
C1250 divbuf_12/OUT4 divbuf_12/OUT5 20.26fF
C1251 divbuf_12/OUT3 divbuf_12/OUT 0.26fF
C1252 pd_0/REF pd_0/tspc_r_1/z5 0.04fF
C1253 pd_0/tspc_r_1/Z1 pd_0/tspc_r_1/Z2 0.71fF
C1254 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z4 0.20fF
C1255 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/and_0/OUT 0.06fF
C1256 divider_2/tspc_1/Q divider_2/tspc_0/Z1 0.01fF
C1257 divider_2/tspc_1/Z1 divider_2/tspc_1/Z2 1.07fF
C1258 divider_2/nor_0/B divider_2/tspc_1/Z3 0.38fF
C1259 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z3 0.05fF
C1260 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z4 0.08fF
C1261 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Q 0.04fF
C1262 pd_1/and_pd_0/Z1 pd_1/UP 0.06fF
C1263 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT5 43.38fF
C1264 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_1/Qbar 0.02fF
C1265 divbuf_5/OUT ro_complete_0/cbank_2/v 0.05fF
C1266 pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1267 divbuf_14/OUT2 divbuf_14/a_492_n240# 0.42fF
C1268 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_1/Q 0.13fF
C1269 divider_0/prescaler_0/m1_2700_2190# divider_0/and_0/OUT 0.14fF
C1270 pll_full_1/pd_0/R pll_full_1/pd_0/DIV 0.51fF
C1271 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C1272 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C1273 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/clk 0.01fF
C1274 ro_complete_1/a3 ro_complete_1/cbank_1/v 0.05fF
C1275 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1276 divider_1/tspc_1/Q divider_1/tspc_1/Z3 0.05fF
C1277 divider_1/tspc_1/Z1 divider_1/tspc_1/Z4 0.00fF
C1278 divider_1/Out divider_1/nor_1/B 0.22fF
C1279 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1280 divbuf_11/a_492_n240# divbuf_11/OUT 0.00fF
C1281 pd_0/tspc_r_1/Qbar pd_0/UP 0.21fF
C1282 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C1283 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z2 0.25fF
C1284 divbuf_18/OUT5 divbuf_18/OUT 43.38fF
C1285 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/switch_1/vin 0.19fF
C1286 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar 0.03fF
C1287 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_4/vin 0.20fF
C1288 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z3 0.06fF
C1289 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C1290 divider_0/prescaler_0/tspc_2/Z4 divider_0/prescaler_0/tspc_2/D 0.11fF
C1291 divider_0/prescaler_0/tspc_0/Z4 divider_0/clk 0.12fF
C1292 divider_2/tspc_0/Z4 divider_2/tspc_1/Q 0.15fF
C1293 divider_1/tspc_1/Z2 divider_1/tspc_1/Z4 0.36fF
C1294 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/D 0.05fF
C1295 divider_1/prescaler_0/tspc_0/Z3 divider_1/clk 0.64fF
C1296 divbuf_20/a_492_n240# divbuf_20/IN 0.13fF
C1297 pll_full_1/divbuf_1/a_492_n240# pll_full_1/divbuf_1/OUT 0.00fF
C1298 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C1299 divbuf_22/OUT4 divbuf_22/OUT 1.11fF
C1300 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z1 0.09fF
C1301 pd_0/DIV pd_0/tspc_r_0/Z2 0.19fF
C1302 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_0/Z4 0.65fF
C1303 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C1304 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1305 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z3 0.05fF
C1306 divider_2/tspc_0/Z3 divider_2/tspc_0/a_630_n680# 0.05fF
C1307 divbuf_13/a_492_n240# divbuf_13/OUT5 0.01fF
C1308 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.19fF
C1309 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/clk 0.01fF
C1310 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/z5 0.11fF
C1311 divbuf_5/OUT ro_complete_0/cbank_1/switch_2/vin 0.14fF
C1312 pll_full_1/divbuf_1/OUT4 pll_full_1/divbuf_1/OUT 1.11fF
C1313 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Out1 0.05fF
C1314 divider_0/tspc_0/a_630_n680# divider_0/Out 0.04fF
C1315 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/a1 0.14fF
C1316 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/a3 0.09fF
C1317 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C1318 divider_0/prescaler_0/tspc_2/Z3 divider_0/clk 0.45fF
C1319 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/Z4 0.65fF
C1320 ro_complete_1/cbank_2/switch_5/vin ro_complete_1/cbank_2/v 1.30fF
C1321 divider_2/prescaler_0/Out divider_2/tspc_2/Z3 0.45fF
C1322 divider_1/tspc_1/Z4 divider_1/nor_0/A 0.02fF
C1323 divbuf_21/OUT2 divbuf_21/OUT3 1.37fF
C1324 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C1325 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C1326 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1327 pd_0/R pd_0/tspc_r_1/Qbar 0.03fF
C1328 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_1/a_630_n680# 0.05fF
C1329 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/nor_0/B 0.03fF
C1330 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/nor_1/B 0.35fF
C1331 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C1332 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C1333 divbuf_24/OUT4 divbuf_24/OUT5 20.26fF
C1334 divbuf_24/OUT3 divbuf_24/OUT 0.26fF
C1335 filter_0/a_4216_n2998# filter_0/v 0.36fF
C1336 pd_1/and_pd_0/Out1 pd_1/and_pd_0/Z1 0.18fF
C1337 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z2 0.23fF
C1338 pll_full_1/divider_0/prescaler_0/tspc_0/D pll_full_1/divider_0/clk 0.29fF
C1339 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/z5 0.03fF
C1340 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/R 0.21fF
C1341 divider_2/nor_0/A divider_2/and_0/B 0.08fF
C1342 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/pd_0/UP 0.06fF
C1343 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1344 divbuf_3/IN divbuf_3/a_492_n240# 0.13fF
C1345 divbuf_1/a_492_n240# divbuf_1/IN 0.13fF
C1346 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/v 1.30fF
C1347 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C1348 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/IN 0.00fF
C1349 divider_0/tspc_2/Z2 divider_0/tspc_2/Z3 0.16fF
C1350 divider_0/nor_0/A divider_0/tspc_2/Z4 0.21fF
C1351 divider_1/nor_0/B divider_1/tspc_0/Z4 0.02fF
C1352 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z4 0.00fF
C1353 divbuf_6/a_492_n240# divbuf_6/OUT2 0.42fF
C1354 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z4 0.12fF
C1355 divider_1/tspc_2/Z1 divider_1/tspc_2/Z2 1.07fF
C1356 divider_1/nor_0/A divider_1/tspc_2/Z3 0.38fF
C1357 pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1358 divbuf_23/a_492_n240# divbuf_23/OUT 0.00fF
C1359 cp_0/a_1710_0# cp_0/a_1710_n2840# 0.83fF
C1360 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Out1 0.05fF
C1361 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/nor_1/B 0.47fF
C1362 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/and_0/OUT 0.06fF
C1363 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1364 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.38fF
C1365 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.11fF
C1366 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Q 0.20fF
C1367 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/D 0.09fF
C1368 divbuf_15/OUT5 divbuf_15/OUT3 0.01fF
C1369 divbuf_15/OUT divbuf_15/OUT2 0.06fF
C1370 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Z1 0.07fF
C1371 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C1372 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1373 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C1374 divider_0/prescaler_0/Out divider_0/tspc_2/a_630_n680# 0.01fF
C1375 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1376 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Q 0.21fF
C1377 divbuf_3/OUT4 divbuf_3/OUT5 20.26fF
C1378 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C1379 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/clk 0.01fF
C1380 divider_0/and_0/B divider_0/and_0/Z1 0.07fF
C1381 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C1382 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z4 0.12fF
C1383 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z3 0.06fF
C1384 divbuf_10/IN divbuf_10/OUT5 0.00fF
C1385 divbuf_22/a_492_n240# divbuf_22/IN 0.13fF
C1386 pd_1/tspc_r_0/z5 pd_1/tspc_r_1/z5 0.02fF
C1387 pd_0/and_pd_0/Z1 pd_0/UP 0.06fF
C1388 divbuf_9/OUT4 divbuf_9/OUT 1.11fF
C1389 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/Z1 0.01fF
C1390 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C1391 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/nor_0/A 1.21fF
C1392 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/tspc_0/D 0.04fF
C1393 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/nand_1/z1 0.22fF
C1394 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z3 0.33fF
C1395 divbuf_1/OUT2 divbuf_1/OUT5 0.02fF
C1396 divbuf_0/IN divbuf_0/a_492_n240# 0.13fF
C1397 divbuf_5/OUT ro_complete_0/cbank_0/switch_2/vin 0.14fF
C1398 ro_complete_0/cbank_0/switch_1/vin divbuf_4/OUT 0.09fF
C1399 ro_complete_0/cbank_0/switch_0/vin divbuf_2/OUT 0.09fF
C1400 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C1401 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/z5 0.20fF
C1402 divbuf_5/OUT divbuf_5/a_492_n240# 0.00fF
C1403 divbuf_3/OUT divbuf_3/OUT3 0.26fF
C1404 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/a_630_n680# 0.05fF
C1405 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/nor_0/B 0.03fF
C1406 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/nor_1/B 0.35fF
C1407 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C1408 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C1409 divider_0/prescaler_0/tspc_1/Z4 divider_0/clk 0.12fF
C1410 divbuf_7/OUT divbuf_7/OUT5 43.38fF
C1411 divbuf_4/OUT2 divbuf_4/OUT5 0.02fF
C1412 divbuf_4/OUT3 divbuf_4/OUT4 5.16fF
C1413 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z2 0.23fF
C1414 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/clk 0.29fF
C1415 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/Q 0.04fF
C1416 divider_1/prescaler_0/tspc_1/Z3 divider_1/clk 0.45fF
C1417 divbuf_18/OUT3 divbuf_18/OUT5 0.01fF
C1418 divider_2/tspc_0/Z3 divider_2/tspc_1/Q 0.45fF
C1419 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z3 0.16fF
C1420 divbuf_8/OUT2 divbuf_8/OUT3 1.37fF
C1421 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/divider_0/clk 1.46fF
C1422 pll_full_1/divbuf_0/OUT3 pll_full_1/pd_0/DIV 0.26fF
C1423 pll_full_0/ro_complete_0/a5 pll_full_0/divider_0/clk 0.15fF
C1424 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/out1 0.31fF
C1425 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/and_0/B 0.29fF
C1426 divider_2/nor_0/A divider_2/tspc_2/Z2 0.23fF
C1427 divbuf_2/IN divbuf_2/OUT5 0.00fF
C1428 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/and_pd_0/Z1 0.18fF
C1429 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C1430 pll_full_1/pd_0/tspc_r_1/Z4 pll_full_1/pd_0/tspc_r_0/Z4 0.02fF
C1431 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_1/B 0.47fF
C1432 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C1433 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1434 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C1435 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C1436 divider_0/prescaler_0/tspc_1/Q divider_0/clk 0.60fF
C1437 divbuf_5/OUT2 divbuf_5/OUT5 0.02fF
C1438 divbuf_5/OUT3 divbuf_5/OUT4 5.16fF
C1439 divider_1/nor_1/Z1 divider_1/nor_1/B 0.06fF
C1440 divbuf_17/OUT4 divbuf_17/OUT5 20.26fF
C1441 divbuf_7/a_492_n240# divbuf_7/OUT2 0.42fF
C1442 pll_full_0/ro_complete_0/a1 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1443 pd_0/R pd_0/and_pd_0/Z1 0.02fF
C1444 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/z5 0.20fF
C1445 divider_2/nor_0/B divider_2/tspc_1/Z4 0.21fF
C1446 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z4 0.12fF
C1447 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z2 1.07fF
C1448 divbuf_12/OUT5 divbuf_12/OUT 43.38fF
C1449 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/Z4 0.36fF
C1450 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/nor_0/B 0.35fF
C1451 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/nor_1/B 0.22fF
C1452 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/and_0/B 0.08fF
C1453 divider_2/and_0/out1 divider_2/and_0/Z1 0.36fF
C1454 divbuf_15/OUT5 divbuf_15/a_492_n240# 0.01fF
C1455 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_1/Q 0.21fF
C1456 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_2/D 0.16fF
C1457 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/D 0.03fF
C1458 divbuf_2/OUT divbuf_2/a_492_n240# 0.00fF
C1459 ro_complete_1/a4 ro_complete_1/cbank_2/v 0.05fF
C1460 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_0/vin 0.19fF
C1461 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z1 0.01fF
C1462 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C1463 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_0/A 1.21fF
C1464 divbuf_25/OUT2 divbuf_25/OUT5 0.02fF
C1465 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_1/Q 0.13fF
C1466 divider_1/prescaler_0/m1_2700_2190# divider_1/and_0/OUT 0.14fF
C1467 pll_full_0/pd_0/DIV pll_full_0/divider_0/clk 2.26fF
C1468 divbuf_17/OUT3 divbuf_17/OUT5 0.01fF
C1469 divbuf_11/IN divbuf_11/OUT5 0.00fF
C1470 pll_full_0/filter_0/a_4216_n5230# pll_full_0/divider_0/clk 1.58fF
C1471 pd_1/DIV pd_1/tspc_r_0/Z3 0.65fF
C1472 pd_0/and_pd_0/Out1 pd_0/and_pd_0/Z1 0.18fF
C1473 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/Qbar 0.01fF
C1474 divider_2/prescaler_0/tspc_1/Z2 divider_2/clk 0.11fF
C1475 divbuf_9/a_492_n240# divbuf_9/IN 0.13fF
C1476 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/and_0/OUT 0.05fF
C1477 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1478 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Qbar1 0.12fF
C1479 divbuf_7/OUT ro_complete_0/cbank_2/switch_5/vin 0.09fF
C1480 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C1481 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a4 0.09fF
C1482 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a5 0.09fF
C1483 io_clamp_low[2] io_clamp_high[2] 0.53fF
C1484 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/and_pd_0/Z1 0.02fF
C1485 pll_full_1/pd_0/R pll_full_1/pd_0/tspc_r_1/Z2 0.21fF
C1486 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/out1 0.31fF
C1487 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/B 0.29fF
C1488 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/OUT2 0.02fF
C1489 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C1490 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1491 divider_1/prescaler_0/tspc_2/Z4 divider_1/prescaler_0/tspc_2/D 0.11fF
C1492 divider_1/prescaler_0/tspc_0/Z4 divider_1/clk 0.12fF
C1493 pd_0/DIV pd_0/R 0.51fF
C1494 io_clamp_high[1] io_analog[5] 0.53fF
C1495 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1496 divbuf_17/OUT4 divbuf_17/OUT 1.11fF
C1497 divider_2/mc2 divider_2/prescaler_0/tspc_2/a_630_n680# 0.33fF
C1498 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z4 0.12fF
C1499 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1500 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1501 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/divider_0/clk 1.46fF
C1502 cp_0/upbar cp_0/down 0.02fF
C1503 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/tspc_r_0/Z2 0.71fF
C1504 divbuf_13/OUT2 divbuf_13/OUT3 1.37fF
C1505 divbuf_4/OUT divbuf_2/OUT 1.95fF
C1506 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/tspc_0/D 0.32fF
C1507 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C1508 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/v 1.30fF
C1509 divider_0/mc2 divider_0/prescaler_0/tspc_2/a_630_n680# 0.33fF
C1510 divider_0/prescaler_0/tspc_2/Z4 divider_0/clk 0.12fF
C1511 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/a1 0.14fF
C1512 pll_full_1/pd_0/tspc_r_1/Z4 pll_full_1/pd_0/tspc_r_1/z5 0.04fF
C1513 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/DIV 0.19fF
C1514 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z4 0.36fF
C1515 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_0/B 0.35fF
C1516 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_1/B 0.22fF
C1517 divbuf_5/a_492_n240# divbuf_5/IN 0.13fF
C1518 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/B 0.08fF
C1519 divider_1/tspc_0/a_630_n680# divider_1/Out 0.04fF
C1520 divbuf_21/OUT2 divbuf_21/OUT5 0.02fF
C1521 divbuf_21/OUT3 divbuf_21/OUT4 5.16fF
C1522 divider_2/prescaler_0/Out divider_2/tspc_2/Z4 0.12fF
C1523 divider_1/prescaler_0/tspc_2/Z3 divider_1/clk 0.45fF
C1524 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/DIV 0.12fF
C1525 pd_0/REF pd_0/tspc_r_1/Qbar1 0.12fF
C1526 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_1/a_630_n680# 0.04fF
C1527 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/nor_0/B 0.38fF
C1528 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C1529 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1530 pll_full_1/ro_complete_0/cbank_1/switch_4/vin pll_full_1/divider_0/clk 1.46fF
C1531 divbuf_17/OUT3 divbuf_17/OUT 0.26fF
C1532 divbuf_12/a_492_n240# divbuf_12/OUT2 0.42fF
C1533 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/divider_0/clk 1.27fF
C1534 filter_0/a_4216_n5230# filter_0/v 0.91fF
C1535 pd_1/tspc_r_1/z5 pd_1/UP 0.03fF
C1536 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z4 0.14fF
C1537 divbuf_24/OUT5 divbuf_24/OUT 43.38fF
C1538 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z3 0.06fF
C1539 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/switch_0/vin 0.19fF
C1540 divider_0/tspc_2/Z2 divider_0/tspc_2/Z4 0.36fF
C1541 divbuf_6/OUT divbuf_6/OUT2 0.06fF
C1542 ro_complete_1/a5 ro_complete_1/cbank_2/switch_0/vin 0.09fF
C1543 pll_full_1/pd_0/tspc_r_0/Z1 pll_full_1/pd_0/DIV 0.17fF
C1544 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/and_0/OUT 0.05fF
C1545 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1546 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Z4 0.65fF
C1547 divider_1/tspc_2/Z2 divider_1/tspc_2/Z3 0.16fF
C1548 divider_1/nor_0/A divider_1/tspc_2/Z4 0.21fF
C1549 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/tspc_r_1/Qbar 0.05fF
C1550 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C1551 divbuf_23/IN divbuf_23/OUT5 0.00fF
C1552 pd_1/tspc_r_0/Qbar1 pd_1/DIV 0.12fF
C1553 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1554 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1555 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.04fF
C1556 divider_2/tspc_1/Z3 divider_2/tspc_1/Z4 0.65fF
C1557 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Q 0.04fF
C1558 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/Z1 0.06fF
C1559 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_492_n240# 0.00fF
C1560 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C1561 divbuf_2/OUT3 divbuf_2/OUT5 0.01fF
C1562 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1563 divider_0/prescaler_0/Out divider_0/nor_0/A 0.15fF
C1564 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1565 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/clk 0.14fF
C1566 divider_0/nor_1/Z1 divider_0/and_0/B 0.78fF
C1567 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C1568 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C1569 divbuf_10/OUT3 divbuf_10/OUT5 0.01fF
C1570 divbuf_10/OUT2 divbuf_10/OUT 0.06fF
C1571 divider_1/prescaler_0/Out divider_1/tspc_2/a_630_n680# 0.01fF
C1572 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z4 0.00fF
C1573 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Q 0.21fF
C1574 divbuf_19/OUT5 divbuf_19/OUT 43.38fF
C1575 divider_1/and_0/B divider_1/and_0/Z1 0.07fF
C1576 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/Out 0.21fF
C1577 pd_1/R pd_1/UP 0.45fF
C1578 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z1 0.09fF
C1579 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/tspc_0/Z1 0.00fF
C1580 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/nand_1/z1 0.01fF
C1581 divider_2/prescaler_0/tspc_2/Z2 divider_2/clk 0.11fF
C1582 divbuf_2/OUT2 divbuf_2/OUT 0.06fF
C1583 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z3 0.05fF
C1584 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1585 divbuf_3/OUT divbuf_3/OUT5 43.38fF
C1586 ro_complete_0/cbank_1/v ro_complete_0/cbank_2/v 1.36fF
C1587 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.04fF
C1588 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/nor_0/B 0.38fF
C1589 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C1590 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1591 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1592 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z3 0.33fF
C1593 divbuf_4/OUT4 divbuf_4/OUT5 20.26fF
C1594 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z3 0.06fF
C1595 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1596 divbuf_16/OUT2 divbuf_16/OUT5 0.02fF
C1597 divider_1/prescaler_0/tspc_1/Z4 divider_1/clk 0.12fF
C1598 pll_full_1/pd_0/REF pll_full_1/divbuf_1/OUT5 0.00fF
C1599 divbuf_8/OUT2 divbuf_8/OUT5 0.02fF
C1600 divbuf_8/OUT3 divbuf_8/OUT4 5.16fF
C1601 pd_0/tspc_r_0/Z4 pd_0/tspc_r_0/z5 0.04fF
C1602 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_1/Q 0.05fF
C1603 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C1604 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/nor_1/B 0.06fF
C1605 divbuf_18/IN divbuf_18/a_492_n240# 0.13fF
C1606 divider_2/tspc_0/a_630_n680# divider_2/tspc_1/Q 0.01fF
C1607 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z4 0.36fF
C1608 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_0/D 0.09fF
C1609 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/nor_1/B 0.38fF
C1610 divbuf_24/a_492_n240# divbuf_24/OUT2 0.42fF
C1611 pd_1/tspc_r_1/Z3 pd_1/UP 0.03fF
C1612 divider_2/tspc_2/Z1 divider_2/tspc_2/Z3 0.06fF
C1613 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1614 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/pd_0/tspc_r_1/Z3 0.09fF
C1615 pll_full_0/pd_0/tspc_r_1/z5 pll_full_0/pd_0/UP 0.03fF
C1616 divider_0/tspc_0/Z3 divider_0/Out 0.05fF
C1617 divider_0/tspc_0/Z2 divider_0/nor_1/B 0.40fF
C1618 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z3 0.33fF
C1619 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/a0 0.13fF
C1620 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1621 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1622 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C1623 divider_0/and_0/OUT divider_0/and_0/Z1 0.04fF
C1624 divider_0/prescaler_0/tspc_2/Q divider_0/clk 0.05fF
C1625 divbuf_16/OUT3 divbuf_16/OUT2 1.37fF
C1626 divbuf_5/OUT4 divbuf_5/OUT5 20.26fF
C1627 pll_full_0/pd_0/DIV pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C1628 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C1629 divbuf_16/IN divbuf_16/OUT5 0.00fF
C1630 divider_1/prescaler_0/tspc_1/Q divider_1/clk 0.60fF
C1631 cp_0/a_1710_0# cp_0/a_10_n50# 0.04fF
C1632 pd_1/tspc_r_0/Z2 pd_1/DIV 0.19fF
C1633 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/nor_1/B 0.22fF
C1634 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C1635 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z3 0.16fF
C1636 divbuf_1/OUT5 divbuf_1/OUT 43.38fF
C1637 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C1638 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/v 1.30fF
C1639 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/nand_0/z1 0.07fF
C1640 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/D 0.05fF
C1641 ro_complete_1/a1 ro_complete_1/cbank_1/v 0.05fF
C1642 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z1 0.00fF
C1643 divider_1/mc2 divider_1/and_0/out1 0.06fF
C1644 divbuf_14/OUT4 divbuf_14/OUT3 5.16fF
C1645 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/IN 0.13fF
C1646 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z2 0.19fF
C1647 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_1/Q 0.21fF
C1648 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_2/D 0.16fF
C1649 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/D 0.03fF
C1650 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1651 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Z2 0.19fF
C1652 divbuf_11/OUT3 divbuf_11/OUT5 0.01fF
C1653 divbuf_11/OUT2 divbuf_11/OUT 0.06fF
C1654 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divbuf_0/IN 0.05fF
C1655 cp_0/a_1710_0# cp_0/down 0.32fF
C1656 pd_1/DOWN pd_1/tspc_r_1/Qbar 0.02fF
C1657 pd_1/R pd_1/and_pd_0/Out1 0.33fF
C1658 pd_0/tspc_r_1/z5 pd_0/UP 0.03fF
C1659 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.20fF
C1660 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.09fF
C1661 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/clk 0.11fF
C1662 divider_0/nor_0/Z1 divider_0/nor_0/B 0.06fF
C1663 divbuf_7/OUT ro_complete_0/cbank_2/v 0.05fF
C1664 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Q 0.05fF
C1665 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C1666 divider_1/mc2 divider_1/nor_0/B 0.06fF
C1667 divbuf_14/OUT2 divbuf_14/OUT3 1.37fF
C1668 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Q 0.05fF
C1669 divider_0/prescaler_0/m1_2700_2190# divider_0/clk 0.01fF
C1670 divbuf_16/OUT3 divbuf_16/OUT5 0.01fF
C1671 divbuf_20/a_492_n240# divbuf_20/OUT5 0.01fF
C1672 pd_0/tspc_r_0/Qbar1 pd_0/R 0.01fF
C1673 pd_0/DIV pd_0/tspc_r_0/Z4 0.02fF
C1674 pd_0/DOWN pd_0/tspc_r_0/Qbar 0.21fF
C1675 io_clamp_low[0] io_analog[4] 0.53fF
C1676 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z2 0.14fF
C1677 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_1/Q 0.01fF
C1678 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C1679 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/Out 0.05fF
C1680 pll_full_1/ro_complete_0/a2 pll_full_1/divider_0/clk 0.11fF
C1681 divbuf_18/OUT2 divbuf_18/a_492_n240# 0.42fF
C1682 pll_full_1/pd_0/tspc_r_1/z5 pll_full_1/pd_0/UP 0.03fF
C1683 divbuf_13/OUT2 divbuf_13/OUT5 0.02fF
C1684 divbuf_13/OUT3 divbuf_13/OUT4 5.16fF
C1685 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/and_0/B 0.31fF
C1686 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/prescaler_0/tspc_0/D 0.04fF
C1687 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/nand_1/z1 0.22fF
C1688 divider_2/and_0/OUT divider_2/and_0/B 0.01fF
C1689 ro_complete_0/cbank_1/switch_3/vin divbuf_6/OUT 0.14fF
C1690 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z4 0.01fF
C1691 ro_complete_1/a4 ro_complete_1/cbank_2/switch_1/vin 0.09fF
C1692 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/v 1.30fF
C1693 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/nor_1/B 0.22fF
C1694 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1695 pll_full_1/pd_0/REF pll_full_1/pd_0/R 0.61fF
C1696 divider_2/prescaler_0/tspc_0/Z3 divider_2/clk 0.64fF
C1697 divider_1/prescaler_0/tspc_2/Z4 divider_1/clk 0.12fF
C1698 divbuf_21/OUT4 divbuf_21/OUT5 20.26fF
C1699 divbuf_21/OUT3 divbuf_21/OUT 0.26fF
C1700 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/OUT4 20.26fF
C1701 pll_full_1/cp_0/a_1710_0# pll_full_1/pd_0/DOWN 0.04fF
C1702 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/tspc_r_0/z5 0.20fF
C1703 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/v 0.08fF
C1704 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1705 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/nor_0/B 0.51fF
C1706 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C1707 pll_full_1/ro_complete_0/cbank_1/switch_0/vin pll_full_1/divider_0/clk 1.58fF
C1708 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z4 0.00fF
C1709 pll_full_0/pd_0/DOWN pll_full_0/pd_0/REF 1.48fF
C1710 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Q 0.15fF
C1711 divider_0/prescaler_0/tspc_0/Z2 divider_0/and_0/OUT 0.06fF
C1712 divbuf_2/OUT divbuf_2/OUT4 1.11fF
C1713 divbuf_4/OUT ro_complete_0/cbank_2/switch_0/vin 0.12fF
C1714 divbuf_6/OUT divbuf_6/OUT4 1.11fF
C1715 divbuf_3/OUT2 divbuf_3/OUT3 1.37fF
C1716 ro_complete_1/a3 ro_complete_1/cbank_2/switch_2/vin 0.09fF
C1717 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C1718 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C1719 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/clk 0.11fF
C1720 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1721 divbuf_17/OUT2 divbuf_17/a_492_n240# 0.42fF
C1722 divbuf_19/OUT2 divbuf_19/a_492_n240# 0.42fF
C1723 divider_1/tspc_2/Z2 divider_1/tspc_2/Z4 0.36fF
C1724 filter_0/v divbuf_25/OUT5 43.38fF
C1725 pd_1/R pd_1/tspc_r_1/Z2 0.21fF
C1726 pd_1/DOWN pd_1/tspc_r_0/Z3 0.03fF
C1727 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1728 divbuf_23/OUT3 divbuf_23/OUT5 0.01fF
C1729 divbuf_23/OUT2 divbuf_23/OUT 0.06fF
C1730 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1731 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1732 divbuf_15/OUT2 divbuf_15/OUT3 1.37fF
C1733 pll_full_0/pd_0/R pll_full_0/pd_0/REF 0.61fF
C1734 divbuf_15/IN divbuf_15/a_492_n240# 0.13fF
C1735 divbuf_25/OUT3 divbuf_25/OUT5 0.01fF
C1736 divbuf_25/a_492_n240# divbuf_25/IN 0.13fF
C1737 divider_0/prescaler_0/Out divider_0/tspc_2/Z2 0.11fF
C1738 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/clk 0.01fF
C1739 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/a3 0.13fF
C1740 divbuf_3/OUT ro_complete_0/cbank_2/v 0.05fF
C1741 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z2 0.14fF
C1742 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_1/Q 0.01fF
C1743 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C1744 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/Out 0.05fF
C1745 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/v 1.30fF
C1746 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/UP 0.21fF
C1747 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/B 0.31fF
C1748 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C1749 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C1750 divider_2/Out divider_2/nor_1/B 0.22fF
C1751 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z2 0.01fF
C1752 divbuf_10/OUT4 divbuf_10/OUT 1.11fF
C1753 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1754 divider_1/prescaler_0/Out divider_1/nor_0/A 0.15fF
C1755 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Z4 0.65fF
C1756 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/clk 0.14fF
C1757 divider_1/nor_1/Z1 divider_1/and_0/B 0.78fF
C1758 divbuf_22/a_492_n240# divbuf_22/OUT5 0.01fF
C1759 pll_full_1/filter_0/a_4216_n5230# pll_full_1/divider_0/clk 1.58fF
C1760 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C1761 pd_1/DOWN pd_1/and_pd_0/Z1 0.07fF
C1762 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z2 0.25fF
C1763 divider_2/prescaler_0/tspc_0/D divider_2/prescaler_0/nand_1/z1 0.21fF
C1764 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/clk 0.11fF
C1765 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z4 0.12fF
C1766 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1767 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_2/Q 0.19fF
C1768 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/clk 0.01fF
C1769 divbuf_4/OUT divbuf_4/OUT3 0.26fF
C1770 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/v 1.30fF
C1771 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/z5 0.11fF
C1772 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/R 0.21fF
C1773 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_0/B 0.51fF
C1774 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C1775 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT5 0.01fF
C1776 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z4 0.00fF
C1777 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z3 0.05fF
C1778 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z4 0.08fF
C1779 pll_full_1/ro_complete_0/cbank_0/switch_5/vin pll_full_1/ro_complete_0/a0 0.09fF
C1780 divbuf_17/OUT2 divbuf_17/OUT5 0.02fF
C1781 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/R 0.01fF
C1782 pd_0/R pd_0/REF 0.61fF
C1783 divbuf_8/OUT4 divbuf_8/OUT5 20.26fF
C1784 divbuf_8/OUT3 divbuf_8/OUT 0.26fF
C1785 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1786 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C1787 divider_2/tspc_2/Z1 divider_2/tspc_2/Z4 0.00fF
C1788 divider_0/nor_0/B divider_0/tspc_2/Q 0.22fF
C1789 divider_0/tspc_0/a_630_n680# divider_0/nor_1/B 0.35fF
C1790 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z3 0.05fF
C1791 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z4 0.08fF
C1792 divbuf_3/OUT ro_complete_0/cbank_1/switch_2/vin 0.09fF
C1793 divider_0/tspc_2/a_630_n680# divider_0/nor_0/A 0.35fF
C1794 divider_0/prescaler_0/tspc_0/D divider_0/clk 0.29fF
C1795 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_4/vin 0.20fF
C1796 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1797 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1798 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C1799 divider_1/tspc_0/Z3 divider_1/Out 0.05fF
C1800 divider_1/tspc_0/Z2 divider_1/nor_1/B 0.40fF
C1801 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z3 0.33fF
C1802 divider_1/and_0/OUT divider_1/and_0/Z1 0.04fF
C1803 divider_1/prescaler_0/tspc_2/Q divider_1/clk 0.05fF
C1804 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/ro_complete_0/cbank_2/v 0.04fF
C1805 pd_1/tspc_r_0/Qbar1 pd_1/DOWN 0.11fF
C1806 pd_1/R pd_1/DIV 0.51fF
C1807 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z4 0.36fF
C1808 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1809 pll_full_1/ro_complete_0/cbank_1/switch_5/vin pll_full_1/divider_0/clk 1.46fF
C1810 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT3 0.26fF
C1811 divbuf_15/OUT2 divbuf_15/a_492_n240# 0.42fF
C1812 divider_0/tspc_1/a_630_n680# divider_0/nor_1/B 0.00fF
C1813 divider_0/prescaler_0/tspc_1/Z2 divider_0/and_0/OUT 0.06fF
C1814 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1815 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Q 0.38fF
C1816 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_0/D 0.11fF
C1817 divider_0/nor_0/Z1 divider_0/and_0/A 0.80fF
C1818 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_5/vin 0.20fF
C1819 divider_1/mc2 divider_1/and_0/A 0.16fF
C1820 divider_0/and_0/out1 divider_0/and_0/A 0.01fF
C1821 ro_complete_1/a5 ro_complete_1/cbank_2/v 0.08fF
C1822 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/clk 0.11fF
C1823 divbuf_10/a_492_n240# divbuf_10/IN 0.13fF
C1824 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/nand_0/z1 0.07fF
C1825 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/D 0.05fF
C1826 divbuf_11/OUT4 divbuf_11/OUT 1.11fF
C1827 divbuf_18/OUT2 divbuf_18/OUT 0.06fF
C1828 divbuf_17/OUT2 divbuf_17/OUT 0.06fF
C1829 divbuf_16/OUT5 divbuf_16/OUT4 20.26fF
C1830 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/a_630_n680# 0.05fF
C1831 divbuf_9/a_492_n240# divbuf_9/OUT5 0.01fF
C1832 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1833 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/clk 0.51fF
C1834 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z1 0.09fF
C1835 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z2 0.19fF
C1836 divider_0/tspc_0/Z2 divider_0/tspc_0/a_630_n680# 0.01fF
C1837 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1838 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C1839 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/clk 0.01fF
C1840 divider_0/nor_0/B divider_0/and_0/A 0.26fF
C1841 divbuf_1/OUT2 divbuf_1/OUT3 1.37fF
C1842 io_clamp_low[1] io_clamp_high[1] 0.53fF
C1843 divbuf_7/OUT divbuf_7/a_492_n240# 0.00fF
C1844 divbuf_4/a_492_n240# divbuf_4/OUT2 0.42fF
C1845 divbuf_20/OUT2 divbuf_20/OUT3 1.37fF
C1846 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_1/Q 0.13fF
C1847 divbuf_16/OUT3 divbuf_16/OUT4 5.16fF
C1848 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Q 0.05fF
C1849 divider_1/prescaler_0/m1_2700_2190# divider_1/clk 0.01fF
C1850 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/z5 0.11fF
C1851 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/nor_0/B 0.18fF
C1852 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Z4 0.12fF
C1853 divider_2/tspc_0/Z2 divider_2/nor_1/B 0.40fF
C1854 divbuf_13/OUT4 divbuf_13/OUT5 20.26fF
C1855 divbuf_13/OUT3 divbuf_13/OUT 0.26fF
C1856 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/prescaler_0/nand_1/z1 0.01fF
C1857 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/clk 0.11fF
C1858 ro_complete_0/cbank_0/switch_3/vin divbuf_6/OUT 0.14fF
C1859 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/v 1.30fF
C1860 ro_complete_0/cbank_0/switch_2/vin divbuf_3/OUT 0.09fF
C1861 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/UP 0.11fF
C1862 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1863 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/Out 0.05fF
C1864 divider_0/nor_1/B divider_0/and_0/B 0.29fF
C1865 ro_complete_1/a2 ro_complete_1/cbank_2/v 0.05fF
C1866 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C1867 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/a_630_n680# 0.05fF
C1868 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z4 0.01fF
C1869 divbuf_5/a_492_n240# divbuf_5/OUT5 0.01fF
C1870 divbuf_21/OUT5 divbuf_21/OUT 43.38fF
C1871 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1872 divider_2/prescaler_0/tspc_0/Z4 divider_2/clk 0.12fF
C1873 divbuf_12/a_492_n240# divbuf_12/OUT 0.00fF
C1874 pd_1/tspc_r_0/Qbar pd_1/tspc_r_0/Qbar1 0.01fF
C1875 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z1 0.09fF
C1876 pd_0/REF pd_0/tspc_r_1/Z2 0.19fF
C1877 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/nor_0/B 0.02fF
C1878 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z4 0.15fF
C1879 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C1880 pll_full_1/divider_0/tspc_2/Z3 pll_full_1/divider_0/tspc_2/Z4 0.65fF
C1881 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/v 1.30fF
C1882 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/cbank_0/v 1.30fF
C1883 divider_0/tspc_1/Z1 divider_0/tspc_1/Z2 1.07fF
C1884 divider_0/nor_0/B divider_0/tspc_1/Z3 0.38fF
C1885 divider_0/tspc_1/Q divider_0/nor_1/B 0.22fF
C1886 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1887 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/clk 0.51fF
C1888 divbuf_3/OUT2 divbuf_3/OUT5 0.02fF
C1889 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/a0 0.09fF
C1890 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT 43.38fF
C1891 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C1892 divider_1/nor_0/Z1 divider_1/and_0/B 0.18fF
C1893 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Q 0.15fF
C1894 divider_1/prescaler_0/tspc_0/Z2 divider_1/and_0/OUT 0.06fF
C1895 divbuf_6/IN divbuf_6/OUT5 0.00fF
C1896 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C1897 divbuf_11/a_492_n240# divbuf_11/IN 0.13fF
C1898 pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_0/ro_complete_0/cbank_2/v 1.45fF
C1899 divbuf_23/OUT4 divbuf_23/OUT 1.11fF
C1900 pd_0/tspc_r_1/Qbar1 pd_0/UP 0.11fF
C1901 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_2/Z3 0.05fF
C1902 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_0/Z2 0.16fF
C1903 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1904 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1905 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/clk 0.14fF
C1906 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/and_0/B 0.78fF
C1907 pll_full_1/cp_0/down pll_full_1/cp_0/upbar 0.02fF
C1908 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar1 0.30fF
C1909 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z4 0.12fF
C1910 divider_0/prescaler_0/tspc_2/Z2 divider_0/and_0/OUT 0.05fF
C1911 pll_full_1/pd_0/R pll_full_1/pd_0/and_pd_0/Z1 0.02fF
C1912 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C1913 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/clk 0.11fF
C1914 pll_full_1/divbuf_1/OUT2 pll_full_1/divbuf_1/OUT3 1.37fF
C1915 divbuf_19/IN divbuf_19/OUT5 0.00fF
C1916 divbuf_17/OUT4 divbuf_17/OUT3 5.16fF
C1917 divider_1/prescaler_0/Out divider_1/tspc_2/Z2 0.11fF
C1918 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/clk 0.01fF
C1919 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/a_492_n240# 0.01fF
C1920 pd_0/DIV pd_0/tspc_r_0/Z3 0.65fF
C1921 divbuf_22/OUT2 divbuf_22/OUT3 1.37fF
C1922 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1923 divider_2/mc2 divider_2/nor_1/B 0.15fF
C1924 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_1/Q 0.45fF
C1925 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/Qbar 0.01fF
C1926 divider_0/tspc_0/Z2 divider_0/tspc_1/Q 0.14fF
C1927 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1928 divbuf_4/OUT divbuf_4/OUT5 43.38fF
C1929 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/cbank_0/v 1.30fF
C1930 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/DOWN 0.03fF
C1931 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/nor_0/B 0.02fF
C1932 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z4 0.15fF
C1933 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C1934 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C1935 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1936 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/a3 0.09fF
C1937 divbuf_16/a_492_n240# divbuf_16/OUT2 0.42fF
C1938 divider_0/tspc_1/Z2 divider_0/nor_0/A 0.15fF
C1939 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_0/D 0.32fF
C1940 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/clk 0.01fF
C1941 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divider_0/tspc_2/Z4 0.65fF
C1942 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z4 0.12fF
C1943 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z2 1.07fF
C1944 divbuf_18/OUT2 divbuf_18/OUT3 1.37fF
C1945 divider_2/nor_1/Z1 divider_2/nor_0/B 0.18fF
C1946 divider_2/prescaler_0/Out divider_2/tspc_2/a_630_n680# 0.01fF
C1947 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_2/Q 0.19fF
C1948 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/clk 0.01fF
C1949 divbuf_21/a_492_n240# divbuf_21/OUT2 0.42fF
C1950 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1951 pd_0/DOWN pd_0/tspc_r_1/Qbar 0.02fF
C1952 pd_0/R pd_0/tspc_r_1/Qbar1 0.30fF
C1953 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/OUT2 0.02fF
C1954 divbuf_8/OUT5 divbuf_8/OUT 43.38fF
C1955 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/Z4 0.15fF
C1956 pll_full_1/divbuf_0/IN pll_full_1/divider_0/nor_1/B 0.27fF
C1957 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C1958 divider_2/nor_1/B divider_2/nor_0/B 0.47fF
C1959 divider_2/tspc_0/Z2 divider_2/tspc_0/Z1 1.07fF
C1960 pll_full_1/pd_0/tspc_r_1/Z4 pll_full_1/pd_0/tspc_r_1/Z2 0.14fF
C1961 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/A 0.80fF
C1962 pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_0/divider_0/clk 1.46fF
C1963 divbuf_24/a_492_n240# divbuf_24/OUT 0.00fF
C1964 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/B 0.01fF
C1965 divider_2/tspc_2/Z3 divider_2/tspc_2/Z4 0.65fF
C1966 divbuf_3/OUT ro_complete_0/cbank_2/switch_1/vin 0.13fF
C1967 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1968 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z3 0.33fF
C1969 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z4 0.12fF
C1970 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1971 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/Z3 0.05fF
C1972 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1973 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1974 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1975 divbuf_16/a_492_n240# divbuf_16/IN 0.13fF
C1976 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z2 0.01fF
C1977 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT2 0.06fF
C1978 divider_1/nor_0/B divider_1/tspc_2/Q 0.22fF
C1979 divider_1/tspc_0/a_630_n680# divider_1/nor_1/B 0.35fF
C1980 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z3 0.05fF
C1981 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z4 0.08fF
C1982 divider_1/tspc_2/a_630_n680# divider_1/nor_0/A 0.35fF
C1983 divider_1/prescaler_0/tspc_0/D divider_1/clk 0.29fF
C1984 divbuf_7/IN divbuf_7/OUT5 0.00fF
C1985 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/R 0.33fF
C1986 divbuf_23/a_492_n240# divbuf_23/IN 0.13fF
C1987 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.91fF
C1988 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1989 divbuf_15/OUT4 divbuf_15/OUT 1.11fF
C1990 divbuf_4/OUT ro_complete_0/cbank_2/v 0.05fF
C1991 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/v 1.30fF
C1992 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/tspc_r_1/z5 0.20fF
C1993 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT2 0.42fF
C1994 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z2 0.01fF
C1995 divider_0/tspc_2/Q divider_0/tspc_1/Z3 0.45fF
C1996 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1997 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1998 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Q 0.04fF
C1999 ro_complete_1/a0 ro_complete_1/cbank_2/switch_4/vin 0.13fF
C2000 ro_complete_1/cbank_0/v ro_complete_1/cbank_1/v 1.27fF
C2001 divider_2/tspc_0/Z4 divider_2/tspc_0/Z2 0.36fF
C2002 divider_2/Out divider_2/tspc_0/Z3 0.05fF
C2003 divbuf_16/a_492_n240# divbuf_16/OUT5 0.01fF
C2004 divider_1/tspc_1/a_630_n680# divider_1/nor_1/B 0.00fF
C2005 divider_1/prescaler_0/tspc_1/Z2 divider_1/and_0/OUT 0.06fF
C2006 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z3 0.33fF
C2007 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Q 0.38fF
C2008 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/D 0.11fF
C2009 divbuf_18/IN divbuf_18/OUT5 0.00fF
C2010 divider_2/tspc_1/a_630_n680# divider_2/nor_1/B 0.00fF
C2011 divider_1/and_0/out1 divider_1/and_0/A 0.01fF
C2012 divbuf_9/OUT2 divbuf_9/OUT3 1.37fF
C2013 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C2014 ro_complete_0/cbank_2/switch_2/vin ro_complete_0/cbank_2/v 1.30fF
C2015 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/tspc_r_0/Z1 0.71fF
C2016 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z4 0.15fF
C2017 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C2018 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/B 0.01fF
C2019 divider_1/tspc_0/Z2 divider_1/tspc_0/a_630_n680# 0.01fF
C2020 divbuf_20/OUT2 divbuf_20/OUT5 0.02fF
C2021 divbuf_20/OUT3 divbuf_20/OUT4 5.16fF
C2022 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_1/Q 0.21fF
C2023 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/clk 0.01fF
C2024 divider_1/nor_0/B divider_1/and_0/A 0.26fF
C2025 pd_0/DOWN pd_0/tspc_r_0/z5 0.03fF
C2026 pd_0/tspc_r_0/Z2 pd_0/R 0.21fF
C2027 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z2 0.01fF
C2028 divbuf_8/a_492_n240# divbuf_8/OUT2 0.42fF
C2029 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C2030 pd_1/tspc_r_1/Z4 pd_1/tspc_r_1/z5 0.04fF
C2031 divbuf_13/OUT5 divbuf_13/OUT 43.38fF
C2032 pll_full_1/divider_0/prescaler_0/tspc_0/D pll_full_1/divider_0/prescaler_0/nand_1/z1 0.21fF
C2033 ro_complete_0/cbank_1/switch_1/vin divbuf_3/OUT 0.14fF
C2034 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z1 0.08fF
C2035 divider_0/mc2 divider_0/nor_1/B 0.15fF
C2036 ro_complete_0/cbank_2/switch_3/vin divbuf_6/OUT 0.14fF
C2037 pll_full_0/pd_0/REF pll_full_0/divbuf_1/a_492_n240# 0.13fF
C2038 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/cbank_0/v 1.30fF
Xpd_0 vdda1 gnd pd_0/REF pd_0/DIV pd_0/UP pd_0/DOWN pd_0/R pd
Xpd_1 vdda1 gnd pd_1/REF pd_1/DIV pd_1/UP pd_1/DOWN pd_1/R pd
Xcp_0 cp_0/vbias vdda1 gnd cp_0/out cp_0/down cp_0/upbar cp
Xfilter_0 gnd filter_0/v filter
Xro_complete_0 divbuf_7/OUT divbuf_6/OUT divbuf_2/OUT divbuf_4/OUT divbuf_3/OUT divbuf_5/OUT
+ ro_complete
Xdivbuf_0 vdda1 divbuf_0/IN divbuf_0/OUT divbuf_0/OUT2 divbuf_0/OUT3 divbuf_0/OUT4
+ divbuf_0/OUT5 gnd divbuf
Xro_complete_1 ro_complete_1/a0 ro_complete_1/a1 ro_complete_1/a5 ro_complete_1/a4
+ ro_complete_1/a3 ro_complete_1/a2 ro_complete
Xdivbuf_1 vdda1 divbuf_1/IN divbuf_1/OUT divbuf_1/OUT2 divbuf_1/OUT3 divbuf_1/OUT4
+ divbuf_1/OUT5 gnd divbuf
Xdivbuf_2 vdda1 divbuf_2/IN divbuf_2/OUT divbuf_2/OUT2 divbuf_2/OUT3 divbuf_2/OUT4
+ divbuf_2/OUT5 gnd divbuf
Xdivbuf_3 vdda1 divbuf_3/IN divbuf_3/OUT divbuf_3/OUT2 divbuf_3/OUT3 divbuf_3/OUT4
+ divbuf_3/OUT5 gnd divbuf
Xdivbuf_4 vdda1 divbuf_4/IN divbuf_4/OUT divbuf_4/OUT2 divbuf_4/OUT3 divbuf_4/OUT4
+ divbuf_4/OUT5 gnd divbuf
Xdivbuf_5 vdda1 divbuf_5/IN divbuf_5/OUT divbuf_5/OUT2 divbuf_5/OUT3 divbuf_5/OUT4
+ divbuf_5/OUT5 gnd divbuf
Xdivbuf_6 vdda1 divbuf_6/IN divbuf_6/OUT divbuf_6/OUT2 divbuf_6/OUT3 divbuf_6/OUT4
+ divbuf_6/OUT5 gnd divbuf
Xdivbuf_10 vdda1 divbuf_10/IN divbuf_10/OUT divbuf_10/OUT2 divbuf_10/OUT3 divbuf_10/OUT4
+ divbuf_10/OUT5 gnd divbuf
Xdivbuf_20 vdda1 divbuf_20/IN divbuf_20/OUT divbuf_20/OUT2 divbuf_20/OUT3 divbuf_20/OUT4
+ divbuf_20/OUT5 gnd divbuf
Xdivbuf_21 vdda1 divbuf_21/IN divbuf_21/OUT divbuf_21/OUT2 divbuf_21/OUT3 divbuf_21/OUT4
+ divbuf_21/OUT5 gnd divbuf
Xdivbuf_7 vdda1 divbuf_7/IN divbuf_7/OUT divbuf_7/OUT2 divbuf_7/OUT3 divbuf_7/OUT4
+ divbuf_7/OUT5 gnd divbuf
Xdivbuf_11 vdda1 divbuf_11/IN divbuf_11/OUT divbuf_11/OUT2 divbuf_11/OUT3 divbuf_11/OUT4
+ divbuf_11/OUT5 gnd divbuf
Xdivbuf_22 vdda1 divbuf_22/IN divbuf_22/OUT divbuf_22/OUT2 divbuf_22/OUT3 divbuf_22/OUT4
+ divbuf_22/OUT5 gnd divbuf
Xdivbuf_8 vdda1 divbuf_8/IN divbuf_8/OUT divbuf_8/OUT2 divbuf_8/OUT3 divbuf_8/OUT4
+ divbuf_8/OUT5 gnd divbuf
Xdivbuf_12 vdda1 divbuf_12/IN divbuf_12/OUT divbuf_12/OUT2 divbuf_12/OUT3 divbuf_12/OUT4
+ divbuf_12/OUT5 gnd divbuf
Xdivbuf_23 vdda1 divbuf_23/IN divbuf_23/OUT divbuf_23/OUT2 divbuf_23/OUT3 divbuf_23/OUT4
+ divbuf_23/OUT5 gnd divbuf
Xdivbuf_9 vdda1 divbuf_9/IN divbuf_9/OUT divbuf_9/OUT2 divbuf_9/OUT3 divbuf_9/OUT4
+ divbuf_9/OUT5 gnd divbuf
Xdivbuf_13 vdda1 divbuf_13/IN divbuf_13/OUT divbuf_13/OUT2 divbuf_13/OUT3 divbuf_13/OUT4
+ divbuf_13/OUT5 gnd divbuf
Xdivbuf_24 vdda1 divbuf_24/IN divbuf_24/OUT divbuf_24/OUT2 divbuf_24/OUT3 divbuf_24/OUT4
+ divbuf_24/OUT5 gnd divbuf
Xdivider_0 gnd vdd divider_0/Out divider_0/clk divider_0/mc2 divider
Xdivbuf_14 vdda1 divbuf_14/IN divbuf_14/OUT divbuf_14/OUT2 divbuf_14/OUT3 divbuf_14/OUT4
+ divbuf_14/OUT5 gnd divbuf
Xdivbuf_25 vdda1 divbuf_25/IN filter_0/v divbuf_25/OUT2 divbuf_25/OUT3 divbuf_25/OUT4
+ divbuf_25/OUT5 gnd divbuf
Xdivbuf_15 vdda1 divbuf_15/IN divbuf_15/OUT divbuf_15/OUT2 divbuf_15/OUT3 divbuf_15/OUT4
+ divbuf_15/OUT5 gnd divbuf
Xdivider_1 gnd vdda1 divider_1/Out divider_1/clk divider_1/mc2 divider
Xdivbuf_16 vdda1 divbuf_16/IN divbuf_16/OUT divbuf_16/OUT2 divbuf_16/OUT3 divbuf_16/OUT4
+ divbuf_16/OUT5 gnd divbuf
Xdivider_2 gnd vdda1 divider_2/Out divider_2/clk divider_2/mc2 divider
Xdivbuf_17 vdda1 divbuf_17/IN divbuf_17/OUT divbuf_17/OUT2 divbuf_17/OUT3 divbuf_17/OUT4
+ divbuf_17/OUT5 gnd divbuf
Xdivbuf_18 vdda1 divbuf_18/IN divbuf_18/OUT divbuf_18/OUT2 divbuf_18/OUT3 divbuf_18/OUT4
+ divbuf_18/OUT5 gnd divbuf
Xdivbuf_19 vdda1 divbuf_19/IN divbuf_19/OUT divbuf_19/OUT2 divbuf_19/OUT3 divbuf_19/OUT4
+ divbuf_19/OUT5 gnd divbuf
Xpll_full_0 vdda1 pll_full
Xpll_full_1 vdda1 pll_full
C2039 io_analog[4] gnd 43.96fF
C2040 io_analog[5] gnd 44.13fF
C2041 io_analog[6] gnd 43.46fF
C2042 io_in_3v3[0] gnd 0.61fF
C2043 io_oeb[26] gnd 0.61fF
C2044 io_in[0] gnd 0.61fF
C2045 io_out[26] gnd 0.61fF
C2046 io_out[0] gnd 0.61fF
C2047 io_in[26] gnd 0.61fF
C2048 io_oeb[0] gnd 0.61fF
C2049 io_in_3v3[26] gnd 0.61fF
C2050 io_in_3v3[1] gnd 0.61fF
C2051 io_oeb[25] gnd 0.61fF
C2052 io_in[1] gnd 0.61fF
C2053 io_out[25] gnd 0.61fF
C2054 io_out[1] gnd 0.61fF
C2055 io_in[25] gnd 0.61fF
C2056 io_oeb[1] gnd 0.61fF
C2057 io_in_3v3[25] gnd 0.61fF
C2058 io_in_3v3[2] gnd 0.61fF
C2059 io_oeb[24] gnd 0.61fF
C2060 io_in[2] gnd 0.61fF
C2061 io_out[24] gnd 0.61fF
C2062 io_out[2] gnd 0.61fF
C2063 io_in[24] gnd 0.61fF
C2064 io_oeb[2] gnd 0.61fF
C2065 io_in_3v3[24] gnd 0.61fF
C2066 io_in_3v3[3] gnd 0.61fF
C2067 io_in[3] gnd 0.61fF
C2068 gpio_noesd[17] gnd 2.32fF
C2069 gpio_analog[17] gnd 2.30fF
C2070 io_out[3] gnd 0.61fF
C2071 io_oeb[3] gnd 0.61fF
C2072 io_in_3v3[4] gnd 0.61fF
C2073 io_in[4] gnd 0.61fF
C2074 io_out[4] gnd 0.61fF
C2075 io_oeb[4] gnd 0.61fF
C2076 io_oeb[23] gnd 0.61fF
C2077 io_out[23] gnd 0.61fF
C2078 io_in[23] gnd 0.61fF
C2079 io_in_3v3[23] gnd 0.61fF
C2080 gpio_noesd[16] gnd 2.30fF
C2081 gpio_analog[16] gnd 2.30fF
C2082 io_in_3v3[5] gnd 0.61fF
C2083 io_in[5] gnd 0.61fF
C2084 io_out[5] gnd 0.61fF
C2085 io_oeb[5] gnd 0.61fF
C2086 io_oeb[22] gnd 0.61fF
C2087 io_out[22] gnd 0.61fF
C2088 io_in[22] gnd 0.61fF
C2089 io_in_3v3[22] gnd 0.61fF
C2090 gpio_noesd[15] gnd 2.31fF
C2091 gpio_analog[15] gnd 2.30fF
C2092 io_in_3v3[6] gnd 0.61fF
C2093 io_in[6] gnd 0.61fF
C2094 io_out[6] gnd 0.61fF
C2095 io_oeb[6] gnd 0.61fF
C2096 io_oeb[21] gnd 0.61fF
C2097 io_out[21] gnd 0.61fF
C2098 io_in[21] gnd 0.61fF
C2099 io_in_3v3[21] gnd 0.61fF
C2100 gpio_noesd[14] gnd 2.30fF
C2101 gpio_analog[14] gnd 2.29fF
C2102 vssa1 gnd 142.71fF
C2103 vssd2 gnd 38.54fF
C2104 vssd1 gnd 13.04fF
C2105 vdda2 gnd 38.30fF
C2106 io_oeb[20] gnd 0.61fF
C2107 io_out[20] gnd 0.61fF
C2108 io_in[20] gnd 0.61fF
C2109 io_in_3v3[20] gnd 0.61fF
C2110 gpio_noesd[13] gnd 2.31fF
C2111 gpio_analog[13] gnd 2.30fF
C2112 gpio_analog[0] gnd 0.61fF
C2113 gpio_noesd[0] gnd 0.61fF
C2114 io_in_3v3[7] gnd 0.61fF
C2115 io_in[7] gnd 0.61fF
C2116 io_out[7] gnd 0.61fF
C2117 io_oeb[7] gnd 0.61fF
C2118 io_oeb[19] gnd 0.61fF
C2119 io_out[19] gnd 0.61fF
C2120 io_in[19] gnd 0.61fF
C2121 io_in_3v3[19] gnd 0.61fF
C2122 gpio_noesd[12] gnd 2.32fF
C2123 gpio_analog[12] gnd 2.30fF
C2124 gpio_analog[1] gnd 0.61fF
C2125 gpio_noesd[1] gnd 0.61fF
C2126 io_in_3v3[8] gnd 0.61fF
C2127 io_in[8] gnd 0.61fF
C2128 io_out[8] gnd 0.61fF
C2129 io_oeb[8] gnd 0.61fF
C2130 io_oeb[18] gnd 0.61fF
C2131 io_out[18] gnd 0.61fF
C2132 io_in[18] gnd 0.61fF
C2133 io_in_3v3[18] gnd 0.61fF
C2134 gpio_noesd[11] gnd 2.30fF
C2135 gpio_analog[11] gnd 2.29fF
C2136 gpio_analog[2] gnd 0.61fF
C2137 gpio_noesd[2] gnd 0.61fF
C2138 io_in_3v3[9] gnd 0.61fF
C2139 io_in[9] gnd 0.61fF
C2140 io_out[9] gnd 0.61fF
C2141 io_oeb[9] gnd 0.61fF
C2142 io_oeb[17] gnd 0.61fF
C2143 io_out[17] gnd 0.61fF
C2144 io_in[17] gnd 0.61fF
C2145 io_in_3v3[17] gnd 0.61fF
C2146 gpio_noesd[10] gnd 2.31fF
C2147 gpio_analog[10] gnd 2.29fF
C2148 gpio_analog[3] gnd 0.61fF
C2149 gpio_noesd[3] gnd 0.61fF
C2150 io_in_3v3[10] gnd 0.61fF
C2151 io_in[10] gnd 0.61fF
C2152 io_out[10] gnd 0.61fF
C2153 io_oeb[10] gnd 0.61fF
C2154 io_oeb[16] gnd 0.61fF
C2155 io_out[16] gnd 0.61fF
C2156 io_in[16] gnd 0.61fF
C2157 io_in_3v3[16] gnd 0.61fF
C2158 gpio_noesd[9] gnd 2.28fF
C2159 gpio_analog[9] gnd 2.28fF
C2160 gpio_analog[4] gnd 0.61fF
C2161 gpio_noesd[4] gnd 0.61fF
C2162 io_in_3v3[11] gnd 0.61fF
C2163 io_in[11] gnd 0.61fF
C2164 io_out[11] gnd 0.61fF
C2165 io_oeb[11] gnd 0.61fF
C2166 io_oeb[15] gnd 0.61fF
C2167 io_out[15] gnd 0.61fF
C2168 io_in[15] gnd 0.61fF
C2169 io_in_3v3[15] gnd 0.61fF
C2170 gpio_noesd[8] gnd 2.28fF
C2171 gpio_analog[8] gnd 2.26fF
C2172 gpio_analog[5] gnd 0.61fF
C2173 gpio_noesd[5] gnd 0.61fF
C2174 io_in_3v3[12] gnd 0.61fF
C2175 io_in[12] gnd 0.61fF
C2176 io_out[12] gnd 0.61fF
C2177 io_oeb[12] gnd 0.61fF
C2178 io_oeb[14] gnd 0.61fF
C2179 io_out[14] gnd 0.61fF
C2180 io_in[14] gnd 0.61fF
C2181 io_in_3v3[14] gnd 0.61fF
C2182 gpio_noesd[7] gnd 2.30fF
C2183 gpio_analog[7] gnd 2.28fF
C2184 vssa2 gnd 38.35fF
C2185 gpio_analog[6] gnd 5.71fF
C2186 gpio_noesd[6] gnd 5.70fF
C2187 io_in_3v3[13] gnd 0.61fF
C2188 io_in[13] gnd 0.61fF
C2189 io_out[13] gnd 0.61fF
C2190 io_oeb[13] gnd 0.61fF
C2191 vccd1 gnd 39.84fF
C2192 vccd2 gnd 38.46fF
C2193 io_analog[0] gnd 19.99fF
C2194 io_analog[10] gnd 19.36fF
C2195 io_analog[1] gnd 13.17fF
C2196 io_analog[2] gnd 12.57fF
C2197 io_analog[3] gnd 12.83fF
C2198 io_clamp_high[0] gnd 3.58fF
C2199 io_clamp_low[0] gnd 3.58fF
C2200 io_clamp_high[1] gnd 3.58fF
C2201 io_clamp_low[1] gnd 3.58fF
C2202 io_clamp_high[2] gnd 3.58fF
C2203 io_clamp_low[2] gnd 3.58fF
C2204 io_analog[7] gnd 12.74fF
C2205 io_analog[8] gnd 13.08fF
C2206 io_analog[9] gnd 13.08fF
C2207 user_irq[2] gnd 0.63fF
C2208 user_irq[1] gnd 0.63fF
C2209 user_irq[0] gnd 0.63fF
C2210 user_clock2 gnd 0.63fF
C2211 la_oenb[127] gnd 0.63fF
C2212 la_data_out[127] gnd 0.63fF
C2213 la_data_in[127] gnd 0.63fF
C2214 la_oenb[126] gnd 0.63fF
C2215 la_data_out[126] gnd 0.63fF
C2216 la_data_in[126] gnd 0.63fF
C2217 la_oenb[125] gnd 0.63fF
C2218 la_data_out[125] gnd 0.63fF
C2219 la_data_in[125] gnd 0.63fF
C2220 la_oenb[124] gnd 0.63fF
C2221 la_data_out[124] gnd 0.63fF
C2222 la_data_in[124] gnd 0.63fF
C2223 la_oenb[123] gnd 0.63fF
C2224 la_data_out[123] gnd 0.63fF
C2225 la_data_in[123] gnd 0.63fF
C2226 la_oenb[122] gnd 0.63fF
C2227 la_data_out[122] gnd 0.63fF
C2228 la_data_in[122] gnd 0.63fF
C2229 la_oenb[121] gnd 0.63fF
C2230 la_data_out[121] gnd 0.63fF
C2231 la_data_in[121] gnd 0.63fF
C2232 la_oenb[120] gnd 0.63fF
C2233 la_data_out[120] gnd 0.63fF
C2234 la_data_in[120] gnd 0.63fF
C2235 la_oenb[119] gnd 0.63fF
C2236 la_data_out[119] gnd 0.63fF
C2237 la_data_in[119] gnd 0.63fF
C2238 la_oenb[118] gnd 0.63fF
C2239 la_data_out[118] gnd 0.63fF
C2240 la_data_in[118] gnd 0.63fF
C2241 la_oenb[117] gnd 0.63fF
C2242 la_data_out[117] gnd 0.63fF
C2243 la_data_in[117] gnd 0.63fF
C2244 la_oenb[116] gnd 0.63fF
C2245 la_data_out[116] gnd 0.63fF
C2246 la_data_in[116] gnd 0.63fF
C2247 la_oenb[115] gnd 0.63fF
C2248 la_data_out[115] gnd 0.63fF
C2249 la_data_in[115] gnd 0.63fF
C2250 la_oenb[114] gnd 0.63fF
C2251 la_data_out[114] gnd 0.63fF
C2252 la_data_in[114] gnd 0.63fF
C2253 la_oenb[113] gnd 0.63fF
C2254 la_data_out[113] gnd 0.63fF
C2255 la_data_in[113] gnd 0.63fF
C2256 la_oenb[112] gnd 0.63fF
C2257 la_data_out[112] gnd 0.63fF
C2258 la_data_in[112] gnd 0.63fF
C2259 la_oenb[111] gnd 0.63fF
C2260 la_data_out[111] gnd 0.63fF
C2261 la_data_in[111] gnd 0.63fF
C2262 la_oenb[110] gnd 0.63fF
C2263 la_data_out[110] gnd 0.63fF
C2264 la_data_in[110] gnd 0.63fF
C2265 la_oenb[109] gnd 0.63fF
C2266 la_data_out[109] gnd 0.63fF
C2267 la_data_in[109] gnd 0.63fF
C2268 la_oenb[108] gnd 0.63fF
C2269 la_data_out[108] gnd 0.63fF
C2270 la_data_in[108] gnd 0.63fF
C2271 la_oenb[107] gnd 0.63fF
C2272 la_data_out[107] gnd 0.63fF
C2273 la_data_in[107] gnd 0.63fF
C2274 la_oenb[106] gnd 0.63fF
C2275 la_data_out[106] gnd 0.63fF
C2276 la_data_in[106] gnd 0.63fF
C2277 la_oenb[105] gnd 0.63fF
C2278 la_data_out[105] gnd 0.63fF
C2279 la_data_in[105] gnd 0.63fF
C2280 la_oenb[104] gnd 0.63fF
C2281 la_data_out[104] gnd 0.63fF
C2282 la_data_in[104] gnd 0.63fF
C2283 la_oenb[103] gnd 0.63fF
C2284 la_data_out[103] gnd 0.63fF
C2285 la_data_in[103] gnd 0.63fF
C2286 la_oenb[102] gnd 0.63fF
C2287 la_data_out[102] gnd 0.63fF
C2288 la_data_in[102] gnd 0.63fF
C2289 la_oenb[101] gnd 0.63fF
C2290 la_data_out[101] gnd 0.63fF
C2291 la_data_in[101] gnd 0.63fF
C2292 la_oenb[100] gnd 0.63fF
C2293 la_data_out[100] gnd 0.63fF
C2294 la_data_in[100] gnd 0.63fF
C2295 la_oenb[99] gnd 0.63fF
C2296 la_data_out[99] gnd 0.63fF
C2297 la_data_in[99] gnd 0.63fF
C2298 la_oenb[98] gnd 0.63fF
C2299 la_data_out[98] gnd 0.63fF
C2300 la_data_in[98] gnd 0.63fF
C2301 la_oenb[97] gnd 0.63fF
C2302 la_data_out[97] gnd 0.63fF
C2303 la_data_in[97] gnd 0.63fF
C2304 la_oenb[96] gnd 0.63fF
C2305 la_data_out[96] gnd 0.63fF
C2306 la_data_in[96] gnd 0.63fF
C2307 la_oenb[95] gnd 0.63fF
C2308 la_data_out[95] gnd 0.63fF
C2309 la_data_in[95] gnd 0.63fF
C2310 la_oenb[94] gnd 0.63fF
C2311 la_data_out[94] gnd 0.63fF
C2312 la_data_in[94] gnd 0.63fF
C2313 la_oenb[93] gnd 0.63fF
C2314 la_data_out[93] gnd 0.63fF
C2315 la_data_in[93] gnd 0.63fF
C2316 la_oenb[92] gnd 0.63fF
C2317 la_data_out[92] gnd 0.63fF
C2318 la_data_in[92] gnd 0.63fF
C2319 la_oenb[91] gnd 0.63fF
C2320 la_data_out[91] gnd 0.63fF
C2321 la_data_in[91] gnd 0.63fF
C2322 la_oenb[90] gnd 0.63fF
C2323 la_data_out[90] gnd 0.63fF
C2324 la_data_in[90] gnd 0.63fF
C2325 la_oenb[89] gnd 0.63fF
C2326 la_data_out[89] gnd 0.63fF
C2327 la_data_in[89] gnd 0.63fF
C2328 la_oenb[88] gnd 0.63fF
C2329 la_data_out[88] gnd 0.63fF
C2330 la_data_in[88] gnd 0.63fF
C2331 la_oenb[87] gnd 0.63fF
C2332 la_data_out[87] gnd 0.63fF
C2333 la_data_in[87] gnd 0.63fF
C2334 la_oenb[86] gnd 0.63fF
C2335 la_data_out[86] gnd 0.63fF
C2336 la_data_in[86] gnd 0.63fF
C2337 la_oenb[85] gnd 0.63fF
C2338 la_data_out[85] gnd 0.63fF
C2339 la_data_in[85] gnd 0.63fF
C2340 la_oenb[84] gnd 0.63fF
C2341 la_data_out[84] gnd 0.63fF
C2342 la_data_in[84] gnd 0.63fF
C2343 la_oenb[83] gnd 0.63fF
C2344 la_data_out[83] gnd 0.63fF
C2345 la_data_in[83] gnd 0.63fF
C2346 la_oenb[82] gnd 0.63fF
C2347 la_data_out[82] gnd 0.63fF
C2348 la_data_in[82] gnd 0.63fF
C2349 la_oenb[81] gnd 0.63fF
C2350 la_data_out[81] gnd 0.63fF
C2351 la_data_in[81] gnd 0.63fF
C2352 la_oenb[80] gnd 0.63fF
C2353 la_data_out[80] gnd 0.63fF
C2354 la_data_in[80] gnd 0.63fF
C2355 la_oenb[79] gnd 0.63fF
C2356 la_data_out[79] gnd 0.63fF
C2357 la_data_in[79] gnd 0.63fF
C2358 la_oenb[78] gnd 0.63fF
C2359 la_data_out[78] gnd 0.63fF
C2360 la_data_in[78] gnd 0.63fF
C2361 la_oenb[77] gnd 0.63fF
C2362 la_data_out[77] gnd 0.63fF
C2363 la_data_in[77] gnd 0.63fF
C2364 la_oenb[76] gnd 0.63fF
C2365 la_data_out[76] gnd 0.63fF
C2366 la_data_in[76] gnd 0.63fF
C2367 la_oenb[75] gnd 0.63fF
C2368 la_data_out[75] gnd 0.63fF
C2369 la_data_in[75] gnd 0.63fF
C2370 la_oenb[74] gnd 0.63fF
C2371 la_data_out[74] gnd 0.63fF
C2372 la_data_in[74] gnd 0.63fF
C2373 la_oenb[73] gnd 0.63fF
C2374 la_data_out[73] gnd 0.63fF
C2375 la_data_in[73] gnd 0.63fF
C2376 la_oenb[72] gnd 0.63fF
C2377 la_data_out[72] gnd 0.63fF
C2378 la_data_in[72] gnd 0.63fF
C2379 la_oenb[71] gnd 0.63fF
C2380 la_data_out[71] gnd 0.63fF
C2381 la_data_in[71] gnd 0.63fF
C2382 la_oenb[70] gnd 0.63fF
C2383 la_data_out[70] gnd 0.63fF
C2384 la_data_in[70] gnd 0.63fF
C2385 la_oenb[69] gnd 0.63fF
C2386 la_data_out[69] gnd 0.63fF
C2387 la_data_in[69] gnd 0.63fF
C2388 la_oenb[68] gnd 0.63fF
C2389 la_data_out[68] gnd 0.63fF
C2390 la_data_in[68] gnd 0.63fF
C2391 la_oenb[67] gnd 0.63fF
C2392 la_data_out[67] gnd 0.63fF
C2393 la_data_in[67] gnd 0.63fF
C2394 la_oenb[66] gnd 0.63fF
C2395 la_data_out[66] gnd 0.63fF
C2396 la_data_in[66] gnd 0.63fF
C2397 la_oenb[65] gnd 0.63fF
C2398 la_data_out[65] gnd 0.63fF
C2399 la_data_in[65] gnd 0.63fF
C2400 la_oenb[64] gnd 0.63fF
C2401 la_data_out[64] gnd 0.63fF
C2402 la_data_in[64] gnd 0.63fF
C2403 la_oenb[63] gnd 0.63fF
C2404 la_data_out[63] gnd 0.63fF
C2405 la_data_in[63] gnd 0.63fF
C2406 la_oenb[62] gnd 0.63fF
C2407 la_data_out[62] gnd 0.63fF
C2408 la_data_in[62] gnd 0.63fF
C2409 la_oenb[61] gnd 0.63fF
C2410 la_data_out[61] gnd 0.63fF
C2411 la_data_in[61] gnd 0.63fF
C2412 la_oenb[60] gnd 0.63fF
C2413 la_data_out[60] gnd 0.63fF
C2414 la_data_in[60] gnd 0.63fF
C2415 la_oenb[59] gnd 0.63fF
C2416 la_data_out[59] gnd 0.63fF
C2417 la_data_in[59] gnd 0.63fF
C2418 la_oenb[58] gnd 0.63fF
C2419 la_data_out[58] gnd 0.63fF
C2420 la_data_in[58] gnd 0.63fF
C2421 la_oenb[57] gnd 0.63fF
C2422 la_data_out[57] gnd 0.63fF
C2423 la_data_in[57] gnd 0.63fF
C2424 la_oenb[56] gnd 0.63fF
C2425 la_data_out[56] gnd 0.63fF
C2426 la_data_in[56] gnd 0.63fF
C2427 la_oenb[55] gnd 0.63fF
C2428 la_data_out[55] gnd 0.63fF
C2429 la_data_in[55] gnd 0.63fF
C2430 la_oenb[54] gnd 0.63fF
C2431 la_data_out[54] gnd 0.63fF
C2432 la_data_in[54] gnd 0.63fF
C2433 la_oenb[53] gnd 0.63fF
C2434 la_data_out[53] gnd 0.63fF
C2435 la_data_in[53] gnd 0.63fF
C2436 la_oenb[52] gnd 0.63fF
C2437 la_data_out[52] gnd 0.63fF
C2438 la_data_in[52] gnd 0.63fF
C2439 la_oenb[51] gnd 0.63fF
C2440 la_data_out[51] gnd 0.63fF
C2441 la_data_in[51] gnd 0.63fF
C2442 la_oenb[50] gnd 0.63fF
C2443 la_data_out[50] gnd 0.63fF
C2444 la_data_in[50] gnd 0.63fF
C2445 la_oenb[49] gnd 0.63fF
C2446 la_data_out[49] gnd 0.63fF
C2447 la_data_in[49] gnd 0.63fF
C2448 la_oenb[48] gnd 0.63fF
C2449 la_data_out[48] gnd 0.63fF
C2450 la_data_in[48] gnd 0.63fF
C2451 la_oenb[47] gnd 0.63fF
C2452 la_data_out[47] gnd 0.63fF
C2453 la_data_in[47] gnd 0.63fF
C2454 la_oenb[46] gnd 0.63fF
C2455 la_data_out[46] gnd 0.63fF
C2456 la_data_in[46] gnd 0.63fF
C2457 la_oenb[45] gnd 0.63fF
C2458 la_data_out[45] gnd 0.63fF
C2459 la_data_in[45] gnd 0.63fF
C2460 la_oenb[44] gnd 0.63fF
C2461 la_data_out[44] gnd 0.63fF
C2462 la_data_in[44] gnd 0.63fF
C2463 la_oenb[43] gnd 0.63fF
C2464 la_data_out[43] gnd 0.63fF
C2465 la_data_in[43] gnd 0.63fF
C2466 la_oenb[42] gnd 0.63fF
C2467 la_data_out[42] gnd 0.63fF
C2468 la_data_in[42] gnd 0.63fF
C2469 la_oenb[41] gnd 0.63fF
C2470 la_data_out[41] gnd 0.63fF
C2471 la_data_in[41] gnd 0.63fF
C2472 la_oenb[40] gnd 0.63fF
C2473 la_data_out[40] gnd 0.63fF
C2474 la_data_in[40] gnd 0.63fF
C2475 la_oenb[39] gnd 0.63fF
C2476 la_data_out[39] gnd 0.63fF
C2477 la_data_in[39] gnd 0.63fF
C2478 la_oenb[38] gnd 0.63fF
C2479 la_data_out[38] gnd 0.63fF
C2480 la_data_in[38] gnd 0.63fF
C2481 la_oenb[37] gnd 0.63fF
C2482 la_data_out[37] gnd 0.63fF
C2483 la_data_in[37] gnd 0.63fF
C2484 la_oenb[36] gnd 0.63fF
C2485 la_data_out[36] gnd 0.63fF
C2486 la_data_in[36] gnd 0.63fF
C2487 la_oenb[35] gnd 0.63fF
C2488 la_data_out[35] gnd 0.63fF
C2489 la_data_in[35] gnd 0.63fF
C2490 la_oenb[34] gnd 0.63fF
C2491 la_data_out[34] gnd 0.63fF
C2492 la_data_in[34] gnd 0.63fF
C2493 la_oenb[33] gnd 0.63fF
C2494 la_data_out[33] gnd 0.63fF
C2495 la_data_in[33] gnd 0.63fF
C2496 la_oenb[32] gnd 0.63fF
C2497 la_data_out[32] gnd 0.63fF
C2498 la_data_in[32] gnd 0.63fF
C2499 la_oenb[31] gnd 0.63fF
C2500 la_data_out[31] gnd 0.63fF
C2501 la_data_in[31] gnd 0.63fF
C2502 la_oenb[30] gnd 0.63fF
C2503 la_data_out[30] gnd 0.63fF
C2504 la_data_in[30] gnd 0.63fF
C2505 la_oenb[29] gnd 0.63fF
C2506 la_data_out[29] gnd 0.63fF
C2507 la_data_in[29] gnd 0.63fF
C2508 la_oenb[28] gnd 0.63fF
C2509 la_data_out[28] gnd 0.63fF
C2510 la_data_in[28] gnd 0.63fF
C2511 la_oenb[27] gnd 0.63fF
C2512 la_data_out[27] gnd 0.63fF
C2513 la_data_in[27] gnd 0.63fF
C2514 la_oenb[26] gnd 0.63fF
C2515 la_data_out[26] gnd 0.63fF
C2516 la_data_in[26] gnd 0.63fF
C2517 la_oenb[25] gnd 0.63fF
C2518 la_data_out[25] gnd 0.63fF
C2519 la_data_in[25] gnd 0.63fF
C2520 la_oenb[24] gnd 0.63fF
C2521 la_data_out[24] gnd 0.63fF
C2522 la_data_in[24] gnd 0.63fF
C2523 la_oenb[23] gnd 0.63fF
C2524 la_data_out[23] gnd 0.63fF
C2525 la_data_in[23] gnd 0.63fF
C2526 la_oenb[22] gnd 0.63fF
C2527 la_data_out[22] gnd 0.63fF
C2528 la_data_in[22] gnd 0.63fF
C2529 la_oenb[21] gnd 0.63fF
C2530 la_data_out[21] gnd 0.63fF
C2531 la_data_in[21] gnd 0.63fF
C2532 la_oenb[20] gnd 0.63fF
C2533 la_data_out[20] gnd 0.63fF
C2534 la_data_in[20] gnd 0.63fF
C2535 la_oenb[19] gnd 0.63fF
C2536 la_data_out[19] gnd 0.63fF
C2537 la_data_in[19] gnd 0.63fF
C2538 la_oenb[18] gnd 0.63fF
C2539 la_data_out[18] gnd 0.63fF
C2540 la_data_in[18] gnd 0.63fF
C2541 la_oenb[17] gnd 0.63fF
C2542 la_data_out[17] gnd 0.63fF
C2543 la_data_in[17] gnd 0.63fF
C2544 la_oenb[16] gnd 0.63fF
C2545 la_data_out[16] gnd 0.63fF
C2546 la_data_in[16] gnd 0.63fF
C2547 la_oenb[15] gnd 0.63fF
C2548 la_data_out[15] gnd 0.63fF
C2549 la_data_in[15] gnd 0.63fF
C2550 la_oenb[14] gnd 0.63fF
C2551 la_data_out[14] gnd 0.63fF
C2552 la_data_in[14] gnd 0.63fF
C2553 la_oenb[13] gnd 0.63fF
C2554 la_data_out[13] gnd 0.63fF
C2555 la_data_in[13] gnd 0.63fF
C2556 la_oenb[12] gnd 0.63fF
C2557 la_data_out[12] gnd 0.63fF
C2558 la_data_in[12] gnd 0.63fF
C2559 la_oenb[11] gnd 0.63fF
C2560 la_data_out[11] gnd 0.63fF
C2561 la_data_in[11] gnd 0.63fF
C2562 la_oenb[10] gnd 0.63fF
C2563 la_data_out[10] gnd 0.63fF
C2564 la_data_in[10] gnd 0.63fF
C2565 la_oenb[9] gnd 0.63fF
C2566 la_data_out[9] gnd 0.63fF
C2567 la_data_in[9] gnd 0.63fF
C2568 la_oenb[8] gnd 0.63fF
C2569 la_data_out[8] gnd 0.63fF
C2570 la_data_in[8] gnd 0.63fF
C2571 la_oenb[7] gnd 0.63fF
C2572 la_data_out[7] gnd 0.63fF
C2573 la_data_in[7] gnd 0.63fF
C2574 la_oenb[6] gnd 0.63fF
C2575 la_data_out[6] gnd 0.63fF
C2576 la_data_in[6] gnd 0.63fF
C2577 la_oenb[5] gnd 0.63fF
C2578 la_data_out[5] gnd 0.63fF
C2579 la_data_in[5] gnd 0.63fF
C2580 la_oenb[4] gnd 0.63fF
C2581 la_data_out[4] gnd 0.63fF
C2582 la_data_in[4] gnd 0.63fF
C2583 la_oenb[3] gnd 0.63fF
C2584 la_data_out[3] gnd 0.63fF
C2585 la_data_in[3] gnd 0.63fF
C2586 la_oenb[2] gnd 0.63fF
C2587 la_data_out[2] gnd 0.63fF
C2588 la_data_in[2] gnd 0.63fF
C2589 la_oenb[1] gnd 0.63fF
C2590 la_data_out[1] gnd 0.63fF
C2591 la_data_in[1] gnd 0.63fF
C2592 la_oenb[0] gnd 0.63fF
C2593 la_data_out[0] gnd 0.63fF
C2594 la_data_in[0] gnd 0.63fF
C2595 wbs_dat_o[31] gnd 0.63fF
C2596 wbs_dat_i[31] gnd 0.63fF
C2597 wbs_adr_i[31] gnd 0.63fF
C2598 wbs_dat_o[30] gnd 0.63fF
C2599 wbs_dat_i[30] gnd 0.63fF
C2600 wbs_adr_i[30] gnd 0.63fF
C2601 wbs_dat_o[29] gnd 0.63fF
C2602 wbs_dat_i[29] gnd 0.63fF
C2603 wbs_adr_i[29] gnd 0.63fF
C2604 wbs_dat_o[28] gnd 0.63fF
C2605 wbs_dat_i[28] gnd 0.63fF
C2606 wbs_adr_i[28] gnd 0.63fF
C2607 wbs_dat_o[27] gnd 0.63fF
C2608 wbs_dat_i[27] gnd 0.63fF
C2609 wbs_adr_i[27] gnd 0.63fF
C2610 wbs_dat_o[26] gnd 0.63fF
C2611 wbs_dat_i[26] gnd 0.63fF
C2612 wbs_adr_i[26] gnd 0.63fF
C2613 wbs_dat_o[25] gnd 0.63fF
C2614 wbs_dat_i[25] gnd 0.63fF
C2615 wbs_adr_i[25] gnd 0.63fF
C2616 wbs_dat_o[24] gnd 0.63fF
C2617 wbs_dat_i[24] gnd 0.63fF
C2618 wbs_adr_i[24] gnd 0.63fF
C2619 wbs_dat_o[23] gnd 0.63fF
C2620 wbs_dat_i[23] gnd 0.63fF
C2621 wbs_adr_i[23] gnd 0.63fF
C2622 wbs_dat_o[22] gnd 0.63fF
C2623 wbs_dat_i[22] gnd 0.63fF
C2624 wbs_adr_i[22] gnd 0.63fF
C2625 wbs_dat_o[21] gnd 0.63fF
C2626 wbs_dat_i[21] gnd 0.63fF
C2627 wbs_adr_i[21] gnd 0.63fF
C2628 wbs_dat_o[20] gnd 0.63fF
C2629 wbs_dat_i[20] gnd 0.63fF
C2630 wbs_adr_i[20] gnd 0.63fF
C2631 wbs_dat_o[19] gnd 0.63fF
C2632 wbs_dat_i[19] gnd 0.63fF
C2633 wbs_adr_i[19] gnd 0.63fF
C2634 wbs_dat_o[18] gnd 0.63fF
C2635 wbs_dat_i[18] gnd 0.63fF
C2636 wbs_adr_i[18] gnd 0.63fF
C2637 wbs_dat_o[17] gnd 0.63fF
C2638 wbs_dat_i[17] gnd 0.63fF
C2639 wbs_adr_i[17] gnd 0.63fF
C2640 wbs_dat_o[16] gnd 0.63fF
C2641 wbs_dat_i[16] gnd 0.63fF
C2642 wbs_adr_i[16] gnd 0.63fF
C2643 wbs_dat_o[15] gnd 0.63fF
C2644 wbs_dat_i[15] gnd 0.63fF
C2645 wbs_adr_i[15] gnd 0.63fF
C2646 wbs_dat_o[14] gnd 0.63fF
C2647 wbs_dat_i[14] gnd 0.63fF
C2648 wbs_adr_i[14] gnd 0.63fF
C2649 wbs_dat_o[13] gnd 0.63fF
C2650 wbs_dat_i[13] gnd 0.63fF
C2651 wbs_adr_i[13] gnd 0.63fF
C2652 wbs_dat_o[12] gnd 0.63fF
C2653 wbs_dat_i[12] gnd 0.63fF
C2654 wbs_adr_i[12] gnd 0.63fF
C2655 wbs_dat_o[11] gnd 0.63fF
C2656 wbs_dat_i[11] gnd 0.63fF
C2657 wbs_adr_i[11] gnd 0.63fF
C2658 wbs_dat_o[10] gnd 0.63fF
C2659 wbs_dat_i[10] gnd 0.63fF
C2660 wbs_adr_i[10] gnd 0.63fF
C2661 wbs_dat_o[9] gnd 0.63fF
C2662 wbs_dat_i[9] gnd 0.63fF
C2663 wbs_adr_i[9] gnd 0.63fF
C2664 wbs_dat_o[8] gnd 0.63fF
C2665 wbs_dat_i[8] gnd 0.63fF
C2666 wbs_adr_i[8] gnd 0.63fF
C2667 wbs_dat_o[7] gnd 0.63fF
C2668 wbs_dat_i[7] gnd 0.63fF
C2669 wbs_adr_i[7] gnd 0.63fF
C2670 wbs_dat_o[6] gnd 0.63fF
C2671 wbs_dat_i[6] gnd 0.63fF
C2672 wbs_adr_i[6] gnd 0.63fF
C2673 wbs_dat_o[5] gnd 0.63fF
C2674 wbs_dat_i[5] gnd 0.63fF
C2675 wbs_adr_i[5] gnd 0.63fF
C2676 wbs_dat_o[4] gnd 0.63fF
C2677 wbs_dat_i[4] gnd 0.63fF
C2678 wbs_adr_i[4] gnd 0.63fF
C2679 wbs_sel_i[3] gnd 0.63fF
C2680 wbs_dat_o[3] gnd 0.63fF
C2681 wbs_dat_i[3] gnd 0.63fF
C2682 wbs_adr_i[3] gnd 0.63fF
C2683 wbs_sel_i[2] gnd 0.63fF
C2684 wbs_dat_o[2] gnd 0.63fF
C2685 wbs_dat_i[2] gnd 0.63fF
C2686 wbs_adr_i[2] gnd 0.63fF
C2687 wbs_sel_i[1] gnd 0.63fF
C2688 wbs_dat_o[1] gnd 0.63fF
C2689 wbs_dat_i[1] gnd 0.63fF
C2690 wbs_adr_i[1] gnd 0.63fF
C2691 wbs_sel_i[0] gnd 0.63fF
C2692 wbs_dat_o[0] gnd 0.63fF
C2693 wbs_dat_i[0] gnd 0.63fF
C2694 wbs_adr_i[0] gnd 0.63fF
C2695 wbs_we_i gnd 0.63fF
C2696 wbs_stb_i gnd 0.63fF
C2697 wbs_cyc_i gnd 0.63fF
C2698 wbs_ack_o gnd 0.63fF
C2699 wb_rst_i gnd 0.63fF
C2700 wb_clk_i gnd 0.63fF
C2701 m5_523158_96000# gnd 31.54fF **FLOATING
C2702 m5_453050_96000# gnd 28.53fF **FLOATING
C2703 m4_523158_52000# gnd 37.79fF **FLOATING
C2704 m4_453050_52000# gnd 34.15fF **FLOATING
C2705 m4_453050_146758# gnd 39.99fF **FLOATING
C2706 m2_494098_659718# gnd 0.80fF **FLOATING
C2707 pll_full_1/divider_0/and_0/Z1 gnd 0.65fF
C2708 pll_full_1/divider_0/and_0/B gnd 2.45fF
C2709 pll_full_1/divider_0/and_0/A gnd 2.35fF
C2710 pll_full_1/divider_0/and_0/out1 gnd 2.99fF
C2711 pll_full_1/divider_0/tspc_2/Z4 gnd 0.86fF
C2712 pll_full_1/divider_0/tspc_2/Z3 gnd 2.26fF
C2713 pll_full_1/divider_0/tspc_2/Z2 gnd 1.46fF
C2714 pll_full_1/divider_0/tspc_2/Z1 gnd 0.99fF
C2715 pll_full_1/divider_0/nor_0/A gnd 7.08fF
C2716 pll_full_1/divider_0/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2717 pll_full_1/divider_0/tspc_1/Z4 gnd 0.86fF
C2718 pll_full_1/divider_0/tspc_1/Z3 gnd 2.26fF
C2719 pll_full_1/divider_0/tspc_1/Z2 gnd 1.46fF
C2720 pll_full_1/divider_0/tspc_1/Z1 gnd 0.99fF
C2721 pll_full_1/divider_0/nor_0/B gnd 7.12fF
C2722 pll_full_1/divider_0/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2723 pll_full_1/divider_0/tspc_2/Q gnd 3.14fF
C2724 pll_full_1/divider_0/tspc_0/Z4 gnd 0.86fF
C2725 pll_full_1/divbuf_0/IN gnd 9.89fF
C2726 pll_full_1/divider_0/tspc_0/Z3 gnd 2.26fF
C2727 pll_full_1/divider_0/tspc_0/Z2 gnd 1.46fF
C2728 pll_full_1/divider_0/tspc_0/Z1 gnd 0.99fF
C2729 pll_full_1/divider_0/nor_1/B gnd 6.48fF
C2730 pll_full_1/divider_0/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2731 pll_full_1/divider_0/tspc_1/Q gnd 3.12fF
C2732 pll_full_1/divider_0/clk gnd 33.42fF
C2733 pll_full_1/divider_0/prescaler_0/nand_1/z1 gnd 0.36fF
C2734 pll_full_1/divider_0/prescaler_0/tspc_0/D gnd 2.64fF
C2735 pll_full_1/divider_0/prescaler_0/tspc_2/Q gnd 3.72fF
C2736 pll_full_1/divider_0/prescaler_0/tspc_1/Q gnd 3.61fF
C2737 pll_full_1/divider_0/prescaler_0/nand_0/z1 gnd 0.36fF
C2738 pll_full_1/divider_0/prescaler_0/tspc_2/D gnd 3.12fF
C2739 pll_full_1/divider_0/and_0/OUT gnd 5.67fF
C2740 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2741 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2742 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 gnd 1.19fF
C2743 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2744 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# gnd 1.47fF **FLOATING
C2745 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2746 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2747 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2748 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2749 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2750 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2751 pll_full_1/divider_0/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2752 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2753 pll_full_1/divider_0/prescaler_0/Out gnd 4.59fF
C2754 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2755 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2756 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2757 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2758 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2759 pll_full_1/divider_0/nor_1/Z1 gnd 1.34fF
C2760 pll_full_1/divider_0/nor_0/Z1 gnd 1.34fF
C2761 pll_full_1/divbuf_1/OUT gnd 363.82fF
C2762 pll_full_1/divbuf_1/OUT5 gnd 350.37fF
C2763 pll_full_1/divbuf_1/OUT4 gnd 133.72fF
C2764 pll_full_1/divbuf_1/OUT3 gnd 34.03fF
C2765 pll_full_1/divbuf_1/OUT2 gnd 8.71fF
C2766 pll_full_1/divbuf_1/a_492_n240# gnd 2.46fF **FLOATING
C2767 pll_full_1/divbuf_0/OUT5 gnd 350.37fF
C2768 pll_full_1/divbuf_0/OUT4 gnd 133.72fF
C2769 pll_full_1/divbuf_0/OUT3 gnd 34.03fF
C2770 pll_full_1/divbuf_0/OUT2 gnd 8.71fF
C2771 pll_full_1/divbuf_0/a_492_n240# gnd 2.46fF **FLOATING
C2772 pll_full_1/ro_complete_0/cbank_2/v gnd 16.43fF
C2773 pll_full_1/ro_complete_0/cbank_2/switch_5/vin gnd 0.78fF
C2774 pll_full_1/ro_complete_0/cbank_2/switch_4/vin gnd 1.50fF
C2775 pll_full_1/ro_complete_0/cbank_2/switch_2/vin gnd 1.30fF
C2776 pll_full_1/ro_complete_0/cbank_2/switch_3/vin gnd 0.56fF
C2777 pll_full_1/ro_complete_0/cbank_2/switch_1/vin gnd 1.14fF
C2778 pll_full_1/ro_complete_0/cbank_2/switch_0/vin gnd 1.02fF
C2779 pll_full_1/ro_complete_0/cbank_1/switch_5/vin gnd 0.78fF
C2780 pll_full_1/ro_complete_0/a0 gnd 5.35fF
C2781 pll_full_1/ro_complete_0/cbank_1/switch_4/vin gnd 1.50fF
C2782 pll_full_1/ro_complete_0/a1 gnd 6.54fF
C2783 pll_full_1/ro_complete_0/cbank_1/switch_2/vin gnd 1.30fF
C2784 pll_full_1/ro_complete_0/a3 gnd 5.96fF
C2785 pll_full_1/ro_complete_0/cbank_1/switch_3/vin gnd 0.56fF
C2786 pll_full_1/ro_complete_0/a2 gnd 5.21fF
C2787 pll_full_1/ro_complete_0/cbank_1/switch_1/vin gnd 1.14fF
C2788 pll_full_1/ro_complete_0/a4 gnd 5.81fF
C2789 pll_full_1/ro_complete_0/cbank_1/switch_0/vin gnd 1.02fF
C2790 pll_full_1/ro_complete_0/a5 gnd 6.74fF
C2791 pll_full_1/ro_complete_0/cbank_0/v gnd 15.12fF
C2792 pll_full_1/ro_complete_0/cbank_0/switch_5/vin gnd 0.78fF
C2793 pll_full_1/ro_complete_0/cbank_0/switch_4/vin gnd 1.50fF
C2794 pll_full_1/ro_complete_0/cbank_0/switch_2/vin gnd 1.30fF
C2795 pll_full_1/ro_complete_0/cbank_0/switch_3/vin gnd 0.56fF
C2796 pll_full_1/ro_complete_0/cbank_0/switch_1/vin gnd 1.14fF
C2797 pll_full_1/ro_complete_0/cbank_0/switch_0/vin gnd 1.02fF
C2798 pll_full_1/ro_complete_0/ro_var_extend_0/vcont gnd 0.27fF
C2799 pll_full_1/filter_0/a_4216_n5230# gnd 418.90fF **FLOATING
C2800 pll_full_1/filter_0/a_4216_n2998# gnd 1.39fF **FLOATING
C2801 pll_full_1/cp_0/down gnd 1.54fF
C2802 pll_full_1/cp_0/upbar gnd 1.79fF
C2803 pll_full_1/cp_0/a_7110_n2840# gnd 0.17fF **FLOATING
C2804 pll_full_1/cp_0/a_3060_n2840# gnd 1.71fF **FLOATING
C2805 pll_full_1/cp_0/a_7110_0# gnd 0.17fF **FLOATING
C2806 pll_full_1/cp_0/a_6370_0# gnd 0.40fF **FLOATING
C2807 pll_full_1/cp_0/a_3060_0# gnd 2.49fF **FLOATING
C2808 pll_full_1/cp_0/a_1710_0# gnd 7.47fF **FLOATING
C2809 pll_full_1/pd_0/UP gnd 6.41fF
C2810 pll_full_1/pd_0/and_pd_0/Z1 gnd 0.39fF
C2811 pll_full_1/pd_0/and_pd_0/Out1 gnd 2.22fF
C2812 pll_full_1/pd_0/tspc_r_1/z5 gnd 1.10fF
C2813 pll_full_1/pd_0/tspc_r_1/Z4 gnd 1.07fF
C2814 pll_full_1/pd_0/tspc_r_1/Qbar gnd 0.88fF
C2815 pll_full_1/pd_0/tspc_r_1/Z2 gnd 1.22fF
C2816 pll_full_1/pd_0/tspc_r_1/Z1 gnd 0.67fF
C2817 pll_full_1/pd_0/tspc_r_1/Qbar1 gnd 1.34fF
C2818 pll_full_1/pd_0/tspc_r_1/Z3 gnd 2.12fF
C2819 pll_full_1/pd_0/REF gnd 6.48fF
C2820 pll_full_1/pd_0/tspc_r_0/z5 gnd 1.10fF
C2821 pll_full_1/pd_0/tspc_r_0/Z4 gnd 1.07fF
C2822 pll_full_1/pd_0/R gnd 3.05fF
C2823 pll_full_1/pd_0/tspc_r_0/Qbar gnd 0.79fF
C2824 pll_full_1/pd_0/tspc_r_0/Z2 gnd 1.22fF
C2825 pll_full_1/pd_0/tspc_r_0/Z1 gnd 0.67fF
C2826 pll_full_1/pd_0/DOWN gnd 7.34fF
C2827 pll_full_1/pd_0/tspc_r_0/Qbar1 gnd 1.34fF
C2828 pll_full_1/pd_0/tspc_r_0/Z3 gnd 2.12fF
C2829 pll_full_1/pd_0/DIV gnd 372.69fF
C2830 pll_full_0/divider_0/and_0/Z1 gnd 0.65fF
C2831 pll_full_0/divider_0/and_0/B gnd 2.45fF
C2832 pll_full_0/divider_0/and_0/A gnd 2.35fF
C2833 pll_full_0/divider_0/and_0/out1 gnd 2.99fF
C2834 pll_full_0/divider_0/tspc_2/Z4 gnd 0.86fF
C2835 pll_full_0/divider_0/tspc_2/Z3 gnd 2.26fF
C2836 pll_full_0/divider_0/tspc_2/Z2 gnd 1.46fF
C2837 pll_full_0/divider_0/tspc_2/Z1 gnd 0.99fF
C2838 pll_full_0/divider_0/nor_0/A gnd 7.08fF
C2839 pll_full_0/divider_0/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2840 pll_full_0/divider_0/tspc_1/Z4 gnd 0.86fF
C2841 pll_full_0/divider_0/tspc_1/Z3 gnd 2.26fF
C2842 pll_full_0/divider_0/tspc_1/Z2 gnd 1.46fF
C2843 pll_full_0/divider_0/tspc_1/Z1 gnd 0.99fF
C2844 pll_full_0/divider_0/nor_0/B gnd 7.12fF
C2845 pll_full_0/divider_0/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2846 pll_full_0/divider_0/tspc_2/Q gnd 3.14fF
C2847 pll_full_0/divider_0/tspc_0/Z4 gnd 0.86fF
C2848 pll_full_0/divbuf_0/IN gnd 9.89fF
C2849 pll_full_0/divider_0/tspc_0/Z3 gnd 2.26fF
C2850 pll_full_0/divider_0/tspc_0/Z2 gnd 1.46fF
C2851 pll_full_0/divider_0/tspc_0/Z1 gnd 0.99fF
C2852 pll_full_0/divider_0/nor_1/B gnd 6.48fF
C2853 pll_full_0/divider_0/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2854 pll_full_0/divider_0/tspc_1/Q gnd 3.12fF
C2855 pll_full_0/divider_0/clk gnd 33.42fF
C2856 pll_full_0/divider_0/prescaler_0/nand_1/z1 gnd 0.36fF
C2857 pll_full_0/divider_0/prescaler_0/tspc_0/D gnd 2.64fF
C2858 pll_full_0/divider_0/prescaler_0/tspc_2/Q gnd 3.72fF
C2859 pll_full_0/divider_0/prescaler_0/tspc_1/Q gnd 3.61fF
C2860 pll_full_0/divider_0/prescaler_0/nand_0/z1 gnd 0.36fF
C2861 pll_full_0/divider_0/prescaler_0/tspc_2/D gnd 3.12fF
C2862 pll_full_0/divider_0/and_0/OUT gnd 5.67fF
C2863 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2864 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2865 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 gnd 1.19fF
C2866 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2867 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# gnd 1.47fF **FLOATING
C2868 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2869 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2870 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2871 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2872 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2873 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2874 pll_full_0/divider_0/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2875 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2876 pll_full_0/divider_0/prescaler_0/Out gnd 4.59fF
C2877 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2878 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2879 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2880 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2881 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2882 pll_full_0/divider_0/nor_1/Z1 gnd 1.34fF
C2883 pll_full_0/divider_0/nor_0/Z1 gnd 1.34fF
C2884 pll_full_0/divbuf_1/OUT gnd 363.82fF
C2885 pll_full_0/divbuf_1/OUT5 gnd 350.37fF
C2886 pll_full_0/divbuf_1/OUT4 gnd 133.72fF
C2887 pll_full_0/divbuf_1/OUT3 gnd 34.03fF
C2888 pll_full_0/divbuf_1/OUT2 gnd 8.71fF
C2889 pll_full_0/divbuf_1/a_492_n240# gnd 2.46fF **FLOATING
C2890 pll_full_0/divbuf_0/OUT5 gnd 350.37fF
C2891 pll_full_0/divbuf_0/OUT4 gnd 133.72fF
C2892 pll_full_0/divbuf_0/OUT3 gnd 34.03fF
C2893 pll_full_0/divbuf_0/OUT2 gnd 8.71fF
C2894 pll_full_0/divbuf_0/a_492_n240# gnd 2.46fF **FLOATING
C2895 pll_full_0/ro_complete_0/cbank_2/v gnd 16.43fF
C2896 pll_full_0/ro_complete_0/cbank_2/switch_5/vin gnd 0.78fF
C2897 pll_full_0/ro_complete_0/cbank_2/switch_4/vin gnd 1.50fF
C2898 pll_full_0/ro_complete_0/cbank_2/switch_2/vin gnd 1.30fF
C2899 pll_full_0/ro_complete_0/cbank_2/switch_3/vin gnd 0.56fF
C2900 pll_full_0/ro_complete_0/cbank_2/switch_1/vin gnd 1.14fF
C2901 pll_full_0/ro_complete_0/cbank_2/switch_0/vin gnd 1.02fF
C2902 pll_full_0/ro_complete_0/cbank_1/switch_5/vin gnd 0.78fF
C2903 pll_full_0/ro_complete_0/a0 gnd 5.35fF
C2904 pll_full_0/ro_complete_0/cbank_1/switch_4/vin gnd 1.50fF
C2905 pll_full_0/ro_complete_0/a1 gnd 6.54fF
C2906 pll_full_0/ro_complete_0/cbank_1/switch_2/vin gnd 1.30fF
C2907 pll_full_0/ro_complete_0/a3 gnd 5.96fF
C2908 pll_full_0/ro_complete_0/cbank_1/switch_3/vin gnd 0.56fF
C2909 pll_full_0/ro_complete_0/a2 gnd 5.21fF
C2910 pll_full_0/ro_complete_0/cbank_1/switch_1/vin gnd 1.14fF
C2911 pll_full_0/ro_complete_0/a4 gnd 5.81fF
C2912 pll_full_0/ro_complete_0/cbank_1/switch_0/vin gnd 1.02fF
C2913 pll_full_0/ro_complete_0/a5 gnd 6.74fF
C2914 pll_full_0/ro_complete_0/cbank_0/v gnd 15.12fF
C2915 pll_full_0/ro_complete_0/cbank_0/switch_5/vin gnd 0.78fF
C2916 pll_full_0/ro_complete_0/cbank_0/switch_4/vin gnd 1.50fF
C2917 pll_full_0/ro_complete_0/cbank_0/switch_2/vin gnd 1.30fF
C2918 pll_full_0/ro_complete_0/cbank_0/switch_3/vin gnd 0.56fF
C2919 pll_full_0/ro_complete_0/cbank_0/switch_1/vin gnd 1.14fF
C2920 pll_full_0/ro_complete_0/cbank_0/switch_0/vin gnd 1.02fF
C2921 pll_full_0/ro_complete_0/ro_var_extend_0/vcont gnd 0.27fF
C2922 pll_full_0/filter_0/a_4216_n5230# gnd 418.90fF **FLOATING
C2923 pll_full_0/filter_0/a_4216_n2998# gnd 1.39fF **FLOATING
C2924 pll_full_0/cp_0/down gnd 1.54fF
C2925 pll_full_0/cp_0/upbar gnd 1.79fF
C2926 pll_full_0/cp_0/a_7110_n2840# gnd 0.17fF **FLOATING
C2927 pll_full_0/cp_0/a_3060_n2840# gnd 1.71fF **FLOATING
C2928 pll_full_0/cp_0/a_7110_0# gnd 0.17fF **FLOATING
C2929 pll_full_0/cp_0/a_6370_0# gnd 0.40fF **FLOATING
C2930 pll_full_0/cp_0/a_3060_0# gnd 2.49fF **FLOATING
C2931 pll_full_0/cp_0/a_1710_0# gnd 7.47fF **FLOATING
C2932 pll_full_0/pd_0/UP gnd 6.41fF
C2933 pll_full_0/pd_0/and_pd_0/Z1 gnd 0.39fF
C2934 pll_full_0/pd_0/and_pd_0/Out1 gnd 2.22fF
C2935 pll_full_0/pd_0/tspc_r_1/z5 gnd 1.10fF
C2936 pll_full_0/pd_0/tspc_r_1/Z4 gnd 1.07fF
C2937 pll_full_0/pd_0/tspc_r_1/Qbar gnd 0.88fF
C2938 pll_full_0/pd_0/tspc_r_1/Z2 gnd 1.22fF
C2939 pll_full_0/pd_0/tspc_r_1/Z1 gnd 0.67fF
C2940 pll_full_0/pd_0/tspc_r_1/Qbar1 gnd 1.34fF
C2941 pll_full_0/pd_0/tspc_r_1/Z3 gnd 2.12fF
C2942 pll_full_0/pd_0/REF gnd 6.48fF
C2943 pll_full_0/pd_0/tspc_r_0/z5 gnd 1.10fF
C2944 pll_full_0/pd_0/tspc_r_0/Z4 gnd 1.07fF
C2945 pll_full_0/pd_0/R gnd 3.05fF
C2946 pll_full_0/pd_0/tspc_r_0/Qbar gnd 0.79fF
C2947 pll_full_0/pd_0/tspc_r_0/Z2 gnd 1.22fF
C2948 pll_full_0/pd_0/tspc_r_0/Z1 gnd 0.67fF
C2949 pll_full_0/pd_0/DOWN gnd 7.34fF
C2950 pll_full_0/pd_0/tspc_r_0/Qbar1 gnd 1.34fF
C2951 pll_full_0/pd_0/tspc_r_0/Z3 gnd 2.12fF
C2952 pll_full_0/pd_0/DIV gnd 372.69fF
C2953 divbuf_19/OUT gnd 363.82fF
C2954 divbuf_19/OUT5 gnd 350.37fF
C2955 divbuf_19/OUT4 gnd 133.72fF
C2956 divbuf_19/OUT3 gnd 34.03fF
C2957 divbuf_19/OUT2 gnd 8.71fF
C2958 divbuf_19/IN gnd 0.89fF
C2959 divbuf_19/a_492_n240# gnd 2.46fF **FLOATING
C2960 divbuf_18/OUT gnd 363.82fF
C2961 divbuf_18/OUT5 gnd 350.37fF
C2962 divbuf_18/OUT4 gnd 133.72fF
C2963 divbuf_18/OUT3 gnd 34.03fF
C2964 divbuf_18/OUT2 gnd 8.71fF
C2965 divbuf_18/IN gnd 0.89fF
C2966 divbuf_18/a_492_n240# gnd 2.46fF **FLOATING
C2967 divbuf_17/OUT gnd 363.82fF
C2968 divbuf_17/OUT5 gnd 350.37fF
C2969 divbuf_17/OUT4 gnd 133.72fF
C2970 divbuf_17/OUT3 gnd 34.03fF
C2971 divbuf_17/OUT2 gnd 8.71fF
C2972 divbuf_17/IN gnd 0.89fF
C2973 divbuf_17/a_492_n240# gnd 2.46fF **FLOATING
C2974 divider_2/and_0/Z1 gnd 0.74fF
C2975 divider_2/and_0/B gnd 2.25fF
C2976 divider_2/and_0/A gnd 2.19fF
C2977 divider_2/and_0/out1 gnd 2.93fF
C2978 divider_2/tspc_2/Z4 gnd 0.86fF
C2979 divider_2/tspc_2/Z3 gnd 2.26fF
C2980 divider_2/tspc_2/Z2 gnd 1.46fF
C2981 divider_2/tspc_2/Z1 gnd 0.99fF
C2982 divider_2/nor_0/A gnd 7.04fF
C2983 divider_2/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2984 divider_2/tspc_1/Z4 gnd 0.86fF
C2985 divider_2/tspc_1/Z3 gnd 2.26fF
C2986 divider_2/tspc_1/Z2 gnd 1.46fF
C2987 divider_2/tspc_1/Z1 gnd 0.99fF
C2988 divider_2/nor_0/B gnd 7.05fF
C2989 divider_2/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2990 divider_2/tspc_2/Q gnd 3.14fF
C2991 divider_2/tspc_0/Z4 gnd 0.86fF
C2992 divider_2/Out gnd 1.60fF
C2993 divider_2/tspc_0/Z3 gnd 2.26fF
C2994 divider_2/tspc_0/Z2 gnd 1.46fF
C2995 divider_2/tspc_0/Z1 gnd 0.99fF
C2996 divider_2/nor_1/B gnd 6.44fF
C2997 divider_2/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2998 divider_2/tspc_1/Q gnd 3.12fF
C2999 divider_2/clk gnd 5.63fF
C3000 divider_2/prescaler_0/nand_1/z1 gnd 0.36fF
C3001 divider_2/prescaler_0/tspc_0/D gnd 2.64fF
C3002 divider_2/prescaler_0/tspc_2/Q gnd 3.74fF
C3003 divider_2/prescaler_0/tspc_1/Q gnd 3.61fF
C3004 divider_2/prescaler_0/nand_0/z1 gnd 0.36fF
C3005 divider_2/prescaler_0/tspc_2/D gnd 3.12fF
C3006 divider_2/and_0/OUT gnd 5.62fF
C3007 divider_2/prescaler_0/tspc_2/Z4 gnd 0.86fF
C3008 divider_2/prescaler_0/tspc_2/Z3 gnd 2.26fF
C3009 divider_2/prescaler_0/tspc_2/Z2 gnd 1.46fF
C3010 divider_2/prescaler_0/tspc_2/Z1 gnd 0.99fF
C3011 divider_2/prescaler_0/tspc_2/a_630_n680# gnd 1.14fF **FLOATING
C3012 divider_2/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C3013 divider_2/prescaler_0/tspc_1/Z4 gnd 0.86fF
C3014 divider_2/prescaler_0/tspc_1/Z3 gnd 2.26fF
C3015 divider_2/prescaler_0/tspc_1/Z2 gnd 1.48fF
C3016 divider_2/prescaler_0/tspc_1/Z1 gnd 0.99fF
C3017 divider_2/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C3018 divider_2/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C3019 divider_2/prescaler_0/tspc_0/Z4 gnd 0.86fF
C3020 divider_2/prescaler_0/Out gnd 4.59fF
C3021 divider_2/prescaler_0/tspc_0/Z3 gnd 2.26fF
C3022 divider_2/prescaler_0/tspc_0/Z2 gnd 1.46fF
C3023 divider_2/prescaler_0/tspc_0/Z1 gnd 0.99fF
C3024 divider_2/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C3025 divider_2/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C3026 divider_2/nor_1/Z1 gnd 1.34fF
C3027 divider_2/mc2 gnd 5.29fF
C3028 divider_2/nor_0/Z1 gnd 1.34fF
C3029 divbuf_16/OUT gnd 363.82fF
C3030 divbuf_16/OUT5 gnd 350.37fF
C3031 divbuf_16/OUT4 gnd 133.72fF
C3032 divbuf_16/OUT3 gnd 34.03fF
C3033 divbuf_16/OUT2 gnd 8.71fF
C3034 divbuf_16/IN gnd 0.89fF
C3035 divbuf_16/a_492_n240# gnd 2.46fF **FLOATING
C3036 divider_1/and_0/Z1 gnd 0.74fF
C3037 divider_1/and_0/B gnd 2.25fF
C3038 divider_1/and_0/A gnd 2.19fF
C3039 divider_1/and_0/out1 gnd 2.93fF
C3040 divider_1/tspc_2/Z4 gnd 0.86fF
C3041 divider_1/tspc_2/Z3 gnd 2.26fF
C3042 divider_1/tspc_2/Z2 gnd 1.46fF
C3043 divider_1/tspc_2/Z1 gnd 0.99fF
C3044 divider_1/nor_0/A gnd 7.04fF
C3045 divider_1/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C3046 divider_1/tspc_1/Z4 gnd 0.86fF
C3047 divider_1/tspc_1/Z3 gnd 2.26fF
C3048 divider_1/tspc_1/Z2 gnd 1.46fF
C3049 divider_1/tspc_1/Z1 gnd 0.99fF
C3050 divider_1/nor_0/B gnd 7.05fF
C3051 divider_1/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C3052 divider_1/tspc_2/Q gnd 3.14fF
C3053 divider_1/tspc_0/Z4 gnd 0.86fF
C3054 divider_1/Out gnd 1.60fF
C3055 divider_1/tspc_0/Z3 gnd 2.26fF
C3056 divider_1/tspc_0/Z2 gnd 1.46fF
C3057 divider_1/tspc_0/Z1 gnd 0.99fF
C3058 divider_1/nor_1/B gnd 6.33fF
C3059 divider_1/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C3060 divider_1/tspc_1/Q gnd 3.12fF
C3061 divider_1/clk gnd 5.63fF
C3062 divider_1/prescaler_0/nand_1/z1 gnd 0.36fF
C3063 divider_1/prescaler_0/tspc_0/D gnd 2.64fF
C3064 divider_1/prescaler_0/tspc_2/Q gnd 3.74fF
C3065 divider_1/prescaler_0/tspc_1/Q gnd 3.61fF
C3066 divider_1/prescaler_0/nand_0/z1 gnd 0.36fF
C3067 divider_1/prescaler_0/tspc_2/D gnd 3.12fF
C3068 divider_1/and_0/OUT gnd 5.62fF
C3069 divider_1/prescaler_0/tspc_2/Z4 gnd 0.86fF
C3070 divider_1/prescaler_0/tspc_2/Z3 gnd 2.26fF
C3071 divider_1/prescaler_0/tspc_2/Z2 gnd 1.46fF
C3072 divider_1/prescaler_0/tspc_2/Z1 gnd 0.99fF
C3073 divider_1/prescaler_0/tspc_2/a_630_n680# gnd 1.14fF **FLOATING
C3074 divider_1/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C3075 divider_1/prescaler_0/tspc_1/Z4 gnd 0.86fF
C3076 divider_1/prescaler_0/tspc_1/Z3 gnd 2.26fF
C3077 divider_1/prescaler_0/tspc_1/Z2 gnd 1.48fF
C3078 divider_1/prescaler_0/tspc_1/Z1 gnd 0.99fF
C3079 divider_1/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C3080 divider_1/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C3081 divider_1/prescaler_0/tspc_0/Z4 gnd 0.86fF
C3082 divider_1/prescaler_0/Out gnd 4.59fF
C3083 divider_1/prescaler_0/tspc_0/Z3 gnd 2.26fF
C3084 divider_1/prescaler_0/tspc_0/Z2 gnd 1.46fF
C3085 divider_1/prescaler_0/tspc_0/Z1 gnd 0.99fF
C3086 divider_1/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C3087 divider_1/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C3088 divider_1/nor_1/Z1 gnd 1.34fF
C3089 divider_1/mc2 gnd 5.29fF
C3090 divider_1/nor_0/Z1 gnd 1.34fF
C3091 divbuf_15/OUT gnd 363.82fF
C3092 divbuf_15/OUT5 gnd 350.37fF
C3093 divbuf_15/OUT4 gnd 133.72fF
C3094 divbuf_15/OUT3 gnd 34.03fF
C3095 divbuf_15/OUT2 gnd 8.71fF
C3096 divbuf_15/IN gnd 0.89fF
C3097 divbuf_15/a_492_n240# gnd 2.46fF **FLOATING
C3098 divbuf_25/OUT5 gnd 350.37fF
C3099 divbuf_25/OUT4 gnd 133.72fF
C3100 divbuf_25/OUT3 gnd 34.03fF
C3101 divbuf_25/OUT2 gnd 8.71fF
C3102 divbuf_25/IN gnd 0.89fF
C3103 divbuf_25/a_492_n240# gnd 2.46fF **FLOATING
C3104 divbuf_14/OUT gnd 363.82fF
C3105 divbuf_14/OUT5 gnd 350.37fF
C3106 divbuf_14/OUT4 gnd 133.72fF
C3107 divbuf_14/OUT3 gnd 34.03fF
C3108 divbuf_14/OUT2 gnd 8.71fF
C3109 divbuf_14/IN gnd 0.89fF
C3110 divbuf_14/a_492_n240# gnd 2.46fF **FLOATING
C3111 divider_0/and_0/Z1 gnd 0.74fF
C3112 divider_0/and_0/B gnd 2.25fF
C3113 divider_0/and_0/A gnd 2.19fF
C3114 divider_0/and_0/out1 gnd 2.93fF
C3115 divider_0/tspc_2/Z4 gnd 0.86fF
C3116 divider_0/tspc_2/Z3 gnd 2.26fF
C3117 divider_0/tspc_2/Z2 gnd 1.46fF
C3118 divider_0/tspc_2/Z1 gnd 0.99fF
C3119 divider_0/nor_0/A gnd 7.04fF
C3120 divider_0/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C3121 divider_0/tspc_1/Z4 gnd 0.86fF
C3122 divider_0/tspc_1/Z3 gnd 2.26fF
C3123 divider_0/tspc_1/Z2 gnd 1.46fF
C3124 divider_0/tspc_1/Z1 gnd 0.99fF
C3125 divider_0/nor_0/B gnd 7.05fF
C3126 divider_0/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C3127 divider_0/tspc_2/Q gnd 3.14fF
C3128 divider_0/tspc_0/Z4 gnd 0.86fF
C3129 divider_0/Out gnd 1.60fF
C3130 divider_0/tspc_0/Z3 gnd 2.26fF
C3131 divider_0/tspc_0/Z2 gnd 1.46fF
C3132 divider_0/tspc_0/Z1 gnd 0.99fF
C3133 divider_0/nor_1/B gnd 6.33fF
C3134 divider_0/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C3135 divider_0/tspc_1/Q gnd 3.12fF
C3136 divider_0/clk gnd 5.63fF
C3137 divider_0/prescaler_0/nand_1/z1 gnd 0.36fF
C3138 divider_0/prescaler_0/tspc_0/D gnd 2.64fF
C3139 divider_0/prescaler_0/tspc_2/Q gnd 3.64fF
C3140 divider_0/prescaler_0/tspc_1/Q gnd 3.61fF
C3141 divider_0/prescaler_0/nand_0/z1 gnd 0.36fF
C3142 divider_0/prescaler_0/tspc_2/D gnd 3.12fF
C3143 divider_0/and_0/OUT gnd 5.62fF
C3144 divider_0/prescaler_0/tspc_2/Z4 gnd 0.86fF
C3145 divider_0/prescaler_0/tspc_2/Z3 gnd 2.26fF
C3146 divider_0/prescaler_0/tspc_2/Z2 gnd 1.46fF
C3147 divider_0/prescaler_0/tspc_2/Z1 gnd 0.99fF
C3148 divider_0/prescaler_0/tspc_2/a_630_n680# gnd 1.14fF **FLOATING
C3149 divider_0/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C3150 divider_0/prescaler_0/tspc_1/Z4 gnd 0.86fF
C3151 divider_0/prescaler_0/tspc_1/Z3 gnd 2.26fF
C3152 divider_0/prescaler_0/tspc_1/Z2 gnd 1.48fF
C3153 divider_0/prescaler_0/tspc_1/Z1 gnd 0.99fF
C3154 divider_0/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C3155 divider_0/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C3156 divider_0/prescaler_0/tspc_0/Z4 gnd 0.86fF
C3157 divider_0/prescaler_0/Out gnd 4.59fF
C3158 divider_0/prescaler_0/tspc_0/Z3 gnd 2.26fF
C3159 divider_0/prescaler_0/tspc_0/Z2 gnd 1.46fF
C3160 divider_0/prescaler_0/tspc_0/Z1 gnd 0.99fF
C3161 divider_0/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C3162 divider_0/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C3163 divider_0/nor_1/Z1 gnd 1.34fF
C3164 divider_0/mc2 gnd 5.29fF
C3165 divider_0/nor_0/Z1 gnd 1.34fF
C3166 divbuf_24/OUT gnd 363.82fF
C3167 divbuf_24/OUT5 gnd 350.37fF
C3168 divbuf_24/OUT4 gnd 133.72fF
C3169 divbuf_24/OUT3 gnd 34.03fF
C3170 divbuf_24/OUT2 gnd 8.71fF
C3171 divbuf_24/IN gnd 0.89fF
C3172 divbuf_24/a_492_n240# gnd 2.46fF **FLOATING
C3173 divbuf_13/OUT gnd 363.82fF
C3174 divbuf_13/OUT5 gnd 350.37fF
C3175 divbuf_13/OUT4 gnd 133.72fF
C3176 divbuf_13/OUT3 gnd 34.03fF
C3177 divbuf_13/OUT2 gnd 8.71fF
C3178 divbuf_13/IN gnd 0.89fF
C3179 divbuf_13/a_492_n240# gnd 2.46fF **FLOATING
C3180 divbuf_9/OUT gnd 363.82fF
C3181 divbuf_9/OUT5 gnd 350.37fF
C3182 divbuf_9/OUT4 gnd 133.72fF
C3183 divbuf_9/OUT3 gnd 34.03fF
C3184 divbuf_9/OUT2 gnd 8.71fF
C3185 divbuf_9/IN gnd 0.89fF
C3186 divbuf_9/a_492_n240# gnd 2.46fF **FLOATING
C3187 divbuf_23/OUT gnd 363.82fF
C3188 divbuf_23/OUT5 gnd 350.37fF
C3189 divbuf_23/OUT4 gnd 133.72fF
C3190 divbuf_23/OUT3 gnd 34.03fF
C3191 divbuf_23/OUT2 gnd 8.71fF
C3192 divbuf_23/IN gnd 0.89fF
C3193 divbuf_23/a_492_n240# gnd 2.46fF **FLOATING
C3194 divbuf_12/OUT gnd 363.82fF
C3195 divbuf_12/OUT5 gnd 350.37fF
C3196 divbuf_12/OUT4 gnd 133.72fF
C3197 divbuf_12/OUT3 gnd 34.03fF
C3198 divbuf_12/OUT2 gnd 8.71fF
C3199 divbuf_12/IN gnd 0.89fF
C3200 divbuf_12/a_492_n240# gnd 2.46fF **FLOATING
C3201 divbuf_8/OUT gnd 363.82fF
C3202 divbuf_8/OUT5 gnd 350.37fF
C3203 divbuf_8/OUT4 gnd 133.72fF
C3204 divbuf_8/OUT3 gnd 34.03fF
C3205 divbuf_8/OUT2 gnd 8.71fF
C3206 divbuf_8/IN gnd 0.89fF
C3207 divbuf_8/a_492_n240# gnd 2.46fF **FLOATING
C3208 divbuf_22/OUT gnd 363.82fF
C3209 divbuf_22/OUT5 gnd 350.37fF
C3210 divbuf_22/OUT4 gnd 133.72fF
C3211 divbuf_22/OUT3 gnd 34.03fF
C3212 divbuf_22/OUT2 gnd 8.71fF
C3213 divbuf_22/IN gnd 0.89fF
C3214 divbuf_22/a_492_n240# gnd 2.46fF **FLOATING
C3215 divbuf_11/OUT gnd 363.82fF
C3216 divbuf_11/OUT5 gnd 350.37fF
C3217 divbuf_11/OUT4 gnd 133.72fF
C3218 divbuf_11/OUT3 gnd 34.03fF
C3219 divbuf_11/OUT2 gnd 8.71fF
C3220 divbuf_11/IN gnd 0.89fF
C3221 divbuf_11/a_492_n240# gnd 2.46fF **FLOATING
C3222 divbuf_7/OUT5 gnd 350.37fF
C3223 divbuf_7/OUT4 gnd 133.72fF
C3224 divbuf_7/OUT3 gnd 34.03fF
C3225 divbuf_7/OUT2 gnd 8.71fF
C3226 divbuf_7/IN gnd 0.89fF
C3227 divbuf_7/a_492_n240# gnd 2.46fF **FLOATING
C3228 divbuf_21/OUT gnd 363.82fF
C3229 divbuf_21/OUT5 gnd 350.37fF
C3230 divbuf_21/OUT4 gnd 133.72fF
C3231 divbuf_21/OUT3 gnd 34.03fF
C3232 divbuf_21/OUT2 gnd 8.71fF
C3233 divbuf_21/IN gnd 0.89fF
C3234 divbuf_21/a_492_n240# gnd 2.46fF **FLOATING
C3235 divbuf_20/OUT gnd 363.82fF
C3236 divbuf_20/OUT5 gnd 350.37fF
C3237 divbuf_20/OUT4 gnd 133.72fF
C3238 divbuf_20/OUT3 gnd 34.03fF
C3239 divbuf_20/OUT2 gnd 8.71fF
C3240 divbuf_20/IN gnd 0.89fF
C3241 divbuf_20/a_492_n240# gnd 2.46fF **FLOATING
C3242 divbuf_10/OUT gnd 363.82fF
C3243 divbuf_10/OUT5 gnd 350.37fF
C3244 divbuf_10/OUT4 gnd 133.72fF
C3245 divbuf_10/OUT3 gnd 34.03fF
C3246 divbuf_10/OUT2 gnd 8.71fF
C3247 divbuf_10/IN gnd 0.89fF
C3248 divbuf_10/a_492_n240# gnd 2.46fF **FLOATING
C3249 divbuf_6/OUT5 gnd 350.37fF
C3250 divbuf_6/OUT4 gnd 133.72fF
C3251 divbuf_6/OUT3 gnd 34.03fF
C3252 divbuf_6/OUT2 gnd 8.71fF
C3253 divbuf_6/IN gnd 0.89fF
C3254 divbuf_6/a_492_n240# gnd 2.46fF **FLOATING
C3255 divbuf_5/OUT5 gnd 350.37fF
C3256 divbuf_5/OUT4 gnd 133.72fF
C3257 divbuf_5/OUT3 gnd 34.03fF
C3258 divbuf_5/OUT2 gnd 8.71fF
C3259 divbuf_5/IN gnd 0.89fF
C3260 divbuf_5/a_492_n240# gnd 2.46fF **FLOATING
C3261 divbuf_4/OUT5 gnd 350.37fF
C3262 divbuf_4/OUT4 gnd 133.72fF
C3263 divbuf_4/OUT3 gnd 34.03fF
C3264 divbuf_4/OUT2 gnd 8.71fF
C3265 divbuf_4/IN gnd 0.89fF
C3266 divbuf_4/a_492_n240# gnd 2.46fF **FLOATING
C3267 divbuf_3/OUT5 gnd 350.37fF
C3268 divbuf_3/OUT4 gnd 133.72fF
C3269 divbuf_3/OUT3 gnd 34.03fF
C3270 divbuf_3/OUT2 gnd 8.71fF
C3271 divbuf_3/IN gnd 0.89fF
C3272 divbuf_3/a_492_n240# gnd 2.46fF **FLOATING
C3273 divbuf_2/OUT5 gnd 350.37fF
C3274 divbuf_2/OUT4 gnd 133.72fF
C3275 divbuf_2/OUT3 gnd 34.03fF
C3276 divbuf_2/OUT2 gnd 8.71fF
C3277 divbuf_2/IN gnd 0.89fF
C3278 divbuf_2/a_492_n240# gnd 2.46fF **FLOATING
C3279 divbuf_1/OUT gnd 363.82fF
C3280 divbuf_1/OUT5 gnd 350.37fF
C3281 divbuf_1/OUT4 gnd 133.72fF
C3282 divbuf_1/OUT3 gnd 34.03fF
C3283 divbuf_1/OUT2 gnd 8.71fF
C3284 divbuf_1/IN gnd 0.89fF
C3285 divbuf_1/a_492_n240# gnd 2.46fF **FLOATING
C3286 ro_complete_1/cbank_2/v gnd 16.43fF
C3287 ro_complete_1/cbank_2/switch_5/vin gnd 0.78fF
C3288 ro_complete_1/cbank_2/switch_4/vin gnd 1.50fF
C3289 ro_complete_1/cbank_2/switch_2/vin gnd 1.30fF
C3290 ro_complete_1/cbank_2/switch_3/vin gnd 0.56fF
C3291 ro_complete_1/cbank_2/switch_1/vin gnd 1.14fF
C3292 ro_complete_1/cbank_2/switch_0/vin gnd 1.02fF
C3293 ro_complete_1/cbank_1/v gnd 16.43fF
C3294 ro_complete_1/cbank_1/switch_5/vin gnd 0.78fF
C3295 ro_complete_1/a0 gnd 5.35fF
C3296 ro_complete_1/cbank_1/switch_4/vin gnd 1.50fF
C3297 ro_complete_1/a1 gnd 6.54fF
C3298 ro_complete_1/cbank_1/switch_2/vin gnd 1.30fF
C3299 ro_complete_1/a3 gnd 5.96fF
C3300 ro_complete_1/cbank_1/switch_3/vin gnd 0.56fF
C3301 ro_complete_1/a2 gnd 5.21fF
C3302 ro_complete_1/cbank_1/switch_1/vin gnd 1.14fF
C3303 ro_complete_1/a4 gnd 5.81fF
C3304 ro_complete_1/cbank_1/switch_0/vin gnd 1.02fF
C3305 ro_complete_1/a5 gnd 6.74fF
C3306 ro_complete_1/cbank_0/v gnd 15.12fF
C3307 ro_complete_1/cbank_0/switch_5/vin gnd 0.78fF
C3308 ro_complete_1/cbank_0/switch_4/vin gnd 1.50fF
C3309 ro_complete_1/cbank_0/switch_2/vin gnd 1.30fF
C3310 ro_complete_1/cbank_0/switch_3/vin gnd 0.56fF
C3311 ro_complete_1/cbank_0/switch_1/vin gnd 1.14fF
C3312 ro_complete_1/cbank_0/switch_0/vin gnd 1.02fF
C3313 ro_complete_1/ro_var_extend_0/vcont gnd 0.27fF
C3314 divbuf_0/OUT gnd 363.82fF
C3315 divbuf_0/OUT5 gnd 350.37fF
C3316 divbuf_0/OUT4 gnd 133.72fF
C3317 divbuf_0/OUT3 gnd 34.03fF
C3318 divbuf_0/OUT2 gnd 8.71fF
C3319 divbuf_0/IN gnd 0.89fF
C3320 divbuf_0/a_492_n240# gnd 2.46fF **FLOATING
C3321 ro_complete_0/cbank_2/v gnd 16.43fF
C3322 ro_complete_0/cbank_2/switch_5/vin gnd 0.78fF
C3323 ro_complete_0/cbank_2/switch_4/vin gnd 1.50fF
C3324 ro_complete_0/cbank_2/switch_2/vin gnd 1.30fF
C3325 ro_complete_0/cbank_2/switch_3/vin gnd 0.56fF
C3326 ro_complete_0/cbank_2/switch_1/vin gnd 1.14fF
C3327 ro_complete_0/cbank_2/switch_0/vin gnd 1.02fF
C3328 ro_complete_0/cbank_1/v gnd 16.46fF
C3329 ro_complete_0/cbank_1/switch_5/vin gnd 0.78fF
C3330 divbuf_7/OUT gnd 405.76fF
C3331 ro_complete_0/cbank_1/switch_4/vin gnd 1.50fF
C3332 divbuf_6/OUT gnd 402.77fF
C3333 ro_complete_0/cbank_1/switch_2/vin gnd 1.30fF
C3334 divbuf_3/OUT gnd 394.74fF
C3335 ro_complete_0/cbank_1/switch_3/vin gnd 0.56fF
C3336 divbuf_5/OUT gnd 397.92fF
C3337 ro_complete_0/cbank_1/switch_1/vin gnd 1.14fF
C3338 divbuf_4/OUT gnd 391.26fF
C3339 ro_complete_0/cbank_1/switch_0/vin gnd 1.02fF
C3340 divbuf_2/OUT gnd 387.66fF
C3341 ro_complete_0/cbank_0/v gnd 15.12fF
C3342 ro_complete_0/cbank_0/switch_5/vin gnd 0.78fF
C3343 ro_complete_0/cbank_0/switch_4/vin gnd 1.50fF
C3344 ro_complete_0/cbank_0/switch_2/vin gnd 1.30fF
C3345 ro_complete_0/cbank_0/switch_3/vin gnd 0.56fF
C3346 ro_complete_0/cbank_0/switch_1/vin gnd 1.14fF
C3347 ro_complete_0/cbank_0/switch_0/vin gnd 1.02fF
C3348 ro_complete_0/ro_var_extend_0/vcont gnd 0.27fF
C3349 filter_0/v gnd 477.90fF
C3350 filter_0/a_4216_n5230# gnd 418.47fF **FLOATING
C3351 filter_0/a_4216_n2998# gnd 1.03fF **FLOATING
C3352 cp_0/down gnd 1.54fF
C3353 cp_0/vbias gnd 2.41fF
C3354 cp_0/out gnd 5.34fF
C3355 cp_0/upbar gnd 1.50fF
C3356 cp_0/a_7110_n2840# gnd 0.17fF **FLOATING
C3357 cp_0/a_3060_n2840# gnd 1.71fF **FLOATING
C3358 cp_0/a_7110_0# gnd 0.17fF **FLOATING
C3359 cp_0/a_6370_0# gnd 0.40fF **FLOATING
C3360 cp_0/a_3060_0# gnd 1.66fF **FLOATING
C3361 cp_0/a_1710_0# gnd 5.89fF **FLOATING
C3362 cp_0/a_1710_n2840# gnd 4.91fF **FLOATING
C3363 cp_0/a_10_n50# gnd 2.96fF **FLOATING
C3364 pd_1/UP gnd 2.21fF
C3365 pd_1/and_pd_0/Z1 gnd 0.39fF
C3366 pd_1/and_pd_0/Out1 gnd 2.22fF
C3367 pd_1/tspc_r_1/z5 gnd 1.10fF
C3368 pd_1/tspc_r_1/Z4 gnd 1.07fF
C3369 pd_1/tspc_r_1/Qbar gnd 0.88fF
C3370 pd_1/tspc_r_1/Z2 gnd 1.22fF
C3371 pd_1/tspc_r_1/Z1 gnd 0.67fF
C3372 pd_1/tspc_r_1/Qbar1 gnd 1.34fF
C3373 pd_1/tspc_r_1/Z3 gnd 2.12fF
C3374 pd_1/REF gnd 1.80fF
C3375 pd_1/tspc_r_0/z5 gnd 1.10fF
C3376 pd_1/tspc_r_0/Z4 gnd 1.07fF
C3377 pd_1/R gnd 3.05fF
C3378 pd_1/tspc_r_0/Qbar gnd 0.79fF
C3379 pd_1/tspc_r_0/Z2 gnd 1.22fF
C3380 pd_1/tspc_r_0/Z1 gnd 0.67fF
C3381 pd_1/DOWN gnd 3.08fF
C3382 pd_1/tspc_r_0/Qbar1 gnd 1.34fF
C3383 pd_1/tspc_r_0/Z3 gnd 2.12fF
C3384 pd_1/DIV gnd 1.82fF
C3385 pd_0/UP gnd 2.21fF
C3386 pd_0/and_pd_0/Z1 gnd 0.39fF
C3387 pd_0/and_pd_0/Out1 gnd 2.22fF
C3388 pd_0/tspc_r_1/z5 gnd 1.10fF
C3389 pd_0/tspc_r_1/Z4 gnd 1.07fF
C3390 pd_0/tspc_r_1/Qbar gnd 0.88fF
C3391 pd_0/tspc_r_1/Z2 gnd 1.22fF
C3392 pd_0/tspc_r_1/Z1 gnd 0.67fF
C3393 pd_0/tspc_r_1/Qbar1 gnd 1.34fF
C3394 pd_0/tspc_r_1/Z3 gnd 2.12fF
C3395 pd_0/REF gnd 1.80fF
C3396 pd_0/tspc_r_0/z5 gnd 1.10fF
C3397 pd_0/tspc_r_0/Z4 gnd 1.07fF
C3398 pd_0/R gnd 3.05fF
C3399 pd_0/tspc_r_0/Qbar gnd 0.79fF
C3400 pd_0/tspc_r_0/Z2 gnd 1.22fF
C3401 pd_0/tspc_r_0/Z1 gnd 0.67fF
C3402 pd_0/DOWN gnd 3.08fF
C3403 pd_0/tspc_r_0/Qbar1 gnd 1.34fF
C3404 pd_0/tspc_r_0/Z3 gnd 2.12fF
C3405 pd_0/DIV gnd 1.82fF
.ends
