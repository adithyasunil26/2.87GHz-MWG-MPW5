* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[5] io_analog[6] io_analog[7]
+ io_analog[8] io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
C0 divider_0/nor_1/A divider_0/tspc_0/Q 0.55fF
C1 divider_0/tspc_0/Z1 divider_0/tspc_0/Z3 0.06fF
C2 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/z5 0.20fF
C3 ro_complete_0/a4 ro_complete_0/cbank_2/v 0.05fF
C4 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/v 1.30fF
C5 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z3 0.16fF
C6 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z3 0.06fF
C7 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C8 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_2/D 0.32fF
C9 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/clk 0.01fF
C10 divider_0/nor_1/B divider_0/tspc_1/Z2 0.30fF
C11 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Q 0.04fF
C12 divbuf_0/OUT5 divbuf_0/OUT4 20.26fF
C13 pll_full_0/cp_0/upbar pll_full_0/cp_0/down 0.02fF
C14 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Qbar 0.01fF
C15 divbuf_3/a_492_n240# divbuf_3/IN 0.13fF
C16 ro_complete_0/cbank_2/switch_2/vin ro_complete_0/cbank_2/v 1.30fF
C17 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/Z3 0.45fF
C18 divbuf_7/a_492_n240# divbuf_7/OUT 0.00fF
C19 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z4 0.12fF
C20 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z2 1.07fF
C21 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C22 pd_0/tspc_r_1/Z4 pd_0/tspc_r_1/z5 0.04fF
C23 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z2 0.01fF
C24 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/a1 0.14fF
C25 pll_full_0/ro_complete_0/a0 pll_full_0/divider_0/clk 0.01fF
C26 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z4 0.08fF
C27 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z3 0.05fF
C28 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Q 0.04fF
C29 divbuf_1/OUT2 divbuf_1/OUT 0.06fF
C30 divbuf_1/OUT3 divbuf_1/OUT5 0.01fF
C31 pll_full_0/pd_0/DOWN pll_full_0/pd_0/R 0.36fF
C32 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/tspc_r_0/Z2 0.71fF
C33 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Qbar1 0.12fF
C34 divider_0/and_0/out1 divider_0/and_0/Z1 0.36fF
C35 ro_complete_0/a5 ro_complete_0/cbank_2/switch_0/vin 0.09fF
C36 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C37 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a4 0.09fF
C38 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a5 0.09fF
C39 divbuf_5/OUT2 divbuf_5/OUT3 1.37fF
C40 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C41 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C42 divider_0/prescaler_0/tspc_2/Z4 divider_0/prescaler_0/tspc_2/D 0.11fF
C43 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/Out 0.08fF
C44 divider_0/tspc_0/Q divider_0/nor_1/B 0.22fF
C45 pd_0/tspc_r_0/Z2 pd_0/tspc_r_0/Z4 0.14fF
C46 divbuf_1/OUT divbuf_1/a_492_n240# 0.00fF
C47 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT2 0.06fF
C48 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT3 0.01fF
C49 ro_complete_0/a1 ro_complete_0/cbank_2/v 0.05fF
C50 divbuf_6/OUT5 divbuf_6/OUT 43.38fF
C51 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C52 divider_0/nor_1/B divider_0/tspc_2/Z2 0.20fF
C53 divider_0/tspc_1/Q divider_0/tspc_2/a_630_n680# 0.01fF
C54 cp_0/a_1710_0# cp_0/out 0.84fF
C55 pd_0/R pd_0/and_pd_0/Out1 0.33fF
C56 pd_0/REF pd_0/tspc_r_1/Z4 0.02fF
C57 pd_0/UP pd_0/tspc_r_1/Qbar 0.21fF
C58 divbuf_0/OUT5 divbuf_0/a_492_n240# 0.01fF
C59 pll_full_0/ro_complete_0/a3 pll_full_0/divider_0/clk 0.11fF
C60 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z1 0.03fF
C61 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z3 0.05fF
C62 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Q 0.04fF
C63 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/a_492_n240# 0.00fF
C64 pll_full_0/pd_0/DOWN pll_full_0/cp_0/a_1710_0# 0.04fF
C65 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/R 0.33fF
C66 ro_complete_0/a2 ro_complete_0/cbank_1/v 0.05fF
C67 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/a0 0.13fF
C68 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C69 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/B 0.18fF
C70 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z3 0.16fF
C71 divider_0/prescaler_0/tspc_0/Z2 divider_0/clk 0.11fF
C72 pd_0/DIV pd_0/tspc_r_0/Z1 0.17fF
C73 pd_0/tspc_r_0/Qbar1 pd_0/DOWN 0.11fF
C74 divider_0/tspc_0/Z1 divider_0/tspc_0/Z4 0.00fF
C75 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/v 1.45fF
C76 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C77 divbuf_6/a_492_n240# divbuf_6/OUT2 0.42fF
C78 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z4 0.36fF
C79 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C80 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C81 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/Out 0.11fF
C82 divider_0/prescaler_0/tspc_0/Q divider_0/prescaler_0/tspc_2/D 0.04fF
C83 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/nand_1/z1 0.22fF
C84 pd_0/R pd_0/tspc_r_1/Z2 0.21fF
C85 divider_0/nor_1/B divider_0/tspc_1/Q 0.51fF
C86 divider_0/tspc_1/Z1 divider_0/tspc_1/Z3 0.06fF
C87 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z4 0.20fF
C88 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C89 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/pd_0/tspc_r_1/Z2 0.71fF
C90 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/switch_5/vin 0.20fF
C91 divbuf_7/IN divbuf_7/OUT5 0.00fF
C92 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z3 0.16fF
C93 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/Z3 0.38fF
C94 pd_0/UP pd_0/and_pd_0/Z1 0.06fF
C95 divider_0/nor_0/B divider_0/tspc_2/Z2 0.40fF
C96 divider_0/tspc_2/a_630_n680# divider_0/Out 0.04fF
C97 ro_complete_0/a4 ro_complete_0/cbank_2/switch_1/vin 0.09fF
C98 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/v 1.30fF
C99 divbuf_4/a_492_n240# divbuf_4/OUT 0.00fF
C100 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C101 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.20fF
C102 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/nor_1/A 1.21fF
C103 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z4 0.12fF
C104 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z2 1.07fF
C105 divbuf_1/OUT4 divbuf_1/OUT 1.11fF
C106 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z2 0.19fF
C107 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C108 divbuf_5/OUT2 divbuf_5/OUT5 0.02fF
C109 divbuf_5/OUT3 divbuf_5/OUT4 5.16fF
C110 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/Out 0.11fF
C111 divider_0/prescaler_0/tspc_1/Z2 divider_0/clk 0.11fF
C112 divider_0/tspc_0/Q divider_0/tspc_1/Z2 0.14fF
C113 divbuf_0/OUT5 divbuf_0/OUT 43.38fF
C114 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT4 1.11fF
C115 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar 0.03fF
C116 ro_complete_0/cbank_1/switch_5/vin ro_complete_0/cbank_1/v 1.30fF
C117 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C118 divider_0/prescaler_0/Out divider_0/tspc_0/a_630_n680# 0.01fF
C119 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C120 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/Out 0.21fF
C121 cp_0/a_1710_0# cp_0/down 0.32fF
C122 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/z5 0.11fF
C123 divider_0/tspc_1/Q divider_0/nor_0/B 0.22fF
C124 io_clamp_low[2] io_analog[6] 0.53fF
C125 ro_complete_0/a4 ro_complete_0/cbank_1/switch_1/vin 0.09fF
C126 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Z2 0.30fF
C127 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C128 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/B 0.78fF
C129 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z3 0.38fF
C130 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z4 0.12fF
C131 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z2 1.07fF
C132 divider_0/prescaler_0/Out divider_0/clk 0.51fF
C133 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C134 pll_full_0/pd_0/DIV pll_full_0/divider_0/clk 2.26fF
C135 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C136 divider_0/tspc_0/Z3 divider_0/tspc_0/Z4 0.65fF
C137 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z2 0.25fF
C138 ro_complete_0/a5 ro_complete_0/cbank_2/v 0.08fF
C139 ro_complete_0/a0 ro_complete_0/cbank_1/switch_5/vin 0.09fF
C140 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C141 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C142 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_0/B 0.22fF
C143 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C144 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C145 divider_0/prescaler_0/tspc_0/Q divider_0/prescaler_0/nand_1/z1 0.01fF
C146 divider_0/prescaler_0/tspc_2/Z2 divider_0/clk 0.11fF
C147 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/Out 0.05fF
C148 divider_0/tspc_1/Z1 divider_0/tspc_1/Z4 0.00fF
C149 pd_0/REF pd_0/tspc_r_1/Z3 0.65fF
C150 divbuf_0/OUT5 divbuf_0/IN 0.00fF
C151 divbuf_0/OUT2 divbuf_0/OUT3 1.37fF
C152 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C153 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/z5 0.20fF
C154 divbuf_3/a_492_n240# divbuf_3/OUT5 0.01fF
C155 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/v 1.30fF
C156 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C157 divider_0/and_0/OUT divider_0/and_0/B 0.01fF
C158 divbuf_7/OUT2 divbuf_7/OUT 0.06fF
C159 divbuf_7/OUT3 divbuf_7/OUT5 0.01fF
C160 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Z1 0.03fF
C161 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/a_630_n680# 0.12fF
C162 pll_full_0/ro_complete_0/a4 pll_full_0/divider_0/clk 0.11fF
C163 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/out1 0.31fF
C164 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/and_0/A 0.01fF
C165 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z4 0.36fF
C166 divider_0/nor_0/B divider_0/Out 0.22fF
C167 divider_0/tspc_2/Z1 divider_0/tspc_2/Z3 0.06fF
C168 cp_0/a_1710_n2840# cp_0/out 0.61fF
C169 divbuf_2/OUT3 divbuf_2/OUT5 0.01fF
C170 divider_0/mc2 divider_0/and_0/out1 0.06fF
C171 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C172 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/nor_1/A 0.01fF
C173 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Z4 0.21fF
C174 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z3 0.16fF
C175 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.15fF
C176 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/B 0.29fF
C177 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C178 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z3 0.16fF
C179 pll_full_0/pd_0/DIV pll_full_0/pd_0/R 0.51fF
C180 divbuf_2/OUT3 divbuf_2/OUT 0.26fF
C181 divbuf_5/OUT3 divbuf_5/OUT 0.26fF
C182 divbuf_5/OUT4 divbuf_5/OUT5 20.26fF
C183 divider_0/prescaler_0/tspc_1/Z4 divider_0/prescaler_0/Out 0.28fF
C184 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Qbar1 0.12fF
C185 divider_0/mc2 divider_0/nor_1/A 0.04fF
C186 ro_complete_0/cbank_0/v ro_complete_0/cbank_2/v 0.04fF
C187 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C188 divider_0/prescaler_0/Out divider_0/nor_1/A 0.15fF
C189 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C190 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/Out 0.04fF
C191 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/Out 0.91fF
C192 pd_0/UP pd_0/tspc_r_1/z5 0.03fF
C193 pll_full_0/divbuf_1/OUT5 pll_full_0/pd_0/REF 0.00fF
C194 divider_0/tspc_1/Q divider_0/tspc_2/Z2 0.14fF
C195 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C196 divider_0/nor_1/Z1 divider_0/nor_1/B 0.06fF
C197 pll_full_0/pd_0/DIV pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C198 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT3 1.37fF
C199 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C200 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Q 0.51fF
C201 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z3 0.06fF
C202 pll_full_0/ro_complete_0/a1 pll_full_0/divider_0/clk 0.11fF
C203 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C204 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z4 0.22fF
C205 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z3 0.16fF
C206 divider_0/nor_1/Z1 divider_0/and_0/A 0.80fF
C207 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Z4 0.65fF
C208 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C209 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C210 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/Qbar 0.01fF
C211 pd_0/tspc_r_0/Z3 pd_0/R 0.27fF
C212 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C213 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C214 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C215 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/a3 0.09fF
C216 ro_complete_0/a0 ro_complete_0/cbank_1/v 0.05fF
C217 divbuf_6/a_492_n240# divbuf_6/OUT 0.00fF
C218 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/B 0.31fF
C219 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z2 0.14fF
C220 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C221 divider_0/prescaler_0/tspc_2/D divider_0/prescaler_0/nand_1/z1 0.21fF
C222 cp_0/upbar cp_0/a_1710_n2840# 0.29fF
C223 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Qbar1 0.38fF
C224 divider_0/tspc_1/Z3 divider_0/tspc_1/Z4 0.65fF
C225 divider_0/mc2 divider_0/nor_1/B 0.06fF
C226 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C227 divbuf_3/OUT2 divbuf_3/OUT3 1.37fF
C228 ro_complete_0/cbank_2/switch_0/vin ro_complete_0/cbank_2/v 1.44fF
C229 divbuf_7/OUT4 divbuf_7/OUT 1.11fF
C230 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/clk 0.05fF
C231 divbuf_1/OUT2 divbuf_1/OUT3 1.37fF
C232 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Z1 0.02fF
C233 divider_0/tspc_2/Z1 divider_0/tspc_2/Z4 0.00fF
C234 ro_complete_0/a2 ro_complete_0/cbank_2/switch_2/vin 0.14fF
C235 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/v 1.30fF
C236 divider_0/mc2 divider_0/and_0/A 0.16fF
C237 divbuf_4/OUT2 divbuf_4/OUT3 1.37fF
C238 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Q 0.05fF
C239 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C240 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z4 0.36fF
C241 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z4 0.02fF
C242 divbuf_2/OUT5 divbuf_2/OUT 43.38fF
C243 ro_complete_0/a3 ro_complete_0/cbank_1/v 0.05fF
C244 divbuf_5/OUT5 divbuf_5/OUT 43.38fF
C245 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z2 0.01fF
C246 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_2/Z4 0.02fF
C247 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/UP 0.03fF
C248 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C249 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C250 divider_0/prescaler_0/Out divider_0/tspc_0/Z2 0.11fF
C251 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C252 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/IN 0.00fF
C253 divbuf_7/a_492_n240# divbuf_7/IN 0.13fF
C254 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z3 0.05fF
C255 io_clamp_low[2] io_clamp_high[2] 0.53fF
C256 cp_0/a_10_n50# cp_0/vbias 0.19fF
C257 pd_0/tspc_r_1/Z2 pd_0/tspc_r_1/Z4 0.14fF
C258 io_clamp_high[1] io_analog[5] 0.53fF
C259 divbuf_0/OUT2 divbuf_0/a_492_n240# 0.42fF
C260 divider_0/mc2 divider_0/nor_0/B 0.15fF
C261 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/v 1.30fF
C262 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT4 5.16fF
C263 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C264 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C265 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C266 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z4 0.36fF
C267 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divbuf_0/IN 0.05fF
C268 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/Z3 0.03fF
C269 divbuf_5/a_492_n240# divbuf_5/OUT2 0.42fF
C270 pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C271 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/Out 0.11fF
C272 pll_full_0/divider_0/and_0/A pll_full_0/divider_0/and_0/B 0.18fF
C273 pd_0/DOWN pd_0/R 0.36fF
C274 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z4 0.20fF
C275 pd_0/DIV pd_0/tspc_r_0/z5 0.04fF
C276 pd_0/tspc_r_0/Z1 pd_0/tspc_r_0/Z2 0.71fF
C277 pll_full_0/pd_0/R pll_full_0/pd_0/REF 0.61fF
C278 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C279 divbuf_6/IN divbuf_6/OUT5 0.00fF
C280 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_1/B 0.06fF
C281 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C282 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/Out 0.19fF
C283 pd_0/tspc_r_0/Z4 pd_0/tspc_r_1/Z4 0.02fF
C284 pd_0/DOWN pd_0/and_pd_0/Out1 0.12fF
C285 pd_0/REF pd_0/tspc_r_1/Z1 0.17fF
C286 pd_0/tspc_r_1/Qbar1 pd_0/UP 0.11fF
C287 divbuf_2/a_492_n240# divbuf_2/OUT5 0.01fF
C288 divbuf_0/OUT3 divbuf_0/OUT4 5.16fF
C289 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C290 divbuf_3/OUT2 divbuf_3/OUT5 0.02fF
C291 divbuf_3/OUT3 divbuf_3/OUT4 5.16fF
C292 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C293 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z2 0.01fF
C294 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/IN 0.13fF
C295 pll_full_0/ro_complete_0/a5 pll_full_0/divider_0/clk 0.15fF
C296 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/clk 0.26fF
C297 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C298 divbuf_1/OUT3 divbuf_1/OUT4 5.16fF
C299 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/pd_0/UP 0.06fF
C300 divider_0/tspc_2/Z3 divider_0/tspc_2/Z4 0.65fF
C301 divbuf_2/a_492_n240# divbuf_2/OUT 0.00fF
C302 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_5/vin 0.20fF
C303 divbuf_4/OUT2 divbuf_4/OUT5 0.02fF
C304 divbuf_4/OUT3 divbuf_4/OUT4 5.16fF
C305 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/IN 5.26fF
C306 pll_full_0/ro_complete_0/a1 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C307 divider_0/mc2 divider_0/prescaler_0/tspc_0/a_630_n680# 0.33fF
C308 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C309 divider_0/nor_1/A divider_0/tspc_0/Z1 0.03fF
C310 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z3 0.05fF
C311 filter_0/a_4216_n2998# filter_0/v 0.31fF
C312 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/R 0.01fF
C313 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_0/vin 0.19fF
C314 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/v 1.30fF
C315 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/clk 0.45fF
C316 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/Out 0.21fF
C317 pd_0/R pd_0/tspc_r_1/Z3 0.29fF
C318 divbuf_0/OUT divbuf_0/OUT2 0.06fF
C319 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z1 0.09fF
C320 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z2 0.19fF
C321 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/a0 0.13fF
C322 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C323 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/divider_0/clk 1.32fF
C324 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C325 divbuf_1/OUT5 divbuf_1/IN 0.00fF
C326 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_4/vin 0.20fF
C327 io_clamp_low[0] io_analog[4] 0.53fF
C328 divbuf_4/a_492_n240# divbuf_4/IN 0.13fF
C329 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z4 0.12fF
C330 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C331 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/divider_0/clk 1.27fF
C332 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/tspc_r_0/Z3 0.09fF
C333 divider_0/and_0/out1 divider_0/and_0/B 0.18fF
C334 ro_complete_0/a4 ro_complete_0/cbank_1/v 0.05fF
C335 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C336 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C337 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/A 0.80fF
C338 divider_0/and_0/OUT divider_0/prescaler_0/tspc_0/D 0.03fF
C339 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/D 0.09fF
C340 cp_0/a_1710_0# cp_0/a_10_n50# 0.04fF
C341 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/z5 0.20fF
C342 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar1 0.30fF
C343 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C344 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C345 pll_full_0/filter_0/a_4216_n5230# pll_full_0/divider_0/clk 1.58fF
C346 divbuf_6/OUT2 divbuf_6/OUT 0.06fF
C347 divbuf_6/OUT3 divbuf_6/OUT5 0.01fF
C348 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C349 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/clk 0.45fF
C350 pd_0/tspc_r_0/z5 pd_0/tspc_r_1/z5 0.02fF
C351 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z2 0.25fF
C352 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/pd_0/DOWN 0.07fF
C353 divider_0/nor_1/A divider_0/and_0/B 0.08fF
C354 pll_full_0/pd_0/REF pll_full_0/divbuf_1/a_492_n240# 0.13fF
C355 divbuf_3/OUT3 divbuf_3/OUT 0.26fF
C356 divbuf_3/OUT4 divbuf_3/OUT5 20.26fF
C357 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C358 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Q 0.04fF
C359 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/nor_1/A 0.55fF
C360 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/D 0.15fF
C361 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/nor_0/B 0.35fF
C362 ro_complete_0/a5 ro_complete_0/cbank_1/switch_0/vin 0.09fF
C363 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/v 1.30fF
C364 divider_0/nor_0/Z1 divider_0/and_0/B 0.78fF
C365 divbuf_4/OUT3 divbuf_4/OUT 0.26fF
C366 divbuf_4/OUT4 divbuf_4/OUT5 20.26fF
C367 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/and_0/OUT 0.14fF
C368 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_0/Z2 0.11fF
C369 divider_0/nor_1/A divider_0/tspc_0/Z3 0.38fF
C370 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z4 0.12fF
C371 divider_0/tspc_0/Z1 divider_0/tspc_0/Z2 1.07fF
C372 pd_0/DIV pd_0/tspc_r_0/Qbar1 0.12fF
C373 filter_0/a_4216_n5230# filter_0/v 0.19fF
C374 pll_full_0/pd_0/DOWN pll_full_0/pd_0/UP 4.58fF
C375 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/R 0.21fF
C376 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/z5 0.11fF
C377 ro_complete_0/a1 ro_complete_0/cbank_1/v 0.05fF
C378 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C379 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z2 1.07fF
C380 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/clk 0.12fF
C381 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z3 0.06fF
C382 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/Out 0.04fF
C383 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/pd_0/and_pd_0/Out1 0.18fF
C384 divider_0/nor_1/B divider_0/tspc_1/Z1 0.03fF
C385 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z3 0.05fF
C386 pd_0/R pd_0/UP 0.45fF
C387 divbuf_0/OUT divbuf_0/OUT3 0.26fF
C388 ro_complete_0/a2 ro_complete_0/cbank_1/switch_3/vin 0.09fF
C389 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C390 divbuf_7/a_492_n240# divbuf_7/OUT5 0.01fF
C391 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/Z2 0.14fF
C392 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_0/B 0.06fF
C393 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/prescaler_0/Out 0.15fF
C394 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/clk 0.64fF
C395 io_clamp_low[1] io_clamp_high[1] 0.53fF
C396 divider_0/nor_1/B divider_0/and_0/B 0.31fF
C397 pd_0/UP pd_0/and_pd_0/Out1 0.33fF
C398 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/v 0.08fF
C399 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C400 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/nor_1/A 0.03fF
C401 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C402 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z2 0.01fF
C403 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/UP 0.33fF
C404 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/Qbar 0.21fF
C405 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z3 0.65fF
C406 divider_0/and_0/A divider_0/and_0/B 0.18fF
C407 divbuf_1/OUT2 divbuf_1/OUT5 0.02fF
C408 ro_complete_0/a3 ro_complete_0/cbank_2/switch_2/vin 0.09fF
C409 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT4 5.16fF
C410 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C411 divbuf_5/a_492_n240# divbuf_5/OUT 0.00fF
C412 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C413 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z3 0.65fF
C414 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C415 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C416 pll_full_0/divider_0/and_0/B pll_full_0/divider_0/and_0/Z1 0.07fF
C417 divider_0/and_0/OUT divider_0/prescaler_0/nand_0/z1 0.01fF
C418 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT2 0.02fF
C419 divbuf_1/OUT5 divbuf_1/a_492_n240# 0.01fF
C420 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/v 1.30fF
C421 divbuf_6/OUT4 divbuf_6/OUT 1.11fF
C422 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/Z1 0.01fF
C423 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/clk 0.12fF
C424 divider_0/and_0/OUT divider_0/clk 0.04fF
C425 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/Qbar 0.01fF
C426 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C427 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_4/vin 0.20fF
C428 divbuf_3/OUT5 divbuf_3/OUT 43.38fF
C429 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/Z4 0.15fF
C430 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/D 0.05fF
C431 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z2 0.01fF
C432 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/clk 0.60fF
C433 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/a_492_n240# 0.01fF
C434 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/pd_0/tspc_r_1/Qbar 0.02fF
C435 divider_0/nor_0/B divider_0/and_0/B 0.29fF
C436 divbuf_4/OUT5 divbuf_4/OUT 43.38fF
C437 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_1/B 0.18fF
C438 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/ro_complete_0/cbank_2/v 0.04fF
C439 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_0/D 0.16fF
C440 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.05fF
C441 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/A 0.01fF
C442 pd_0/tspc_r_0/Z3 pd_0/DOWN 0.03fF
C443 divider_0/nor_1/A divider_0/tspc_0/Z4 0.21fF
C444 divider_0/tspc_0/Z2 divider_0/tspc_0/Z3 0.16fF
C445 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z4 0.14fF
C446 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C447 divbuf_6/a_492_n240# divbuf_6/IN 0.13fF
C448 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z4 0.00fF
C449 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C450 divider_0/nor_1/B divider_0/tspc_1/Z3 0.38fF
C451 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z4 0.12fF
C452 divider_0/tspc_1/Z1 divider_0/tspc_1/Z2 1.07fF
C453 divbuf_0/OUT divbuf_0/OUT4 1.11fF
C454 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/a4 0.12fF
C455 ro_complete_0/a2 ro_complete_0/cbank_0/switch_3/vin 0.09fF
C456 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C457 pll_full_0/pd_0/UP pll_full_0/pd_0/tspc_r_1/Qbar 0.21fF
C458 divbuf_3/a_492_n240# divbuf_3/OUT2 0.42fF
C459 divider_0/and_0/OUT divider_0/and_0/out1 0.31fF
C460 divbuf_7/OUT2 divbuf_7/OUT3 1.37fF
C461 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z3 0.06fF
C462 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/Z2 0.23fF
C463 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/clk 0.12fF
C464 cp_0/upbar cp_0/down 0.02fF
C465 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/DOWN 0.12fF
C466 divider_0/nor_0/B divider_0/tspc_2/Z1 0.03fF
C467 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z3 0.05fF
C468 divbuf_2/OUT2 divbuf_2/OUT3 1.37fF
C469 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C470 divbuf_4/a_492_n240# divbuf_4/OUT5 0.01fF
C471 divbuf_1/OUT3 divbuf_1/OUT 0.26fF
C472 divbuf_1/OUT4 divbuf_1/OUT5 20.26fF
C473 divbuf_2/OUT5 divbuf_2/IN 0.00fF
C474 ro_complete_0/a5 ro_complete_0/cbank_1/v 0.10fF
C475 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/a0 0.09fF
C476 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT5 0.01fF
C477 pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_0/ro_complete_0/cbank_2/v 1.44fF
C478 divbuf_5/IN divbuf_5/OUT5 0.00fF
C479 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/nor_0/B 0.47fF
C480 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C481 pll_full_0/ro_complete_0/cbank_2/v pll_full_0/divider_0/clk 1.36fF
C482 divider_0/prescaler_0/tspc_0/D divider_0/prescaler_0/nand_0/z1 0.24fF
C483 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/Out 0.19fF
C484 divider_0/nor_1/A divider_0/tspc_1/Z4 0.02fF
C485 divider_0/tspc_0/Q divider_0/tspc_1/Z1 0.01fF
C486 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT3 0.26fF
C487 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT4 20.26fF
C488 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z2 0.21fF
C489 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C490 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C491 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C492 divider_0/prescaler_0/tspc_0/D divider_0/clk 0.26fF
C493 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z4 0.20fF
C494 pd_0/REF pd_0/tspc_r_1/z5 0.04fF
C495 pd_0/tspc_r_1/Z1 pd_0/tspc_r_1/Z2 0.71fF
C496 divbuf_0/OUT divbuf_0/a_492_n240# 0.00fF
C497 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a3 0.13fF
C498 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C499 pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_0/divider_0/clk 1.46fF
C500 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_0/D 0.11fF
C501 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/Z1 0.04fF
C502 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z2 0.40fF
C503 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divbuf_0/IN 0.04fF
C504 pll_full_0/divider_0/prescaler_0/tspc_0/Q pll_full_0/divider_0/clk 0.05fF
C505 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/v 1.30fF
C506 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_1/A 0.15fF
C507 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C508 divider_0/prescaler_0/tspc_0/Z3 divider_0/clk 0.45fF
C509 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z1 0.09fF
C510 pd_0/DIV pd_0/tspc_r_0/Z2 0.19fF
C511 divider_0/tspc_0/Z2 divider_0/tspc_0/Z4 0.36fF
C512 divider_0/tspc_0/Z3 divider_0/tspc_0/Q 0.05fF
C513 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_1/Qbar 0.02fF
C514 ro_complete_0/a0 ro_complete_0/cbank_2/switch_4/vin 0.13fF
C515 ro_complete_0/cbank_0/v ro_complete_0/cbank_1/v 1.27fF
C516 pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C517 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/Z4 0.65fF
C518 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C519 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C520 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/clk 0.01fF
C521 pd_0/R pd_0/tspc_r_1/Qbar 0.03fF
C522 divider_0/nor_1/B divider_0/tspc_1/Z4 0.21fF
C523 divider_0/tspc_1/Z2 divider_0/tspc_1/Z3 0.16fF
C524 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT3 0.26fF
C525 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/z5 0.11fF
C526 ro_complete_0/a2 ro_complete_0/cbank_2/switch_3/vin 0.09fF
C527 divbuf_7/OUT2 divbuf_7/OUT5 0.02fF
C528 divbuf_7/OUT3 divbuf_7/OUT4 5.16fF
C529 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_0/a_630_n680# 0.04fF
C530 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z4 0.00fF
C531 io_clamp_low[0] io_clamp_high[0] 0.53fF
C532 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Out1 0.05fF
C533 divider_0/nor_0/B divider_0/tspc_2/Z3 0.38fF
C534 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z4 0.12fF
C535 divider_0/tspc_2/Z1 divider_0/tspc_2/Z2 1.07fF
C536 divbuf_2/a_492_n240# divbuf_2/IN 0.13fF
C537 divbuf_2/OUT2 divbuf_2/OUT5 0.02fF
C538 divbuf_2/OUT3 divbuf_2/OUT4 5.16fF
C539 divbuf_1/a_492_n240# divbuf_1/IN 0.13fF
C540 divbuf_0/IN divbuf_0/a_492_n240# 0.13fF
C541 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/and_0/OUT 0.05fF
C542 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z3 0.06fF
C543 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/tspc_r_1/Qbar 0.05fF
C544 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/z5 0.03fF
C545 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Qbar1 0.38fF
C546 divider_0/and_0/B divider_0/and_0/Z1 0.07fF
C547 pll_full_0/divbuf_0/OUT4 pll_full_0/divbuf_0/OUT5 20.26fF
C548 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C549 divbuf_2/OUT2 divbuf_2/OUT 0.06fF
C550 ro_complete_0/a2 ro_complete_0/cbank_2/v 0.05fF
C551 divbuf_5/OUT2 divbuf_5/OUT 0.06fF
C552 divbuf_5/OUT3 divbuf_5/OUT5 0.01fF
C553 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_1/Z4 0.02fF
C554 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_2/Z2 0.20fF
C555 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C556 divider_0/and_0/OUT divider_0/prescaler_0/tspc_0/Q 0.04fF
C557 divider_0/prescaler_0/tspc_1/Z3 divider_0/clk 0.45fF
C558 divider_0/tspc_0/Q divider_0/tspc_1/Z3 0.45fF
C559 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/switch_1/vin 0.19fF
C560 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z3 0.65fF
C561 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C562 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C563 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C564 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/Out 0.01fF
C565 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.19fF
C566 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/clk 0.14fF
C567 pd_0/R pd_0/and_pd_0/Z1 0.02fF
C568 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/z5 0.20fF
C569 divider_0/nor_1/B divider_0/tspc_2/Z4 0.02fF
C570 divider_0/tspc_1/Q divider_0/tspc_2/Z1 0.01fF
C571 io_clamp_high[2] io_analog[6] 0.53fF
C572 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C573 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C574 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Z3 0.38fF
C575 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z2 1.07fF
C576 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C577 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C578 divider_0/prescaler_0/m1_2700_2190# divider_0/and_0/OUT 0.14fF
C579 pll_full_0/divider_0/nor_0/B pll_full_0/divbuf_0/IN 0.29fF
C580 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z3 0.06fF
C581 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/clk 0.29fF
C582 pd_0/and_pd_0/Out1 pd_0/and_pd_0/Z1 0.18fF
C583 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z4 0.36fF
C584 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C585 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C586 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C587 divider_0/prescaler_0/tspc_0/Z4 divider_0/clk 0.12fF
C588 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/Z1 0.36fF
C589 pd_0/DIV pd_0/R 0.51fF
C590 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT2 0.42fF
C591 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C592 divbuf_6/a_492_n240# divbuf_6/OUT5 0.01fF
C593 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z1 0.01fF
C594 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C595 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C596 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/A 0.26fF
C597 divider_0/prescaler_0/tspc_2/Z3 divider_0/clk 0.64fF
C598 pd_0/REF pd_0/tspc_r_1/Qbar1 0.12fF
C599 divider_0/tspc_1/Z2 divider_0/tspc_1/Z4 0.36fF
C600 divider_0/tspc_1/Z3 divider_0/tspc_1/Q 0.05fF
C601 divbuf_2/a_492_n240# divbuf_2/OUT2 0.42fF
C602 ro_complete_0/a2 ro_complete_0/cbank_0/switch_2/vin 0.14fF
C603 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a4 0.09fF
C604 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/a5 0.09fF
C605 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT4 1.11fF
C606 pll_full_0/pd_0/UP pll_full_0/pd_0/tspc_r_1/z5 0.03fF
C607 divbuf_3/a_492_n240# divbuf_3/OUT 0.00fF
C608 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/divider_0/clk 1.46fF
C609 divbuf_7/OUT3 divbuf_7/OUT 0.26fF
C610 divbuf_7/OUT4 divbuf_7/OUT5 20.26fF
C611 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Z4 0.65fF
C612 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/and_0/B 0.08fF
C613 divider_0/nor_0/B divider_0/tspc_2/Z4 0.22fF
C614 divider_0/tspc_2/Z2 divider_0/tspc_2/Z3 0.16fF
C615 divbuf_2/OUT4 divbuf_2/OUT5 20.26fF
C616 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z4 0.00fF
C617 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C618 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C619 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z4 0.00fF
C620 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Q 0.21fF
C621 divider_0/tspc_0/a_630_n680# divider_0/nor_1/A 0.35fF
C622 divbuf_1/OUT2 divbuf_1/a_492_n240# 0.42fF
C623 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z2 0.25fF
C624 divbuf_2/OUT4 divbuf_2/OUT 1.11fF
C625 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT2 1.37fF
C626 divbuf_5/OUT4 divbuf_5/OUT 1.11fF
C627 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C628 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C629 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z3 0.33fF
C630 divider_0/prescaler_0/tspc_1/Z4 divider_0/clk 0.12fF
C631 divider_0/tspc_0/Q divider_0/tspc_1/Z4 0.15fF
C632 pd_0/DOWN pd_0/UP 0.46fF
C633 pd_0/tspc_r_0/Z4 pd_0/tspc_r_0/z5 0.04fF
C634 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Qbar1 0.38fF
C635 ro_complete_0/a0 ro_complete_0/cbank_2/switch_5/vin 0.09fF
C636 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C637 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C638 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C639 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z2 0.01fF
C640 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_2/D 0.32fF
C641 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C642 divider_0/prescaler_0/tspc_1/Q divider_0/clk 0.60fF
C643 divider_0/tspc_1/Q divider_0/tspc_2/Z3 0.45fF
C644 io_clamp_low[1] io_analog[5] 0.53fF
C645 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/v 1.30fF
C646 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C647 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C648 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/divider_0/clk 1.46fF
C649 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z4 0.00fF
C650 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_0/D 0.16fF
C651 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/Q 0.05fF
C652 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/DIV 0.17fF
C653 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C654 divider_0/nor_1/Z1 divider_0/and_0/B 0.18fF
C655 divbuf_5/a_492_n240# divbuf_5/IN 0.13fF
C656 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_0/B 0.00fF
C657 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/nor_1/A 0.35fF
C658 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C659 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C660 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C661 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_1/Q 0.13fF
C662 pd_0/tspc_r_0/Qbar1 pd_0/R 0.01fF
C663 pd_0/DIV pd_0/tspc_r_0/Z4 0.02fF
C664 pd_0/DOWN pd_0/tspc_r_0/Qbar 0.21fF
C665 divider_0/tspc_0/a_630_n680# divider_0/nor_1/B 0.01fF
C666 divbuf_1/OUT5 divbuf_1/OUT 43.38fF
C667 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/a_492_n240# 0.01fF
C668 divbuf_6/OUT2 divbuf_6/OUT3 1.37fF
C669 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z3 0.45fF
C670 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C671 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/Out 0.08fF
C672 divider_0/prescaler_0/tspc_2/Z4 divider_0/clk 0.12fF
C673 pd_0/tspc_r_1/Z3 pd_0/UP 0.03fF
C674 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT5 43.38fF
C675 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/tspc_r_1/Z4 0.14fF
C676 divbuf_3/IN divbuf_3/OUT5 0.00fF
C677 ro_complete_0/cbank_1/v ro_complete_0/cbank_2/v 1.36fF
C678 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C679 divider_0/and_0/OUT divider_0/and_0/Z1 0.04fF
C680 divbuf_7/OUT5 divbuf_7/OUT 43.38fF
C681 divider_0/tspc_2/Z2 divider_0/tspc_2/Z4 0.36fF
C682 divider_0/tspc_2/Z3 divider_0/Out 0.05fF
C683 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_0/vin 0.19fF
C684 divider_0/mc2 divider_0/and_0/B 0.20fF
C685 divbuf_4/IN divbuf_4/OUT5 0.00fF
C686 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C687 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C688 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Z4 0.65fF
C689 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/clk 0.01fF
C690 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z2 0.01fF
C691 pll_full_0/pd_0/DOWN pll_full_0/pd_0/REF 1.48fF
C692 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C693 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/Qbar 0.01fF
C694 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/R 0.27fF
C695 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C696 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/v 1.30fF
C697 divider_0/prescaler_0/tspc_1/Q divider_0/nor_1/A 0.03fF
C698 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z4 0.08fF
C699 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z3 0.05fF
C700 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/clk 0.11fF
C701 cp_0/a_1710_0# cp_0/a_1710_n2840# 0.83fF
C702 pd_0/R pd_0/REF 0.61fF
C703 divider_0/tspc_1/a_630_n680# divider_0/nor_1/B 0.35fF
C704 divbuf_0/OUT5 divbuf_0/OUT2 0.02fF
C705 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C706 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z1 0.17fF
C707 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/UP 0.11fF
C708 ro_complete_0/a0 ro_complete_0/cbank_2/v 0.05fF
C709 divider_0/prescaler_0/Out divider_0/tspc_0/Z3 0.45fF
C710 divbuf_7/a_492_n240# divbuf_7/OUT2 0.42fF
C711 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_1/B 0.35fF
C712 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C713 pll_full_0/ro_complete_0/a2 pll_full_0/divider_0/clk 0.11fF
C714 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z3 0.33fF
C715 pll_full_0/divider_0/prescaler_0/tspc_0/Q pll_full_0/divider_0/prescaler_0/tspc_2/D 0.04fF
C716 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C717 divider_0/prescaler_0/tspc_0/Q divider_0/clk 0.05fF
C718 divider_0/tspc_1/Q divider_0/tspc_2/Z4 0.15fF
C719 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_492_n240# 0.00fF
C720 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C721 pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_0/divider_0/clk 1.61fF
C722 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/nand_0/z1 0.07fF
C723 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divider_0/tspc_2/Z4 0.65fF
C724 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT 43.38fF
C725 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/Qbar1 0.11fF
C726 divider_0/and_0/out1 divider_0/and_0/A 0.01fF
C727 ro_complete_0/a4 ro_complete_0/cbank_2/switch_0/vin 0.12fF
C728 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a4 0.12fF
C729 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C730 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/Out 0.12fF
C731 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C732 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C733 divider_0/prescaler_0/tspc_2/Z4 divider_0/prescaler_0/tspc_1/Q 0.21fF
C734 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/D 0.03fF
C735 divider_0/prescaler_0/m1_2700_2190# divider_0/clk 0.01fF
C736 divider_0/nor_1/A divider_0/nor_1/B 1.21fF
C737 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/z5 0.11fF
C738 pll_full_0/cp_0/a_1710_0# pll_full_0/cp_0/down 0.32fF
C739 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z3 0.29fF
C740 ro_complete_0/a3 ro_complete_0/cbank_2/v 0.05fF
C741 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C742 divbuf_6/OUT2 divbuf_6/OUT5 0.02fF
C743 divbuf_6/OUT3 divbuf_6/OUT4 5.16fF
C744 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z1 0.00fF
C745 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C746 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z4 0.15fF
C747 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/Out 0.11fF
C748 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/clk 0.11fF
C749 divider_0/tspc_1/a_630_n680# divider_0/nor_0/B 0.00fF
C750 divider_0/nor_1/A divider_0/and_0/A 0.01fF
C751 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z1 0.09fF
C752 pd_0/REF pd_0/tspc_r_1/Z2 0.19fF
C753 divider_0/nor_0/Z1 divider_0/nor_1/B 0.18fF
C754 divbuf_3/OUT2 divbuf_3/OUT 0.06fF
C755 divbuf_3/OUT3 divbuf_3/OUT5 0.01fF
C756 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/a0 0.09fF
C757 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z3 0.05fF
C758 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C759 divider_0/prescaler_0/tspc_0/Z2 divider_0/and_0/OUT 0.05fF
C760 ro_complete_0/a3 ro_complete_0/cbank_1/switch_2/vin 0.09fF
C761 divbuf_4/OUT2 divbuf_4/OUT 0.06fF
C762 divbuf_4/OUT3 divbuf_4/OUT5 0.01fF
C763 pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_0/divider_0/clk 1.46fF
C764 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/clk 0.51fF
C765 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/clk 0.01fF
C766 pd_0/DIV pd_0/tspc_r_0/Z3 0.65fF
C767 divider_0/nor_1/A divider_0/tspc_0/Z2 0.23fF
C768 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Q 0.04fF
C769 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z4 0.20fF
C770 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_5/vin 0.20fF
C771 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/OUT2 0.02fF
C772 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a3 0.13fF
C773 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z4 0.12fF
C774 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z2 1.07fF
C775 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_0/Q 0.19fF
C776 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/clk 0.14fF
C777 pd_0/DOWN pd_0/tspc_r_1/Qbar 0.02fF
C778 pd_0/R pd_0/tspc_r_1/Qbar1 0.30fF
C779 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z2 0.01fF
C780 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/tspc_r_1/z5 0.02fF
C781 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z2 0.25fF
C782 divbuf_0/OUT5 divbuf_0/OUT3 0.01fF
C783 divider_0/prescaler_0/Out divider_0/tspc_0/Z4 0.12fF
C784 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z4 0.08fF
C785 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z3 0.05fF
C786 pll_full_0/divider_0/prescaler_0/tspc_0/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C787 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/clk 0.11fF
C788 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/Out 0.05fF
C789 divider_0/prescaler_0/tspc_2/D divider_0/clk 0.29fF
C790 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/pd_0/R 0.02fF
C791 divider_0/tspc_2/a_630_n680# divider_0/nor_0/B 0.35fF
C792 divider_0/nor_1/B divider_0/and_0/A 0.26fF
C793 io_clamp_high[0] io_analog[4] 0.53fF
C794 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/a1 0.14fF
C795 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/v 1.30fF
C796 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/a3 0.09fF
C797 divider_0/prescaler_0/m1_2700_2190# divider_0/nor_1/A 0.01fF
C798 divider_0/nor_0/Z1 divider_0/nor_0/B 0.06fF
C799 divbuf_4/a_492_n240# divbuf_4/OUT2 0.42fF
C800 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C801 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C802 divider_0/prescaler_0/tspc_1/Z2 divider_0/and_0/OUT 0.06fF
C803 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z3 0.33fF
C804 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Q 0.38fF
C805 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C806 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/v 1.30fF
C807 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/cbank_0/v 1.30fF
C808 divbuf_5/a_492_n240# divbuf_5/OUT5 0.01fF
C809 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/B 0.18fF
C810 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z2 0.36fF
C811 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_0/Z3 0.05fF
C812 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C813 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C814 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/clk 0.01fF
C815 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/D 0.05fF
C816 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/clk 0.01fF
C817 pd_0/DOWN pd_0/tspc_r_0/z5 0.03fF
C818 pd_0/tspc_r_0/Z2 pd_0/R 0.21fF
C819 divider_0/nor_1/A divider_0/tspc_1/Z2 0.15fF
C820 divider_0/tspc_0/Q divider_0/tspc_1/a_630_n680# 0.01fF
C821 pll_full_0/pd_0/R pll_full_0/pd_0/UP 0.46fF
C822 pll_full_0/divbuf_0/OUT2 pll_full_0/divbuf_0/a_492_n240# 0.42fF
C823 divbuf_6/OUT3 divbuf_6/OUT 0.26fF
C824 divbuf_6/OUT4 divbuf_6/OUT5 20.26fF
C825 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/nor_1/B 0.22fF
C826 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C827 divider_0/mc2 divider_0/and_0/OUT 0.05fF
C828 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/prescaler_0/Out 0.28fF
C829 pd_0/DOWN pd_0/and_pd_0/Z1 0.07fF
C830 divider_0/nor_1/B divider_0/nor_0/B 0.47fF
C831 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT2 0.06fF
C832 pll_full_0/pd_0/DIV pll_full_0/divider_0/and_0/OUT 0.01fF
C833 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C834 divbuf_3/OUT4 divbuf_3/OUT 1.11fF
C835 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/nor_1/A 0.21fF
C836 divider_0/prescaler_0/tspc_1/Z4 divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C837 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Q 0.20fF
C838 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/D 0.09fF
C839 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/B 0.01fF
C840 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/Out 0.91fF
C841 ro_complete_0/a3 ro_complete_0/cbank_2/switch_1/vin 0.13fF
C842 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C843 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C844 divbuf_4/OUT4 divbuf_4/OUT 1.11fF
C845 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C846 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_1/Q 0.15fF
C847 divider_0/prescaler_0/tspc_2/Z2 divider_0/and_0/OUT 0.06fF
C848 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_0/Z3 0.45fF
C849 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Qbar1 0.38fF
Xpd_0 VDD gnd pd_0/REF pd_0/DIV pd_0/UP pd_0/DOWN pd_0/R pd
Xcp_0 cp_0/vbias vdd gnd cp_0/out cp_0/down cp_0/upbar cp
Xfilter_0 gnd filter_0/v filter
Xro_complete_0 ro_complete_0/a0 ro_complete_0/a1 ro_complete_0/a5 ro_complete_0/a4
+ ro_complete_0/a3 ro_complete_0/a2 ro_complete
Xdivbuf_0 VDD divbuf_0/IN divbuf_0/OUT divbuf_0/OUT2 divbuf_0/OUT3 divbuf_0/OUT4 divbuf_0/OUT5
+ gnd divbuf
Xdivbuf_1 VDD divbuf_1/IN divbuf_1/OUT divbuf_1/OUT2 divbuf_1/OUT3 divbuf_1/OUT4 divbuf_1/OUT5
+ gnd divbuf
Xdivbuf_2 VDD divbuf_2/IN divbuf_2/OUT divbuf_2/OUT2 divbuf_2/OUT3 divbuf_2/OUT4 divbuf_2/OUT5
+ gnd divbuf
Xdivbuf_3 VDD divbuf_3/IN divbuf_3/OUT divbuf_3/OUT2 divbuf_3/OUT3 divbuf_3/OUT4 divbuf_3/OUT5
+ gnd divbuf
Xdivbuf_4 VDD divbuf_4/IN divbuf_4/OUT divbuf_4/OUT2 divbuf_4/OUT3 divbuf_4/OUT4 divbuf_4/OUT5
+ gnd divbuf
Xdivbuf_5 VDD divbuf_5/IN divbuf_5/OUT divbuf_5/OUT2 divbuf_5/OUT3 divbuf_5/OUT4 divbuf_5/OUT5
+ gnd divbuf
Xdivbuf_6 VDD divbuf_6/IN divbuf_6/OUT divbuf_6/OUT2 divbuf_6/OUT3 divbuf_6/OUT4 divbuf_6/OUT5
+ gnd divbuf
Xdivbuf_7 VDD divbuf_7/IN divbuf_7/OUT divbuf_7/OUT2 divbuf_7/OUT3 divbuf_7/OUT4 divbuf_7/OUT5
+ gnd divbuf
Xdivider_0 gnd vdd divider_0/Out divider_0/clk divider_0/mc2 divider
Xpll_full_0 vdd pll_full
C850 io_analog[4] vdd 43.96fF
C851 io_analog[5] vdd 44.13fF
C852 io_analog[6] vdd 43.46fF
C853 io_in_3v3[0] vdd 0.61fF
C854 io_oeb[26] vdd 0.61fF
C855 io_in[0] vdd 0.61fF
C856 io_out[26] vdd 0.61fF
C857 io_out[0] vdd 0.61fF
C858 io_in[26] vdd 0.61fF
C859 io_oeb[0] vdd 0.61fF
C860 io_in_3v3[26] vdd 0.61fF
C861 io_in_3v3[1] vdd 0.61fF
C862 io_oeb[25] vdd 0.61fF
C863 io_in[1] vdd 0.61fF
C864 io_out[25] vdd 0.61fF
C865 io_out[1] vdd 0.61fF
C866 io_in[25] vdd 0.61fF
C867 io_oeb[1] vdd 0.61fF
C868 io_in_3v3[25] vdd 0.61fF
C869 io_in_3v3[2] vdd 0.61fF
C870 io_oeb[24] vdd 0.61fF
C871 io_in[2] vdd 0.61fF
C872 io_out[24] vdd 0.61fF
C873 io_out[2] vdd 0.61fF
C874 io_in[24] vdd 0.61fF
C875 io_oeb[2] vdd 0.61fF
C876 io_in_3v3[24] vdd 0.61fF
C877 io_in_3v3[3] vdd 0.61fF
C878 gpio_noesd[17] vdd 0.61fF
C879 io_in[3] vdd 0.61fF
C880 gpio_analog[17] vdd 0.61fF
C881 io_out[3] vdd 0.61fF
C882 io_oeb[3] vdd 0.61fF
C883 io_in_3v3[4] vdd 0.61fF
C884 io_in[4] vdd 0.61fF
C885 io_out[4] vdd 0.61fF
C886 io_oeb[4] vdd 0.61fF
C887 io_oeb[23] vdd 0.61fF
C888 io_out[23] vdd 0.61fF
C889 io_in[23] vdd 0.61fF
C890 io_in_3v3[23] vdd 0.61fF
C891 gpio_noesd[16] vdd 0.61fF
C892 gpio_analog[16] vdd 0.61fF
C893 io_in_3v3[5] vdd 0.61fF
C894 io_in[5] vdd 0.61fF
C895 io_out[5] vdd 0.61fF
C896 io_oeb[5] vdd 0.61fF
C897 io_oeb[22] vdd 0.61fF
C898 io_out[22] vdd 0.61fF
C899 io_in[22] vdd 0.61fF
C900 io_in_3v3[22] vdd 0.61fF
C901 gpio_noesd[15] vdd 0.61fF
C902 gpio_analog[15] vdd 0.61fF
C903 io_in_3v3[6] vdd 0.61fF
C904 io_in[6] vdd 0.61fF
C905 io_out[6] vdd 0.61fF
C906 io_oeb[6] vdd 0.61fF
C907 io_oeb[21] vdd 0.61fF
C908 io_out[21] vdd 0.61fF
C909 io_in[21] vdd 0.61fF
C910 io_in_3v3[21] vdd 0.61fF
C911 gpio_noesd[14] vdd 0.61fF
C912 gpio_analog[14] vdd 0.61fF
C913 vssa1 vdd 38.21fF
C914 vssd2 vdd 13.04fF
C915 vssd1 vdd 13.04fF
C916 vdda2 vdd 13.04fF
C917 vdda1 vdd 26.08fF
C918 io_oeb[20] vdd 0.61fF
C919 io_out[20] vdd 0.61fF
C920 io_in[20] vdd 0.61fF
C921 io_in_3v3[20] vdd 0.61fF
C922 gpio_noesd[13] vdd 0.61fF
C923 gpio_analog[13] vdd 0.61fF
C924 gpio_analog[0] vdd 0.61fF
C925 gpio_noesd[0] vdd 0.61fF
C926 io_in_3v3[7] vdd 0.61fF
C927 io_in[7] vdd 0.61fF
C928 io_out[7] vdd 0.61fF
C929 io_oeb[7] vdd 0.61fF
C930 io_oeb[19] vdd 0.61fF
C931 io_out[19] vdd 0.61fF
C932 io_in[19] vdd 0.61fF
C933 io_in_3v3[19] vdd 0.61fF
C934 gpio_noesd[12] vdd 0.61fF
C935 gpio_analog[12] vdd 0.61fF
C936 gpio_analog[1] vdd 0.61fF
C937 gpio_noesd[1] vdd 0.61fF
C938 io_in_3v3[8] vdd 0.61fF
C939 io_in[8] vdd 0.61fF
C940 io_out[8] vdd 0.61fF
C941 io_oeb[8] vdd 0.61fF
C942 io_oeb[18] vdd 0.61fF
C943 io_out[18] vdd 0.61fF
C944 io_in[18] vdd 0.61fF
C945 io_in_3v3[18] vdd 0.61fF
C946 gpio_noesd[11] vdd 0.61fF
C947 gpio_analog[11] vdd 0.61fF
C948 gpio_analog[2] vdd 0.61fF
C949 gpio_noesd[2] vdd 0.61fF
C950 io_in_3v3[9] vdd 0.61fF
C951 io_in[9] vdd 0.61fF
C952 io_out[9] vdd 0.61fF
C953 io_oeb[9] vdd 0.61fF
C954 io_oeb[17] vdd 0.61fF
C955 io_out[17] vdd 0.61fF
C956 io_in[17] vdd 0.61fF
C957 io_in_3v3[17] vdd 0.61fF
C958 gpio_noesd[10] vdd 0.61fF
C959 gpio_analog[10] vdd 0.61fF
C960 gpio_analog[3] vdd 0.61fF
C961 gpio_noesd[3] vdd 0.61fF
C962 io_in_3v3[10] vdd 0.61fF
C963 io_in[10] vdd 0.61fF
C964 io_out[10] vdd 0.61fF
C965 io_oeb[10] vdd 0.61fF
C966 io_oeb[16] vdd 0.61fF
C967 io_out[16] vdd 0.61fF
C968 io_in[16] vdd 0.61fF
C969 io_in_3v3[16] vdd 0.61fF
C970 gpio_noesd[9] vdd 0.61fF
C971 gpio_analog[9] vdd 0.61fF
C972 gpio_analog[4] vdd 0.61fF
C973 gpio_noesd[4] vdd 0.61fF
C974 io_in_3v3[11] vdd 0.61fF
C975 io_in[11] vdd 0.61fF
C976 io_out[11] vdd 0.61fF
C977 io_oeb[11] vdd 0.61fF
C978 io_oeb[15] vdd 0.61fF
C979 io_out[15] vdd 0.61fF
C980 io_in[15] vdd 0.61fF
C981 io_in_3v3[15] vdd 0.61fF
C982 gpio_noesd[8] vdd 0.61fF
C983 gpio_analog[8] vdd 0.61fF
C984 gpio_analog[5] vdd 0.61fF
C985 gpio_noesd[5] vdd 0.61fF
C986 io_in_3v3[12] vdd 0.61fF
C987 io_in[12] vdd 0.61fF
C988 io_out[12] vdd 0.61fF
C989 io_oeb[12] vdd 0.61fF
C990 io_oeb[14] vdd 0.61fF
C991 io_out[14] vdd 0.61fF
C992 io_in[14] vdd 0.61fF
C993 io_in_3v3[14] vdd 0.61fF
C994 gpio_noesd[7] vdd 0.61fF
C995 gpio_analog[7] vdd 0.61fF
C996 vssa2 vdd 13.04fF
C997 gpio_analog[6] vdd 0.61fF
C998 gpio_noesd[6] vdd 0.61fF
C999 io_in_3v3[13] vdd 0.61fF
C1000 io_in[13] vdd 0.61fF
C1001 io_out[13] vdd 0.61fF
C1002 io_oeb[13] vdd 0.61fF
C1003 vccd1 vdd 13.04fF
C1004 vccd2 vdd 13.04fF
C1005 io_analog[0] vdd 6.83fF
C1006 io_analog[10] vdd 6.83fF
C1007 io_analog[1] vdd 13.17fF
C1008 io_analog[2] vdd 12.57fF
C1009 io_analog[3] vdd 12.83fF
C1010 io_clamp_high[0] vdd 3.58fF
C1011 io_clamp_low[0] vdd 3.58fF
C1012 io_clamp_high[1] vdd 3.58fF
C1013 io_clamp_low[1] vdd 3.58fF
C1014 io_clamp_high[2] vdd 3.58fF
C1015 io_clamp_low[2] vdd 3.58fF
C1016 io_analog[7] vdd 12.74fF
C1017 io_analog[8] vdd 13.08fF
C1018 io_analog[9] vdd 13.08fF
C1019 user_irq[2] vdd 0.63fF
C1020 user_irq[1] vdd 0.63fF
C1021 user_irq[0] vdd 0.63fF
C1022 user_clock2 vdd 0.63fF
C1023 la_oenb[127] vdd 0.63fF
C1024 la_data_out[127] vdd 0.63fF
C1025 la_data_in[127] vdd 0.63fF
C1026 la_oenb[126] vdd 0.63fF
C1027 la_data_out[126] vdd 0.63fF
C1028 la_data_in[126] vdd 0.63fF
C1029 la_oenb[125] vdd 0.63fF
C1030 la_data_out[125] vdd 0.63fF
C1031 la_data_in[125] vdd 0.63fF
C1032 la_oenb[124] vdd 0.63fF
C1033 la_data_out[124] vdd 0.63fF
C1034 la_data_in[124] vdd 0.63fF
C1035 la_oenb[123] vdd 0.63fF
C1036 la_data_out[123] vdd 0.63fF
C1037 la_data_in[123] vdd 0.63fF
C1038 la_oenb[122] vdd 0.63fF
C1039 la_data_out[122] vdd 0.63fF
C1040 la_data_in[122] vdd 0.63fF
C1041 la_oenb[121] vdd 0.63fF
C1042 la_data_out[121] vdd 0.63fF
C1043 la_data_in[121] vdd 0.63fF
C1044 la_oenb[120] vdd 0.63fF
C1045 la_data_out[120] vdd 0.63fF
C1046 la_data_in[120] vdd 0.63fF
C1047 la_oenb[119] vdd 0.63fF
C1048 la_data_out[119] vdd 0.63fF
C1049 la_data_in[119] vdd 0.63fF
C1050 la_oenb[118] vdd 0.63fF
C1051 la_data_out[118] vdd 0.63fF
C1052 la_data_in[118] vdd 0.63fF
C1053 la_oenb[117] vdd 0.63fF
C1054 la_data_out[117] vdd 0.63fF
C1055 la_data_in[117] vdd 0.63fF
C1056 la_oenb[116] vdd 0.63fF
C1057 la_data_out[116] vdd 0.63fF
C1058 la_data_in[116] vdd 0.63fF
C1059 la_oenb[115] vdd 0.63fF
C1060 la_data_out[115] vdd 0.63fF
C1061 la_data_in[115] vdd 0.63fF
C1062 la_oenb[114] vdd 0.63fF
C1063 la_data_out[114] vdd 0.63fF
C1064 la_data_in[114] vdd 0.63fF
C1065 la_oenb[113] vdd 0.63fF
C1066 la_data_out[113] vdd 0.63fF
C1067 la_data_in[113] vdd 0.63fF
C1068 la_oenb[112] vdd 0.63fF
C1069 la_data_out[112] vdd 0.63fF
C1070 la_data_in[112] vdd 0.63fF
C1071 la_oenb[111] vdd 0.63fF
C1072 la_data_out[111] vdd 0.63fF
C1073 la_data_in[111] vdd 0.63fF
C1074 la_oenb[110] vdd 0.63fF
C1075 la_data_out[110] vdd 0.63fF
C1076 la_data_in[110] vdd 0.63fF
C1077 la_oenb[109] vdd 0.63fF
C1078 la_data_out[109] vdd 0.63fF
C1079 la_data_in[109] vdd 0.63fF
C1080 la_oenb[108] vdd 0.63fF
C1081 la_data_out[108] vdd 0.63fF
C1082 la_data_in[108] vdd 0.63fF
C1083 la_oenb[107] vdd 0.63fF
C1084 la_data_out[107] vdd 0.63fF
C1085 la_data_in[107] vdd 0.63fF
C1086 la_oenb[106] vdd 0.63fF
C1087 la_data_out[106] vdd 0.63fF
C1088 la_data_in[106] vdd 0.63fF
C1089 la_oenb[105] vdd 0.63fF
C1090 la_data_out[105] vdd 0.63fF
C1091 la_data_in[105] vdd 0.63fF
C1092 la_oenb[104] vdd 0.63fF
C1093 la_data_out[104] vdd 0.63fF
C1094 la_data_in[104] vdd 0.63fF
C1095 la_oenb[103] vdd 0.63fF
C1096 la_data_out[103] vdd 0.63fF
C1097 la_data_in[103] vdd 0.63fF
C1098 la_oenb[102] vdd 0.63fF
C1099 la_data_out[102] vdd 0.63fF
C1100 la_data_in[102] vdd 0.63fF
C1101 la_oenb[101] vdd 0.63fF
C1102 la_data_out[101] vdd 0.63fF
C1103 la_data_in[101] vdd 0.63fF
C1104 la_oenb[100] vdd 0.63fF
C1105 la_data_out[100] vdd 0.63fF
C1106 la_data_in[100] vdd 0.63fF
C1107 la_oenb[99] vdd 0.63fF
C1108 la_data_out[99] vdd 0.63fF
C1109 la_data_in[99] vdd 0.63fF
C1110 la_oenb[98] vdd 0.63fF
C1111 la_data_out[98] vdd 0.63fF
C1112 la_data_in[98] vdd 0.63fF
C1113 la_oenb[97] vdd 0.63fF
C1114 la_data_out[97] vdd 0.63fF
C1115 la_data_in[97] vdd 0.63fF
C1116 la_oenb[96] vdd 0.63fF
C1117 la_data_out[96] vdd 0.63fF
C1118 la_data_in[96] vdd 0.63fF
C1119 la_oenb[95] vdd 0.63fF
C1120 la_data_out[95] vdd 0.63fF
C1121 la_data_in[95] vdd 0.63fF
C1122 la_oenb[94] vdd 0.63fF
C1123 la_data_out[94] vdd 0.63fF
C1124 la_data_in[94] vdd 0.63fF
C1125 la_oenb[93] vdd 0.63fF
C1126 la_data_out[93] vdd 0.63fF
C1127 la_data_in[93] vdd 0.63fF
C1128 la_oenb[92] vdd 0.63fF
C1129 la_data_out[92] vdd 0.63fF
C1130 la_data_in[92] vdd 0.63fF
C1131 la_oenb[91] vdd 0.63fF
C1132 la_data_out[91] vdd 0.63fF
C1133 la_data_in[91] vdd 0.63fF
C1134 la_oenb[90] vdd 0.63fF
C1135 la_data_out[90] vdd 0.63fF
C1136 la_data_in[90] vdd 0.63fF
C1137 la_oenb[89] vdd 0.63fF
C1138 la_data_out[89] vdd 0.63fF
C1139 la_data_in[89] vdd 0.63fF
C1140 la_oenb[88] vdd 0.63fF
C1141 la_data_out[88] vdd 0.63fF
C1142 la_data_in[88] vdd 0.63fF
C1143 la_oenb[87] vdd 0.63fF
C1144 la_data_out[87] vdd 0.63fF
C1145 la_data_in[87] vdd 0.63fF
C1146 la_oenb[86] vdd 0.63fF
C1147 la_data_out[86] vdd 0.63fF
C1148 la_data_in[86] vdd 0.63fF
C1149 la_oenb[85] vdd 0.63fF
C1150 la_data_out[85] vdd 0.63fF
C1151 la_data_in[85] vdd 0.63fF
C1152 la_oenb[84] vdd 0.63fF
C1153 la_data_out[84] vdd 0.63fF
C1154 la_data_in[84] vdd 0.63fF
C1155 la_oenb[83] vdd 0.63fF
C1156 la_data_out[83] vdd 0.63fF
C1157 la_data_in[83] vdd 0.63fF
C1158 la_oenb[82] vdd 0.63fF
C1159 la_data_out[82] vdd 0.63fF
C1160 la_data_in[82] vdd 0.63fF
C1161 la_oenb[81] vdd 0.63fF
C1162 la_data_out[81] vdd 0.63fF
C1163 la_data_in[81] vdd 0.63fF
C1164 la_oenb[80] vdd 0.63fF
C1165 la_data_out[80] vdd 0.63fF
C1166 la_data_in[80] vdd 0.63fF
C1167 la_oenb[79] vdd 0.63fF
C1168 la_data_out[79] vdd 0.63fF
C1169 la_data_in[79] vdd 0.63fF
C1170 la_oenb[78] vdd 0.63fF
C1171 la_data_out[78] vdd 0.63fF
C1172 la_data_in[78] vdd 0.63fF
C1173 la_oenb[77] vdd 0.63fF
C1174 la_data_out[77] vdd 0.63fF
C1175 la_data_in[77] vdd 0.63fF
C1176 la_oenb[76] vdd 0.63fF
C1177 la_data_out[76] vdd 0.63fF
C1178 la_data_in[76] vdd 0.63fF
C1179 la_oenb[75] vdd 0.63fF
C1180 la_data_out[75] vdd 0.63fF
C1181 la_data_in[75] vdd 0.63fF
C1182 la_oenb[74] vdd 0.63fF
C1183 la_data_out[74] vdd 0.63fF
C1184 la_data_in[74] vdd 0.63fF
C1185 la_oenb[73] vdd 0.63fF
C1186 la_data_out[73] vdd 0.63fF
C1187 la_data_in[73] vdd 0.63fF
C1188 la_oenb[72] vdd 0.63fF
C1189 la_data_out[72] vdd 0.63fF
C1190 la_data_in[72] vdd 0.63fF
C1191 la_oenb[71] vdd 0.63fF
C1192 la_data_out[71] vdd 0.63fF
C1193 la_data_in[71] vdd 0.63fF
C1194 la_oenb[70] vdd 0.63fF
C1195 la_data_out[70] vdd 0.63fF
C1196 la_data_in[70] vdd 0.63fF
C1197 la_oenb[69] vdd 0.63fF
C1198 la_data_out[69] vdd 0.63fF
C1199 la_data_in[69] vdd 0.63fF
C1200 la_oenb[68] vdd 0.63fF
C1201 la_data_out[68] vdd 0.63fF
C1202 la_data_in[68] vdd 0.63fF
C1203 la_oenb[67] vdd 0.63fF
C1204 la_data_out[67] vdd 0.63fF
C1205 la_data_in[67] vdd 0.63fF
C1206 la_oenb[66] vdd 0.63fF
C1207 la_data_out[66] vdd 0.63fF
C1208 la_data_in[66] vdd 0.63fF
C1209 la_oenb[65] vdd 0.63fF
C1210 la_data_out[65] vdd 0.63fF
C1211 la_data_in[65] vdd 0.63fF
C1212 la_oenb[64] vdd 0.63fF
C1213 la_data_out[64] vdd 0.63fF
C1214 la_data_in[64] vdd 0.63fF
C1215 la_oenb[63] vdd 0.63fF
C1216 la_data_out[63] vdd 0.63fF
C1217 la_data_in[63] vdd 0.63fF
C1218 la_oenb[62] vdd 0.63fF
C1219 la_data_out[62] vdd 0.63fF
C1220 la_data_in[62] vdd 0.63fF
C1221 la_oenb[61] vdd 0.63fF
C1222 la_data_out[61] vdd 0.63fF
C1223 la_data_in[61] vdd 0.63fF
C1224 la_oenb[60] vdd 0.63fF
C1225 la_data_out[60] vdd 0.63fF
C1226 la_data_in[60] vdd 0.63fF
C1227 la_oenb[59] vdd 0.63fF
C1228 la_data_out[59] vdd 0.63fF
C1229 la_data_in[59] vdd 0.63fF
C1230 la_oenb[58] vdd 0.63fF
C1231 la_data_out[58] vdd 0.63fF
C1232 la_data_in[58] vdd 0.63fF
C1233 la_oenb[57] vdd 0.63fF
C1234 la_data_out[57] vdd 0.63fF
C1235 la_data_in[57] vdd 0.63fF
C1236 la_oenb[56] vdd 0.63fF
C1237 la_data_out[56] vdd 0.63fF
C1238 la_data_in[56] vdd 0.63fF
C1239 la_oenb[55] vdd 0.63fF
C1240 la_data_out[55] vdd 0.63fF
C1241 la_data_in[55] vdd 0.63fF
C1242 la_oenb[54] vdd 0.63fF
C1243 la_data_out[54] vdd 0.63fF
C1244 la_data_in[54] vdd 0.63fF
C1245 la_oenb[53] vdd 0.63fF
C1246 la_data_out[53] vdd 0.63fF
C1247 la_data_in[53] vdd 0.63fF
C1248 la_oenb[52] vdd 0.63fF
C1249 la_data_out[52] vdd 0.63fF
C1250 la_data_in[52] vdd 0.63fF
C1251 la_oenb[51] vdd 0.63fF
C1252 la_data_out[51] vdd 0.63fF
C1253 la_data_in[51] vdd 0.63fF
C1254 la_oenb[50] vdd 0.63fF
C1255 la_data_out[50] vdd 0.63fF
C1256 la_data_in[50] vdd 0.63fF
C1257 la_oenb[49] vdd 0.63fF
C1258 la_data_out[49] vdd 0.63fF
C1259 la_data_in[49] vdd 0.63fF
C1260 la_oenb[48] vdd 0.63fF
C1261 la_data_out[48] vdd 0.63fF
C1262 la_data_in[48] vdd 0.63fF
C1263 la_oenb[47] vdd 0.63fF
C1264 la_data_out[47] vdd 0.63fF
C1265 la_data_in[47] vdd 0.63fF
C1266 la_oenb[46] vdd 0.63fF
C1267 la_data_out[46] vdd 0.63fF
C1268 la_data_in[46] vdd 0.63fF
C1269 la_oenb[45] vdd 0.63fF
C1270 la_data_out[45] vdd 0.63fF
C1271 la_data_in[45] vdd 0.63fF
C1272 la_oenb[44] vdd 0.63fF
C1273 la_data_out[44] vdd 0.63fF
C1274 la_data_in[44] vdd 0.63fF
C1275 la_oenb[43] vdd 0.63fF
C1276 la_data_out[43] vdd 0.63fF
C1277 la_data_in[43] vdd 0.63fF
C1278 la_oenb[42] vdd 0.63fF
C1279 la_data_out[42] vdd 0.63fF
C1280 la_data_in[42] vdd 0.63fF
C1281 la_oenb[41] vdd 0.63fF
C1282 la_data_out[41] vdd 0.63fF
C1283 la_data_in[41] vdd 0.63fF
C1284 la_oenb[40] vdd 0.63fF
C1285 la_data_out[40] vdd 0.63fF
C1286 la_data_in[40] vdd 0.63fF
C1287 la_oenb[39] vdd 0.63fF
C1288 la_data_out[39] vdd 0.63fF
C1289 la_data_in[39] vdd 0.63fF
C1290 la_oenb[38] vdd 0.63fF
C1291 la_data_out[38] vdd 0.63fF
C1292 la_data_in[38] vdd 0.63fF
C1293 la_oenb[37] vdd 0.63fF
C1294 la_data_out[37] vdd 0.63fF
C1295 la_data_in[37] vdd 0.63fF
C1296 la_oenb[36] vdd 0.63fF
C1297 la_data_out[36] vdd 0.63fF
C1298 la_data_in[36] vdd 0.63fF
C1299 la_oenb[35] vdd 0.63fF
C1300 la_data_out[35] vdd 0.63fF
C1301 la_data_in[35] vdd 0.63fF
C1302 la_oenb[34] vdd 0.63fF
C1303 la_data_out[34] vdd 0.63fF
C1304 la_data_in[34] vdd 0.63fF
C1305 la_oenb[33] vdd 0.63fF
C1306 la_data_out[33] vdd 0.63fF
C1307 la_data_in[33] vdd 0.63fF
C1308 la_oenb[32] vdd 0.63fF
C1309 la_data_out[32] vdd 0.63fF
C1310 la_data_in[32] vdd 0.63fF
C1311 la_oenb[31] vdd 0.63fF
C1312 la_data_out[31] vdd 0.63fF
C1313 la_data_in[31] vdd 0.63fF
C1314 la_oenb[30] vdd 0.63fF
C1315 la_data_out[30] vdd 0.63fF
C1316 la_data_in[30] vdd 0.63fF
C1317 la_oenb[29] vdd 0.63fF
C1318 la_data_out[29] vdd 0.63fF
C1319 la_data_in[29] vdd 0.63fF
C1320 la_oenb[28] vdd 0.63fF
C1321 la_data_out[28] vdd 0.63fF
C1322 la_data_in[28] vdd 0.63fF
C1323 la_oenb[27] vdd 0.63fF
C1324 la_data_out[27] vdd 0.63fF
C1325 la_data_in[27] vdd 0.63fF
C1326 la_oenb[26] vdd 0.63fF
C1327 la_data_out[26] vdd 0.63fF
C1328 la_data_in[26] vdd 0.63fF
C1329 la_oenb[25] vdd 0.63fF
C1330 la_data_out[25] vdd 0.63fF
C1331 la_data_in[25] vdd 0.63fF
C1332 la_oenb[24] vdd 0.63fF
C1333 la_data_out[24] vdd 0.63fF
C1334 la_data_in[24] vdd 0.63fF
C1335 la_oenb[23] vdd 0.63fF
C1336 la_data_out[23] vdd 0.63fF
C1337 la_data_in[23] vdd 0.63fF
C1338 la_oenb[22] vdd 0.63fF
C1339 la_data_out[22] vdd 0.63fF
C1340 la_data_in[22] vdd 0.63fF
C1341 la_oenb[21] vdd 0.63fF
C1342 la_data_out[21] vdd 0.63fF
C1343 la_data_in[21] vdd 0.63fF
C1344 la_oenb[20] vdd 0.63fF
C1345 la_data_out[20] vdd 0.63fF
C1346 la_data_in[20] vdd 0.63fF
C1347 la_oenb[19] vdd 0.63fF
C1348 la_data_out[19] vdd 0.63fF
C1349 la_data_in[19] vdd 0.63fF
C1350 la_oenb[18] vdd 0.63fF
C1351 la_data_out[18] vdd 0.63fF
C1352 la_data_in[18] vdd 0.63fF
C1353 la_oenb[17] vdd 0.63fF
C1354 la_data_out[17] vdd 0.63fF
C1355 la_data_in[17] vdd 0.63fF
C1356 la_oenb[16] vdd 0.63fF
C1357 la_data_out[16] vdd 0.63fF
C1358 la_data_in[16] vdd 0.63fF
C1359 la_oenb[15] vdd 0.63fF
C1360 la_data_out[15] vdd 0.63fF
C1361 la_data_in[15] vdd 0.63fF
C1362 la_oenb[14] vdd 0.63fF
C1363 la_data_out[14] vdd 0.63fF
C1364 la_data_in[14] vdd 0.63fF
C1365 la_oenb[13] vdd 0.63fF
C1366 la_data_out[13] vdd 0.63fF
C1367 la_data_in[13] vdd 0.63fF
C1368 la_oenb[12] vdd 0.63fF
C1369 la_data_out[12] vdd 0.63fF
C1370 la_data_in[12] vdd 0.63fF
C1371 la_oenb[11] vdd 0.63fF
C1372 la_data_out[11] vdd 0.63fF
C1373 la_data_in[11] vdd 0.63fF
C1374 la_oenb[10] vdd 0.63fF
C1375 la_data_out[10] vdd 0.63fF
C1376 la_data_in[10] vdd 0.63fF
C1377 la_oenb[9] vdd 0.63fF
C1378 la_data_out[9] vdd 0.63fF
C1379 la_data_in[9] vdd 0.63fF
C1380 la_oenb[8] vdd 0.63fF
C1381 la_data_out[8] vdd 0.63fF
C1382 la_data_in[8] vdd 0.63fF
C1383 la_oenb[7] vdd 0.63fF
C1384 la_data_out[7] vdd 0.63fF
C1385 la_data_in[7] vdd 0.63fF
C1386 la_oenb[6] vdd 0.63fF
C1387 la_data_out[6] vdd 0.63fF
C1388 la_data_in[6] vdd 0.63fF
C1389 la_oenb[5] vdd 0.63fF
C1390 la_data_out[5] vdd 0.63fF
C1391 la_data_in[5] vdd 0.63fF
C1392 la_oenb[4] vdd 0.63fF
C1393 la_data_out[4] vdd 0.63fF
C1394 la_data_in[4] vdd 0.63fF
C1395 la_oenb[3] vdd 0.63fF
C1396 la_data_out[3] vdd 0.63fF
C1397 la_data_in[3] vdd 0.63fF
C1398 la_oenb[2] vdd 0.63fF
C1399 la_data_out[2] vdd 0.63fF
C1400 la_data_in[2] vdd 0.63fF
C1401 la_oenb[1] vdd 0.63fF
C1402 la_data_out[1] vdd 0.63fF
C1403 la_data_in[1] vdd 0.63fF
C1404 la_oenb[0] vdd 0.63fF
C1405 la_data_out[0] vdd 0.63fF
C1406 la_data_in[0] vdd 0.63fF
C1407 wbs_dat_o[31] vdd 0.63fF
C1408 wbs_dat_i[31] vdd 0.63fF
C1409 wbs_adr_i[31] vdd 0.63fF
C1410 wbs_dat_o[30] vdd 0.63fF
C1411 wbs_dat_i[30] vdd 0.63fF
C1412 wbs_adr_i[30] vdd 0.63fF
C1413 wbs_dat_o[29] vdd 0.63fF
C1414 wbs_dat_i[29] vdd 0.63fF
C1415 wbs_adr_i[29] vdd 0.63fF
C1416 wbs_dat_o[28] vdd 0.63fF
C1417 wbs_dat_i[28] vdd 0.63fF
C1418 wbs_adr_i[28] vdd 0.63fF
C1419 wbs_dat_o[27] vdd 0.63fF
C1420 wbs_dat_i[27] vdd 0.63fF
C1421 wbs_adr_i[27] vdd 0.63fF
C1422 wbs_dat_o[26] vdd 0.63fF
C1423 wbs_dat_i[26] vdd 0.63fF
C1424 wbs_adr_i[26] vdd 0.63fF
C1425 wbs_dat_o[25] vdd 0.63fF
C1426 wbs_dat_i[25] vdd 0.63fF
C1427 wbs_adr_i[25] vdd 0.63fF
C1428 wbs_dat_o[24] vdd 0.63fF
C1429 wbs_dat_i[24] vdd 0.63fF
C1430 wbs_adr_i[24] vdd 0.63fF
C1431 wbs_dat_o[23] vdd 0.63fF
C1432 wbs_dat_i[23] vdd 0.63fF
C1433 wbs_adr_i[23] vdd 0.63fF
C1434 wbs_dat_o[22] vdd 0.63fF
C1435 wbs_dat_i[22] vdd 0.63fF
C1436 wbs_adr_i[22] vdd 0.63fF
C1437 wbs_dat_o[21] vdd 0.63fF
C1438 wbs_dat_i[21] vdd 0.63fF
C1439 wbs_adr_i[21] vdd 0.63fF
C1440 wbs_dat_o[20] vdd 0.63fF
C1441 wbs_dat_i[20] vdd 0.63fF
C1442 wbs_adr_i[20] vdd 0.63fF
C1443 wbs_dat_o[19] vdd 0.63fF
C1444 wbs_dat_i[19] vdd 0.63fF
C1445 wbs_adr_i[19] vdd 0.63fF
C1446 wbs_dat_o[18] vdd 0.63fF
C1447 wbs_dat_i[18] vdd 0.63fF
C1448 wbs_adr_i[18] vdd 0.63fF
C1449 wbs_dat_o[17] vdd 0.63fF
C1450 wbs_dat_i[17] vdd 0.63fF
C1451 wbs_adr_i[17] vdd 0.63fF
C1452 wbs_dat_o[16] vdd 0.63fF
C1453 wbs_dat_i[16] vdd 0.63fF
C1454 wbs_adr_i[16] vdd 0.63fF
C1455 wbs_dat_o[15] vdd 0.63fF
C1456 wbs_dat_i[15] vdd 0.63fF
C1457 wbs_adr_i[15] vdd 0.63fF
C1458 wbs_dat_o[14] vdd 0.63fF
C1459 wbs_dat_i[14] vdd 0.63fF
C1460 wbs_adr_i[14] vdd 0.63fF
C1461 wbs_dat_o[13] vdd 0.63fF
C1462 wbs_dat_i[13] vdd 0.63fF
C1463 wbs_adr_i[13] vdd 0.63fF
C1464 wbs_dat_o[12] vdd 0.63fF
C1465 wbs_dat_i[12] vdd 0.63fF
C1466 wbs_adr_i[12] vdd 0.63fF
C1467 wbs_dat_o[11] vdd 0.63fF
C1468 wbs_dat_i[11] vdd 0.63fF
C1469 wbs_adr_i[11] vdd 0.63fF
C1470 wbs_dat_o[10] vdd 0.63fF
C1471 wbs_dat_i[10] vdd 0.63fF
C1472 wbs_adr_i[10] vdd 0.63fF
C1473 wbs_dat_o[9] vdd 0.63fF
C1474 wbs_dat_i[9] vdd 0.63fF
C1475 wbs_adr_i[9] vdd 0.63fF
C1476 wbs_dat_o[8] vdd 0.63fF
C1477 wbs_dat_i[8] vdd 0.63fF
C1478 wbs_adr_i[8] vdd 0.63fF
C1479 wbs_dat_o[7] vdd 0.63fF
C1480 wbs_dat_i[7] vdd 0.63fF
C1481 wbs_adr_i[7] vdd 0.63fF
C1482 wbs_dat_o[6] vdd 0.63fF
C1483 wbs_dat_i[6] vdd 0.63fF
C1484 wbs_adr_i[6] vdd 0.63fF
C1485 wbs_dat_o[5] vdd 0.63fF
C1486 wbs_dat_i[5] vdd 0.63fF
C1487 wbs_adr_i[5] vdd 0.63fF
C1488 wbs_dat_o[4] vdd 0.63fF
C1489 wbs_dat_i[4] vdd 0.63fF
C1490 wbs_adr_i[4] vdd 0.63fF
C1491 wbs_sel_i[3] vdd 0.63fF
C1492 wbs_dat_o[3] vdd 0.63fF
C1493 wbs_dat_i[3] vdd 0.63fF
C1494 wbs_adr_i[3] vdd 0.63fF
C1495 wbs_sel_i[2] vdd 0.63fF
C1496 wbs_dat_o[2] vdd 0.63fF
C1497 wbs_dat_i[2] vdd 0.63fF
C1498 wbs_adr_i[2] vdd 0.63fF
C1499 wbs_sel_i[1] vdd 0.63fF
C1500 wbs_dat_o[1] vdd 0.63fF
C1501 wbs_dat_i[1] vdd 0.63fF
C1502 wbs_adr_i[1] vdd 0.63fF
C1503 wbs_sel_i[0] vdd 0.63fF
C1504 wbs_dat_o[0] vdd 0.63fF
C1505 wbs_dat_i[0] vdd 0.63fF
C1506 wbs_adr_i[0] vdd 0.63fF
C1507 wbs_we_i vdd 0.63fF
C1508 wbs_stb_i vdd 0.63fF
C1509 wbs_cyc_i vdd 0.63fF
C1510 wbs_ack_o vdd 0.63fF
C1511 wb_rst_i vdd 0.63fF
C1512 wb_clk_i vdd 0.63fF
C1513 pll_full_0/divider_0/and_0/Z1 vdd 0.65fF
C1514 pll_full_0/divider_0/and_0/B vdd 2.45fF
C1515 pll_full_0/divider_0/and_0/A vdd 2.35fF
C1516 pll_full_0/divider_0/and_0/out1 vdd 2.99fF
C1517 pll_full_0/divider_0/tspc_2/Z4 vdd 0.86fF
C1518 pll_full_0/divbuf_0/IN vdd 9.95fF
C1519 pll_full_0/divider_0/tspc_2/Z3 vdd 2.26fF
C1520 pll_full_0/divider_0/tspc_2/Z2 vdd 1.46fF
C1521 pll_full_0/divider_0/tspc_2/Z1 vdd 0.99fF
C1522 pll_full_0/divider_0/nor_0/B vdd 6.48fF
C1523 pll_full_0/divider_0/tspc_2/a_630_n680# vdd 1.14fF **FLOATING
C1524 pll_full_0/divider_0/tspc_1/Z4 vdd 0.86fF
C1525 pll_full_0/divider_0/tspc_1/Q vdd 3.12fF
C1526 pll_full_0/divider_0/tspc_1/Z3 vdd 2.26fF
C1527 pll_full_0/divider_0/tspc_1/Z2 vdd 1.46fF
C1528 pll_full_0/divider_0/tspc_1/Z1 vdd 0.99fF
C1529 pll_full_0/divider_0/nor_1/B vdd 7.12fF
C1530 pll_full_0/divider_0/tspc_1/a_630_n680# vdd 1.15fF **FLOATING
C1531 pll_full_0/divider_0/tspc_0/Z4 vdd 0.86fF
C1532 pll_full_0/divider_0/tspc_0/Q vdd 3.14fF
C1533 pll_full_0/divider_0/tspc_0/Z3 vdd 2.26fF
C1534 pll_full_0/divider_0/tspc_0/Z2 vdd 1.46fF
C1535 pll_full_0/divider_0/tspc_0/Z1 vdd 0.99fF
C1536 pll_full_0/divider_0/nor_1/A vdd 7.08fF
C1537 pll_full_0/divider_0/tspc_0/a_630_n680# vdd 1.15fF **FLOATING
C1538 pll_full_0/divider_0/clk vdd 31.85fF
C1539 pll_full_0/divider_0/prescaler_0/Out vdd 4.59fF
C1540 pll_full_0/divider_0/prescaler_0/nand_1/z1 vdd 0.36fF
C1541 pll_full_0/divider_0/prescaler_0/tspc_2/D vdd 2.64fF
C1542 pll_full_0/divider_0/prescaler_0/tspc_0/Q vdd 3.64fF
C1543 pll_full_0/divider_0/prescaler_0/tspc_1/Q vdd 3.61fF
C1544 pll_full_0/divider_0/prescaler_0/nand_0/z1 vdd 0.36fF
C1545 pll_full_0/divider_0/prescaler_0/tspc_0/D vdd 3.12fF
C1546 pll_full_0/divider_0/and_0/OUT vdd 5.67fF
C1547 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 vdd 0.86fF
C1548 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 vdd 2.26fF
C1549 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 vdd 1.46fF
C1550 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 vdd 0.99fF
C1551 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# vdd 1.16fF **FLOATING
C1552 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# vdd 2.11fF **FLOATING
C1553 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 vdd 0.86fF
C1554 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 vdd 2.26fF
C1555 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 vdd 1.48fF
C1556 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 vdd 0.99fF
C1557 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# vdd 1.14fF **FLOATING
C1558 pll_full_0/divider_0/prescaler_0/m1_2700_2190# vdd 4.22fF **FLOATING
C1559 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 vdd 0.86fF
C1560 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 vdd 2.26fF
C1561 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 vdd 1.19fF
C1562 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 vdd 0.99fF
C1563 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# vdd 1.47fF **FLOATING
C1564 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# vdd 2.11fF **FLOATING
C1565 pll_full_0/divider_0/nor_1/Z1 vdd 1.34fF
C1566 pll_full_0/divider_0/nor_0/Z1 vdd 1.34fF
C1567 pll_full_0/divbuf_1/OUT vdd 363.82fF
C1568 pll_full_0/divbuf_1/OUT5 vdd 350.37fF
C1569 pll_full_0/divbuf_1/OUT4 vdd 133.72fF
C1570 pll_full_0/divbuf_1/OUT3 vdd 34.03fF
C1571 pll_full_0/divbuf_1/OUT2 vdd 8.71fF
C1572 pll_full_0/divbuf_1/a_492_n240# vdd 2.46fF **FLOATING
C1573 pll_full_0/divbuf_0/OUT5 vdd 350.37fF
C1574 pll_full_0/divbuf_0/OUT4 vdd 133.72fF
C1575 pll_full_0/divbuf_0/OUT3 vdd 34.03fF
C1576 pll_full_0/divbuf_0/OUT2 vdd 8.71fF
C1577 pll_full_0/divbuf_0/a_492_n240# vdd 2.46fF **FLOATING
C1578 pll_full_0/ro_complete_0/cbank_2/v vdd 17.88fF
C1579 pll_full_0/ro_complete_0/cbank_2/switch_5/vin vdd 0.78fF
C1580 pll_full_0/ro_complete_0/cbank_2/switch_4/vin vdd 1.50fF
C1581 pll_full_0/ro_complete_0/cbank_2/switch_2/vin vdd 1.30fF
C1582 pll_full_0/ro_complete_0/cbank_2/switch_3/vin vdd 0.56fF
C1583 pll_full_0/ro_complete_0/cbank_2/switch_1/vin vdd 1.14fF
C1584 pll_full_0/ro_complete_0/cbank_2/switch_0/vin vdd 1.02fF
C1585 pll_full_0/ro_complete_0/cbank_1/switch_5/vin vdd 0.78fF
C1586 pll_full_0/ro_complete_0/a0 vdd 7.88fF
C1587 pll_full_0/ro_complete_0/cbank_1/switch_4/vin vdd 1.50fF
C1588 pll_full_0/ro_complete_0/a1 vdd 5.39fF
C1589 pll_full_0/ro_complete_0/cbank_1/switch_2/vin vdd 1.30fF
C1590 pll_full_0/ro_complete_0/a3 vdd 6.85fF
C1591 pll_full_0/ro_complete_0/cbank_1/switch_3/vin vdd 0.56fF
C1592 pll_full_0/ro_complete_0/a2 vdd 5.48fF
C1593 pll_full_0/ro_complete_0/cbank_1/switch_1/vin vdd 1.14fF
C1594 pll_full_0/ro_complete_0/a4 vdd 5.36fF
C1595 pll_full_0/ro_complete_0/cbank_1/switch_0/vin vdd 1.02fF
C1596 pll_full_0/ro_complete_0/a5 vdd 5.19fF
C1597 pll_full_0/ro_complete_0/cbank_0/v vdd 15.02fF
C1598 pll_full_0/ro_complete_0/cbank_0/switch_5/vin vdd 0.78fF
C1599 pll_full_0/ro_complete_0/cbank_0/switch_4/vin vdd 1.50fF
C1600 pll_full_0/ro_complete_0/cbank_0/switch_2/vin vdd 1.30fF
C1601 pll_full_0/ro_complete_0/cbank_0/switch_3/vin vdd 0.56fF
C1602 pll_full_0/ro_complete_0/cbank_0/switch_1/vin vdd 1.14fF
C1603 pll_full_0/ro_complete_0/cbank_0/switch_0/vin vdd 1.02fF
C1604 pll_full_0/ro_complete_0/ro_var_extend_0/vcont vdd 0.27fF
C1605 pll_full_0/filter_0/a_4216_n5230# vdd 419.25fF **FLOATING
C1606 pll_full_0/filter_0/a_4216_n2998# vdd 1.39fF **FLOATING
C1607 pll_full_0/cp_0/down vdd 1.54fF
C1608 pll_full_0/cp_0/upbar vdd 1.79fF
C1609 pll_full_0/cp_0/a_7110_n2840# vdd 0.17fF **FLOATING
C1610 pll_full_0/cp_0/a_3060_n2840# vdd 1.71fF **FLOATING
C1611 pll_full_0/cp_0/a_7110_0# vdd 0.17fF **FLOATING
C1612 pll_full_0/cp_0/a_6370_0# vdd 0.40fF **FLOATING
C1613 pll_full_0/cp_0/a_3060_0# vdd 2.49fF **FLOATING
C1614 pll_full_0/cp_0/a_1710_0# vdd 7.47fF **FLOATING
C1615 pll_full_0/pd_0/and_pd_0/Z1 vdd 0.39fF
C1616 pll_full_0/pd_0/and_pd_0/Out1 vdd 2.22fF
C1617 pll_full_0/pd_0/tspc_r_1/z5 vdd 1.10fF
C1618 pll_full_0/pd_0/tspc_r_1/Z4 vdd 1.07fF
C1619 pll_full_0/pd_0/tspc_r_1/Qbar vdd 0.88fF
C1620 pll_full_0/pd_0/tspc_r_1/Z2 vdd 1.22fF
C1621 pll_full_0/pd_0/tspc_r_1/Z1 vdd 0.67fF
C1622 pll_full_0/pd_0/UP vdd 6.61fF
C1623 pll_full_0/pd_0/tspc_r_1/Qbar1 vdd 1.34fF
C1624 pll_full_0/pd_0/tspc_r_1/Z3 vdd 2.12fF
C1625 pll_full_0/pd_0/REF vdd 6.44fF
C1626 pll_full_0/pd_0/tspc_r_0/z5 vdd 1.10fF
C1627 pll_full_0/pd_0/tspc_r_0/Z4 vdd 1.07fF
C1628 pll_full_0/pd_0/R vdd 3.05fF
C1629 pll_full_0/pd_0/tspc_r_0/Qbar vdd 0.79fF
C1630 pll_full_0/pd_0/tspc_r_0/Z2 vdd 1.22fF
C1631 pll_full_0/pd_0/tspc_r_0/Z1 vdd 0.67fF
C1632 pll_full_0/pd_0/DOWN vdd 7.24fF
C1633 pll_full_0/pd_0/tspc_r_0/Qbar1 vdd 1.34fF
C1634 pll_full_0/pd_0/tspc_r_0/Z3 vdd 2.12fF
C1635 pll_full_0/pd_0/DIV vdd 371.87fF
C1636 divider_0/and_0/Z1 vdd 0.74fF
C1637 divider_0/and_0/B vdd 2.25fF
C1638 divider_0/and_0/A vdd 2.19fF
C1639 divider_0/and_0/out1 vdd 2.93fF
C1640 divider_0/tspc_2/Z4 vdd 0.86fF
C1641 divider_0/Out vdd 1.60fF
C1642 divider_0/tspc_2/Z3 vdd 2.26fF
C1643 divider_0/tspc_2/Z2 vdd 1.46fF
C1644 divider_0/tspc_2/Z1 vdd 0.99fF
C1645 divider_0/nor_0/B vdd 6.33fF
C1646 divider_0/tspc_2/a_630_n680# vdd 1.14fF **FLOATING
C1647 divider_0/tspc_1/Z4 vdd 0.86fF
C1648 divider_0/tspc_1/Q vdd 3.12fF
C1649 divider_0/tspc_1/Z3 vdd 2.26fF
C1650 divider_0/tspc_1/Z2 vdd 1.46fF
C1651 divider_0/tspc_1/Z1 vdd 0.99fF
C1652 divider_0/nor_1/B vdd 7.05fF
C1653 divider_0/tspc_1/a_630_n680# vdd 1.15fF **FLOATING
C1654 divider_0/tspc_0/Z4 vdd 0.86fF
C1655 divider_0/tspc_0/Q vdd 3.14fF
C1656 divider_0/tspc_0/Z3 vdd 2.26fF
C1657 divider_0/tspc_0/Z2 vdd 1.46fF
C1658 divider_0/tspc_0/Z1 vdd 0.99fF
C1659 divider_0/nor_1/A vdd 7.04fF
C1660 divider_0/tspc_0/a_630_n680# vdd 1.15fF **FLOATING
C1661 divider_0/clk vdd 5.63fF
C1662 divider_0/prescaler_0/Out vdd 4.59fF
C1663 divider_0/prescaler_0/nand_1/z1 vdd 0.36fF
C1664 divider_0/prescaler_0/tspc_2/D vdd 2.64fF
C1665 divider_0/prescaler_0/tspc_0/Q vdd 3.64fF
C1666 divider_0/prescaler_0/tspc_1/Q vdd 3.61fF
C1667 divider_0/prescaler_0/nand_0/z1 vdd 0.36fF
C1668 divider_0/prescaler_0/tspc_0/D vdd 3.12fF
C1669 divider_0/and_0/OUT vdd 5.62fF
C1670 divider_0/prescaler_0/tspc_2/Z4 vdd 0.86fF
C1671 divider_0/prescaler_0/tspc_2/Z3 vdd 2.26fF
C1672 divider_0/prescaler_0/tspc_2/Z2 vdd 1.46fF
C1673 divider_0/prescaler_0/tspc_2/Z1 vdd 0.99fF
C1674 divider_0/prescaler_0/tspc_2/a_630_n680# vdd 1.16fF **FLOATING
C1675 divider_0/prescaler_0/tspc_2/a_740_n680# vdd 2.11fF **FLOATING
C1676 divider_0/prescaler_0/tspc_1/Z4 vdd 0.86fF
C1677 divider_0/prescaler_0/tspc_1/Z3 vdd 2.26fF
C1678 divider_0/prescaler_0/tspc_1/Z2 vdd 1.48fF
C1679 divider_0/prescaler_0/tspc_1/Z1 vdd 0.99fF
C1680 divider_0/prescaler_0/tspc_1/a_630_n680# vdd 1.14fF **FLOATING
C1681 divider_0/prescaler_0/m1_2700_2190# vdd 4.22fF **FLOATING
C1682 divider_0/prescaler_0/tspc_0/Z4 vdd 0.86fF
C1683 divider_0/prescaler_0/tspc_0/Z3 vdd 2.26fF
C1684 divider_0/prescaler_0/tspc_0/Z2 vdd 1.46fF
C1685 divider_0/prescaler_0/tspc_0/Z1 vdd 0.99fF
C1686 divider_0/prescaler_0/tspc_0/a_630_n680# vdd 1.14fF **FLOATING
C1687 divider_0/prescaler_0/tspc_0/a_740_n680# vdd 2.11fF **FLOATING
C1688 divider_0/nor_1/Z1 vdd 1.34fF
C1689 divider_0/nor_0/Z1 vdd 1.34fF
C1690 divider_0/mc2 vdd 5.29fF
C1691 divbuf_7/OUT vdd 363.82fF
C1692 divbuf_7/OUT5 vdd 350.37fF
C1693 divbuf_7/OUT4 vdd 133.72fF
C1694 divbuf_7/OUT3 vdd 34.03fF
C1695 divbuf_7/OUT2 vdd 8.71fF
C1696 divbuf_7/IN vdd 0.89fF
C1697 divbuf_7/a_492_n240# vdd 2.46fF **FLOATING
C1698 divbuf_6/OUT vdd 363.82fF
C1699 divbuf_6/OUT5 vdd 350.37fF
C1700 divbuf_6/OUT4 vdd 133.72fF
C1701 divbuf_6/OUT3 vdd 34.03fF
C1702 divbuf_6/OUT2 vdd 8.71fF
C1703 divbuf_6/IN vdd 0.89fF
C1704 divbuf_6/a_492_n240# vdd 2.46fF **FLOATING
C1705 divbuf_5/OUT vdd 363.82fF
C1706 divbuf_5/OUT5 vdd 350.37fF
C1707 divbuf_5/OUT4 vdd 133.72fF
C1708 divbuf_5/OUT3 vdd 34.03fF
C1709 divbuf_5/OUT2 vdd 8.71fF
C1710 divbuf_5/IN vdd 0.89fF
C1711 divbuf_5/a_492_n240# vdd 2.46fF **FLOATING
C1712 divbuf_4/OUT vdd 363.82fF
C1713 divbuf_4/OUT5 vdd 350.37fF
C1714 divbuf_4/OUT4 vdd 133.72fF
C1715 divbuf_4/OUT3 vdd 34.03fF
C1716 divbuf_4/OUT2 vdd 8.71fF
C1717 divbuf_4/IN vdd 0.89fF
C1718 divbuf_4/a_492_n240# vdd 2.46fF **FLOATING
C1719 divbuf_3/OUT vdd 363.82fF
C1720 divbuf_3/OUT5 vdd 350.37fF
C1721 divbuf_3/OUT4 vdd 133.72fF
C1722 divbuf_3/OUT3 vdd 34.03fF
C1723 divbuf_3/OUT2 vdd 8.71fF
C1724 divbuf_3/IN vdd 0.89fF
C1725 divbuf_3/a_492_n240# vdd 2.46fF **FLOATING
C1726 divbuf_2/OUT vdd 363.82fF
C1727 divbuf_2/OUT5 vdd 350.37fF
C1728 divbuf_2/OUT4 vdd 133.72fF
C1729 divbuf_2/OUT3 vdd 34.03fF
C1730 divbuf_2/OUT2 vdd 8.71fF
C1731 divbuf_2/IN vdd 0.89fF
C1732 divbuf_2/a_492_n240# vdd 2.46fF **FLOATING
C1733 divbuf_1/OUT vdd 363.82fF
C1734 divbuf_1/OUT5 vdd 350.37fF
C1735 divbuf_1/OUT4 vdd 133.72fF
C1736 divbuf_1/OUT3 vdd 34.03fF
C1737 divbuf_1/OUT2 vdd 8.71fF
C1738 divbuf_1/IN vdd 0.89fF
C1739 divbuf_1/a_492_n240# vdd 2.46fF **FLOATING
C1740 divbuf_0/OUT vdd 363.82fF
C1741 divbuf_0/OUT5 vdd 350.37fF
C1742 divbuf_0/OUT4 vdd 133.72fF
C1743 divbuf_0/OUT3 vdd 34.03fF
C1744 divbuf_0/OUT2 vdd 8.71fF
C1745 divbuf_0/IN vdd 0.89fF
C1746 divbuf_0/a_492_n240# vdd 2.46fF **FLOATING
C1747 ro_complete_0/cbank_2/v vdd 17.84fF
C1748 ro_complete_0/cbank_2/switch_5/vin vdd 0.78fF
C1749 ro_complete_0/cbank_2/switch_4/vin vdd 1.50fF
C1750 ro_complete_0/cbank_2/switch_2/vin vdd 1.30fF
C1751 ro_complete_0/cbank_2/switch_3/vin vdd 0.56fF
C1752 ro_complete_0/cbank_2/switch_1/vin vdd 1.14fF
C1753 ro_complete_0/cbank_2/switch_0/vin vdd 1.02fF
C1754 ro_complete_0/cbank_1/v vdd 16.34fF
C1755 ro_complete_0/cbank_1/switch_5/vin vdd 0.78fF
C1756 ro_complete_0/a0 vdd 7.88fF
C1757 ro_complete_0/cbank_1/switch_4/vin vdd 1.50fF
C1758 ro_complete_0/a1 vdd 5.39fF
C1759 ro_complete_0/cbank_1/switch_2/vin vdd 1.30fF
C1760 ro_complete_0/a3 vdd 6.85fF
C1761 ro_complete_0/cbank_1/switch_3/vin vdd 0.56fF
C1762 ro_complete_0/a2 vdd 5.48fF
C1763 ro_complete_0/cbank_1/switch_1/vin vdd 1.14fF
C1764 ro_complete_0/a4 vdd 5.36fF
C1765 ro_complete_0/cbank_1/switch_0/vin vdd 1.02fF
C1766 ro_complete_0/a5 vdd 5.19fF
C1767 ro_complete_0/cbank_0/v vdd 14.98fF
C1768 ro_complete_0/cbank_0/switch_5/vin vdd 0.78fF
C1769 ro_complete_0/cbank_0/switch_4/vin vdd 1.50fF
C1770 ro_complete_0/cbank_0/switch_2/vin vdd 1.30fF
C1771 ro_complete_0/cbank_0/switch_3/vin vdd 0.56fF
C1772 ro_complete_0/cbank_0/switch_1/vin vdd 1.14fF
C1773 ro_complete_0/cbank_0/switch_0/vin vdd 1.02fF
C1774 ro_complete_0/ro_var_extend_0/vcont vdd 0.27fF
C1775 filter_0/v vdd 85.69fF
C1776 filter_0/a_4216_n5230# vdd 418.47fF **FLOATING
C1777 filter_0/a_4216_n2998# vdd 1.03fF **FLOATING
C1778 cp_0/down vdd 1.54fF
C1779 cp_0/vbias vdd 2.41fF
C1780 cp_0/out vdd 5.26fF
C1781 cp_0/upbar vdd 1.50fF
C1782 cp_0/a_7110_n2840# vdd 0.17fF **FLOATING
C1783 cp_0/a_3060_n2840# vdd 1.71fF **FLOATING
C1784 cp_0/a_7110_0# vdd 0.17fF **FLOATING
C1785 cp_0/a_6370_0# vdd 0.40fF **FLOATING
C1786 cp_0/a_3060_0# vdd 1.65fF **FLOATING
C1787 cp_0/a_1710_0# vdd 5.76fF **FLOATING
C1788 cp_0/a_1710_n2840# vdd 4.89fF **FLOATING
C1789 cp_0/a_10_n50# vdd 2.96fF **FLOATING
C1790 pd_0/and_pd_0/Z1 vdd 0.39fF
C1791 pd_0/and_pd_0/Out1 vdd 2.22fF
C1792 pd_0/tspc_r_1/z5 vdd 1.10fF
C1793 pd_0/tspc_r_1/Z4 vdd 1.07fF
C1794 pd_0/tspc_r_1/Qbar vdd 0.88fF
C1795 pd_0/tspc_r_1/Z2 vdd 1.22fF
C1796 pd_0/tspc_r_1/Z1 vdd 0.67fF
C1797 pd_0/UP vdd 2.21fF
C1798 pd_0/tspc_r_1/Qbar1 vdd 1.34fF
C1799 pd_0/tspc_r_1/Z3 vdd 2.12fF
C1800 pd_0/REF vdd 1.80fF
C1801 pd_0/tspc_r_0/z5 vdd 1.10fF
C1802 pd_0/tspc_r_0/Z4 vdd 1.07fF
C1803 pd_0/R vdd 3.05fF
C1804 pd_0/tspc_r_0/Qbar vdd 0.79fF
C1805 pd_0/tspc_r_0/Z2 vdd 1.22fF
C1806 pd_0/tspc_r_0/Z1 vdd 0.67fF
C1807 pd_0/DOWN vdd 3.08fF
C1808 pd_0/tspc_r_0/Qbar1 vdd 1.34fF
C1809 pd_0/tspc_r_0/Z3 vdd 2.12fF
C1810 pd_0/DIV vdd 1.82fF
.ends
