* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[5] io_analog[6] io_analog[7]
+ io_analog[8] io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vssa1 vdda2 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
C0 pll_full_0/divbuf_0/OUT pll_full_0/divbuf_0/OUT4 1.11fF
C1 divider_0/tspc_0/Z3 divider_0/Out 0.05fF
C2 divider_0/tspc_0/Z2 divider_0/nor_1/B 0.40fF
C3 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z3 0.33fF
C4 divbuf_3/a_492_n240# divbuf_3/OUT 0.00fF
C5 divbuf_16/OUT5 divbuf_16/OUT 43.38fF
C6 divider_1/prescaler_0/tspc_0/Z2 divider_1/clk 0.11fF
C7 divider_0/and_0/OUT divider_0/and_0/Z1 0.04fF
C8 divider_0/prescaler_0/tspc_2/Q divider_0/clk 0.05fF
C9 divbuf_20/OUT3 divbuf_20/OUT 0.26fF
C10 divbuf_20/OUT4 divbuf_20/OUT5 20.26fF
C11 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z4 0.36fF
C12 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C13 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C14 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Qbar1 0.12fF
C15 divbuf_17/a_492_n240# divbuf_17/IN 0.13fF
C16 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/clk 0.14fF
C17 pd_1/DOWN pd_1/and_pd_0/Z1 0.07fF
C18 pd_1/REF pd_1/tspc_r_1/Z1 0.17fF
C19 pd_1/tspc_r_1/Qbar1 pd_1/UP 0.11fF
C20 divider_2/prescaler_0/tspc_2/Z3 divider_2/clk 0.45fF
C21 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/a_740_n680# 0.33fF
C22 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C23 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/tspc_r_1/Z4 0.14fF
C24 ro_complete_1/a2 ro_complete_1/cbank_2/switch_2/vin 0.14fF
C25 ro_complete_1/a3 ro_complete_1/cbank_2/switch_1/vin 0.13fF
C26 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/nand_0/z1 0.07fF
C27 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/D 0.05fF
C28 pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C29 divbuf_15/OUT4 divbuf_15/OUT3 5.16fF
C30 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C31 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/clk 0.01fF
C32 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Z4 0.65fF
C33 divbuf_23/OUT3 divbuf_23/OUT5 0.01fF
C34 divbuf_23/OUT2 divbuf_23/OUT 0.06fF
C35 divider_2/tspc_2/Z2 divider_2/tspc_2/Z3 0.16fF
C36 divider_2/nor_0/A divider_2/tspc_2/Z4 0.21fF
C37 divider_0/nor_0/Z1 divider_0/nor_0/B 0.06fF
C38 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_5/vin 0.20fF
C39 ro_complete_1/a5 ro_complete_1/cbank_2/v 0.08fF
C40 io_clamp_low[1] io_analog[5] 0.53fF
C41 divbuf_15/OUT2 divbuf_15/OUT3 1.37fF
C42 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Q 0.05fF
C43 divider_0/prescaler_0/m1_2700_2190# divider_0/clk 0.01fF
C44 divbuf_5/OUT4 divbuf_5/OUT 1.11fF
C45 divider_1/tspc_0/Z2 divider_1/nor_1/B 0.40fF
C46 divbuf_22/a_492_n240# divbuf_22/OUT5 0.01fF
C47 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z3 0.25fF
C48 pd_0/tspc_r_1/Z2 pd_0/tspc_r_1/Z4 0.14fF
C49 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z2 0.01fF
C50 divider_2/tspc_2/Q divider_2/tspc_1/Z3 0.45fF
C51 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z4 0.00fF
C52 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Q 0.21fF
C53 divbuf_25/OUT2 divbuf_25/OUT5 0.02fF
C54 divbuf_25/OUT3 divbuf_25/OUT4 5.16fF
C55 divbuf_19/OUT5 divbuf_19/OUT 43.38fF
C56 divider_2/and_0/B divider_2/and_0/Z1 0.07fF
C57 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z4 0.01fF
C58 divbuf_1/IN divbuf_1/a_492_n240# 0.13fF
C59 divbuf_0/OUT4 divbuf_0/OUT5 20.26fF
C60 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_0/vin 0.19fF
C61 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/v 1.30fF
C62 ro_complete_1/a0 ro_complete_1/cbank_2/switch_5/vin 0.09fF
C63 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C64 divbuf_18/OUT divbuf_18/OUT2 0.06fF
C65 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/clk 0.01fF
C66 divbuf_11/OUT3 divbuf_11/OUT 0.26fF
C67 divbuf_11/OUT4 divbuf_11/OUT5 20.26fF
C68 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z1 0.08fF
C69 cp_0/a_1710_n2840# cp_0/a_1710_0# 0.83fF
C70 divider_2/prescaler_0/tspc_1/Z4 divider_2/clk 0.12fF
C71 divbuf_0/OUT3 divbuf_0/OUT4 5.16fF
C72 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C73 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z1 0.17fF
C74 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/UP 0.11fF
C75 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Q 0.15fF
C76 divider_0/prescaler_0/tspc_0/Z2 divider_0/and_0/OUT 0.06fF
C77 divbuf_1/OUT2 divbuf_1/a_492_n240# 0.42fF
C78 pll_full_0/divbuf_0/OUT4 pll_full_0/divbuf_0/OUT5 20.26fF
C79 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C80 divbuf_10/a_492_n240# divbuf_10/OUT 0.00fF
C81 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z2 0.11fF
C82 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C83 pd_1/DIV pd_1/tspc_r_0/Z2 0.19fF
C84 pd_0/DOWN pd_0/R 0.36fF
C85 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z4 0.20fF
C86 pd_0/DIV pd_0/tspc_r_0/z5 0.04fF
C87 pd_0/tspc_r_0/Z1 pd_0/tspc_r_0/Z2 0.71fF
C88 cp_0/a_1710_0# cp_0/down 0.32fF
C89 divider_2/prescaler_0/tspc_1/Q divider_2/clk 0.60fF
C90 divbuf_13/OUT3 divbuf_13/OUT5 0.01fF
C91 divbuf_13/OUT2 divbuf_13/OUT 0.06fF
C92 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/cbank_0/switch_1/vin 0.19fF
C93 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_4/vin 0.20fF
C94 divider_1/tspc_0/Z4 divider_1/tspc_0/a_630_n680# 0.12fF
C95 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z3 0.11fF
C96 divider_0/prescaler_0/Out divider_0/tspc_2/Z2 0.11fF
C97 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/clk 0.01fF
C98 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C99 divbuf_5/a_492_n240# divbuf_5/IN 0.13fF
C100 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z3 0.06fF
C101 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C102 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C103 divbuf_16/OUT4 divbuf_16/OUT 1.11fF
C104 divbuf_6/OUT4 divbuf_6/OUT 1.11fF
C105 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C106 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/clk 0.01fF
C107 divider_2/nor_1/B divider_2/tspc_0/Z1 0.03fF
C108 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z4 0.01fF
C109 divbuf_8/a_492_n240# divbuf_8/OUT5 0.01fF
C110 pd_0/tspc_r_0/Z4 pd_0/tspc_r_1/Z4 0.02fF
C111 pd_0/DOWN pd_0/and_pd_0/Out1 0.12fF
C112 pd_0/REF pd_0/tspc_r_1/Z1 0.17fF
C113 pd_0/tspc_r_1/Qbar1 pd_0/UP 0.11fF
C114 divider_2/tspc_0/Z1 divider_2/tspc_0/Z3 0.06fF
C115 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_2/D 0.16fF
C116 divider_2/prescaler_0/tspc_0/Z2 divider_2/clk 0.11fF
C117 divbuf_19/IN divbuf_19/OUT5 0.00fF
C118 divbuf_1/OUT2 divbuf_1/OUT3 1.37fF
C119 ro_complete_0/a4 ro_complete_0/cbank_1/v 0.05fF
C120 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z4 0.12fF
C121 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z2 1.07fF
C122 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C123 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_2/Q 0.19fF
C124 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/clk 0.01fF
C125 divbuf_1/OUT5 divbuf_1/a_492_n240# 0.01fF
C126 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C127 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C128 divider_1/nor_1/B divider_1/nor_0/B 0.47fF
C129 divider_1/tspc_0/Z2 divider_1/tspc_0/Z1 1.07fF
C130 divbuf_21/OUT2 divbuf_21/OUT3 1.37fF
C131 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Q 0.22fF
C132 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/nor_1/B 0.35fF
C133 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C134 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C135 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/nor_0/A 0.35fF
C136 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/clk 0.29fF
C137 divbuf_18/OUT5 divbuf_18/a_492_n240# 0.01fF
C138 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Q 0.15fF
C139 divider_1/tspc_2/Z3 divider_1/tspc_2/Z4 0.65fF
C140 divbuf_12/OUT3 divbuf_12/OUT 0.26fF
C141 divbuf_12/OUT4 divbuf_12/OUT5 20.26fF
C142 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/z5 0.04fF
C143 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/cbank_1/switch_1/vin 0.19fF
C144 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z3 0.29fF
C145 divider_0/nor_0/B divider_0/tspc_2/Q 0.22fF
C146 divider_0/tspc_0/a_630_n680# divider_0/nor_1/B 0.35fF
C147 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z3 0.05fF
C148 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z4 0.08fF
C149 pll_full_0/pd_0/DIV pll_full_0/divider_0/clk 2.26fF
C150 pll_full_0/divbuf_0/OUT pll_full_0/divbuf_0/OUT5 43.38fF
C151 divider_1/prescaler_0/Out divider_1/clk 0.51fF
C152 divider_0/tspc_2/a_630_n680# divider_0/nor_0/A 0.35fF
C153 divider_0/prescaler_0/tspc_0/D divider_0/clk 0.29fF
C154 divbuf_3/IN divbuf_3/OUT5 0.00fF
C155 ro_complete_1/cbank_1/v ro_complete_1/cbank_2/v 1.36fF
C156 divbuf_19/OUT2 divbuf_19/OUT 0.06fF
C157 divbuf_20/OUT5 divbuf_20/OUT 43.38fF
C158 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_1/B 0.00fF
C159 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C160 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C161 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C162 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C163 divbuf_7/a_492_n240# divbuf_7/OUT 0.00fF
C164 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/A 0.01fF
C165 divbuf_17/a_492_n240# divbuf_17/OUT2 0.42fF
C166 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z2 0.25fF
C167 divider_2/prescaler_0/tspc_2/Z4 divider_2/clk 0.12fF
C168 divbuf_0/OUT divbuf_0/OUT2 0.06fF
C169 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/a_740_n680# 0.08fF
C170 divbuf_1/OUT3 divbuf_1/OUT5 0.01fF
C171 divider_0/tspc_1/a_630_n680# divider_0/nor_1/B 0.00fF
C172 divider_0/prescaler_0/tspc_1/Z2 divider_0/and_0/OUT 0.06fF
C173 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z3 0.33fF
C174 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Q 0.38fF
C175 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_0/D 0.11fF
C176 divider_0/nor_0/Z1 divider_0/and_0/A 0.80fF
C177 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT2 0.42fF
C178 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C179 divbuf_16/OUT2 divbuf_16/OUT 0.06fF
C180 divider_0/and_0/out1 divider_0/and_0/A 0.01fF
C181 divbuf_4/IN divbuf_4/OUT5 0.00fF
C182 divbuf_6/a_492_n240# divbuf_6/IN 0.13fF
C183 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C184 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/A 0.26fF
C185 divbuf_23/OUT4 divbuf_23/OUT 1.11fF
C186 pd_0/R pd_0/tspc_r_1/Z3 0.29fF
C187 divbuf_9/a_492_n240# divbuf_9/OUT5 0.01fF
C188 divider_2/tspc_2/Z2 divider_2/tspc_2/Z4 0.36fF
C189 ro_complete_0/a5 ro_complete_0/cbank_1/switch_0/vin 0.09fF
C190 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/v 1.30fF
C191 divider_0/tspc_0/Z2 divider_0/tspc_0/a_630_n680# 0.01fF
C192 ro_complete_1/a1 ro_complete_1/cbank_1/v 0.05fF
C193 divider_1/nor_1/Z1 divider_1/nor_0/B 0.18fF
C194 divider_1/tspc_0/Z4 divider_1/tspc_1/Q 0.15fF
C195 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/clk 0.01fF
C196 divider_0/nor_0/B divider_0/and_0/A 0.26fF
C197 divider_2/tspc_1/Q divider_2/tspc_1/a_630_n680# 0.04fF
C198 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C199 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z4 0.00fF
C200 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/divider_0/clk 1.46fF
C201 divider_2/nor_1/B divider_2/tspc_0/Z3 0.38fF
C202 divbuf_22/OUT2 divbuf_22/OUT3 1.37fF
C203 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/B 0.29fF
C204 pd_1/tspc_r_0/Qbar pd_1/tspc_r_0/Qbar1 0.01fF
C205 divider_2/mc2 divider_2/and_0/out1 0.06fF
C206 divider_2/tspc_2/Q divider_2/tspc_1/Z4 0.15fF
C207 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Z4 0.65fF
C208 divbuf_25/OUT3 divbuf_25/OUT 0.26fF
C209 divbuf_25/OUT4 divbuf_25/OUT5 20.26fF
C210 ro_complete_0/a1 ro_complete_0/cbank_1/v 0.05fF
C211 ro_complete_1/a0 ro_complete_1/cbank_2/v 0.05fF
C212 divider_0/nor_1/B divider_0/and_0/B 0.29fF
C213 divbuf_20/a_492_n240# divbuf_20/OUT2 0.42fF
C214 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z2 1.07fF
C215 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z3 0.38fF
C216 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_1/B 0.22fF
C217 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z3 0.11fF
C218 divbuf_11/OUT5 divbuf_11/OUT 43.38fF
C219 divbuf_24/a_492_n240# divbuf_24/OUT 0.00fF
C220 pd_1/R pd_1/tspc_r_1/Qbar 0.03fF
C221 divider_2/tspc_2/Q divider_2/tspc_2/Z3 0.05fF
C222 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z3 0.16fF
C223 ro_complete_0/a2 ro_complete_0/cbank_1/switch_3/vin 0.09fF
C224 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/tspc_r_1/z5 0.02fF
C225 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z2 0.25fF
C226 divbuf_2/IN divbuf_2/OUT5 0.00fF
C227 pll_full_0/divbuf_0/OUT pll_full_0/divbuf_0/a_492_n240# 0.00fF
C228 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT2 1.37fF
C229 divider_0/tspc_1/Z1 divider_0/tspc_1/Z2 1.07fF
C230 divider_0/nor_0/B divider_0/tspc_1/Z3 0.38fF
C231 divider_0/tspc_1/Q divider_0/nor_1/B 0.22fF
C232 divider_1/nor_0/B divider_1/tspc_2/a_630_n680# 0.01fF
C233 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/D 0.03fF
C234 divbuf_10/IN divbuf_10/OUT5 0.00fF
C235 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/and_0/OUT 0.05fF
C236 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/z5 0.20fF
C237 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Qbar1 0.38fF
C238 divider_2/tspc_0/Z4 divider_2/tspc_0/Z1 0.00fF
C239 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C240 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z3 0.33fF
C241 divbuf_23/a_492_n240# divbuf_23/IN 0.13fF
C242 divbuf_13/OUT4 divbuf_13/OUT 1.11fF
C243 pd_1/UP pd_1/and_pd_0/Out1 0.33fF
C244 divbuf_19/a_492_n240# divbuf_19/OUT 0.00fF
C245 divider_2/and_0/OUT divider_2/and_0/Z1 0.04fF
C246 divider_2/prescaler_0/tspc_2/Q divider_2/clk 0.05fF
C247 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C248 ro_complete_1/a4 ro_complete_1/cbank_0/switch_1/vin 0.09fF
C249 divbuf_2/OUT5 divbuf_2/a_492_n240# 0.01fF
C250 ro_complete_1/a3 ro_complete_1/cbank_2/switch_2/vin 0.09fF
C251 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C252 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C253 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z4 0.28fF
C254 divider_0/prescaler_0/tspc_2/Z2 divider_0/and_0/OUT 0.05fF
C255 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C256 divbuf_16/OUT3 divbuf_16/OUT 0.26fF
C257 divider_1/tspc_0/Z2 divider_1/tspc_0/Z3 0.16fF
C258 divider_1/prescaler_0/tspc_1/Q divider_1/nor_0/A 0.03fF
C259 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_0/A 0.15fF
C260 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C261 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C262 pd_1/tspc_r_0/Qbar pd_1/DOWN 0.21fF
C263 pd_0/tspc_r_0/z5 pd_0/tspc_r_1/z5 0.02fF
C264 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z2 0.25fF
C265 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z2 0.19fF
C266 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/nand_0/z1 0.07fF
C267 divider_2/prescaler_0/Out divider_2/clk 0.51fF
C268 divbuf_8/OUT2 divbuf_8/OUT3 1.37fF
C269 pll_full_0/pd_0/DOWN pll_full_0/pd_0/UP 4.58fF
C270 divider_0/tspc_0/Z2 divider_0/tspc_1/Q 0.14fF
C271 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z3 0.16fF
C272 ro_complete_0/a3 ro_complete_0/cbank_2/switch_2/vin 0.09fF
C273 pll_full_0/pd_0/DIV pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C274 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/v 1.30fF
C275 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Q 0.91fF
C276 divider_0/tspc_1/Z2 divider_0/nor_0/A 0.15fF
C277 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_0/D 0.32fF
C278 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/clk 0.01fF
C279 divbuf_21/OUT2 divbuf_21/OUT5 0.02fF
C280 divbuf_21/OUT3 divbuf_21/OUT4 5.16fF
C281 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C282 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C283 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/divider_0/clk 1.46fF
C284 divider_1/tspc_2/Q divider_1/tspc_2/a_630_n680# 0.04fF
C285 divbuf_11/a_492_n240# divbuf_11/OUT2 0.42fF
C286 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z2 0.01fF
C287 pd_1/R pd_1/tspc_r_0/Qbar1 0.01fF
C288 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C289 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Q 0.05fF
C290 divider_2/prescaler_0/m1_2700_2190# divider_2/clk 0.01fF
C291 divbuf_12/OUT5 divbuf_12/OUT 43.38fF
C292 divbuf_14/a_492_n240# divbuf_14/OUT 0.00fF
C293 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a4 0.12fF
C294 pll_full_0/pd_0/R pll_full_0/pd_0/UP 0.46fF
C295 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/a_630_n680# 0.05fF
C296 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z4 0.12fF
C297 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z2 1.07fF
C298 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/v 1.30fF
C299 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C300 divbuf_3/OUT3 divbuf_3/OUT5 0.01fF
C301 divbuf_3/OUT2 divbuf_3/OUT 0.06fF
C302 divbuf_18/OUT divbuf_18/OUT3 0.26fF
C303 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z2 0.01fF
C304 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z2 0.01fF
C305 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z3 0.45fF
C306 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C307 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C308 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C309 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/clk 0.01fF
C310 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/Out 0.21fF
C311 divider_1/mc2 divider_1/and_0/out1 0.06fF
C312 pd_0/DIV pd_0/tspc_r_0/Qbar1 0.12fF
C313 divider_2/mc2 divider_2/nor_0/B 0.06fF
C314 divbuf_7/IN divbuf_7/OUT5 0.00fF
C315 pd_1/R pd_1/and_pd_0/Z1 0.02fF
C316 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/Qbar 0.01fF
C317 divbuf_19/a_492_n240# divbuf_19/IN 0.13fF
C318 divbuf_13/a_492_n240# divbuf_13/IN 0.13fF
C319 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_4/vin 0.20fF
C320 pll_full_0/pd_0/UP pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C321 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z2 0.01fF
C322 divider_0/tspc_2/Q divider_0/tspc_1/Z3 0.45fF
C323 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z3 0.05fF
C324 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z4 0.08fF
C325 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Q 0.04fF
C326 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/a_492_n240# 0.01fF
C327 divbuf_4/OUT3 divbuf_4/OUT5 0.01fF
C328 divbuf_4/OUT2 divbuf_4/OUT 0.06fF
C329 divider_2/nor_1/B divider_2/tspc_0/Z4 0.22fF
C330 pd_0/R pd_0/UP 0.45fF
C331 divider_2/tspc_0/Z4 divider_2/tspc_0/Z3 0.65fF
C332 divbuf_9/OUT2 divbuf_9/OUT3 1.37fF
C333 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C334 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/a_740_n680# 0.19fF
C335 divbuf_1/OUT4 divbuf_1/OUT5 20.26fF
C336 io_clamp_high[0] io_analog[4] 0.53fF
C337 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C338 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C339 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_1/B 0.06fF
C340 divbuf_22/OUT2 divbuf_22/OUT5 0.02fF
C341 divbuf_22/OUT3 divbuf_22/OUT4 5.16fF
C342 divider_2/tspc_0/Z2 divider_2/nor_0/B 0.20fF
C343 pd_1/DOWN pd_1/R 0.36fF
C344 pd_0/UP pd_0/and_pd_0/Out1 0.33fF
C345 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/DOWN 0.11fF
C346 divider_2/mc2 divider_2/and_0/A 0.16fF
C347 divbuf_12/a_492_n240# divbuf_12/OUT2 0.42fF
C348 pll_full_0/pd_0/DIV pll_full_0/divbuf_1/OUT2 0.06fF
C349 divbuf_25/OUT5 divbuf_25/OUT 43.38fF
C350 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z1 0.08fF
C351 divider_0/mc2 divider_0/nor_1/B 0.15fF
C352 divbuf_0/OUT2 divbuf_0/OUT5 0.02fF
C353 divbuf_18/OUT4 divbuf_18/OUT3 5.16fF
C354 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C355 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z4 0.21fF
C356 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/nor_1/B 0.38fF
C357 divider_1/nor_0/B divider_1/tspc_1/Z2 0.30fF
C358 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z2 0.01fF
C359 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/B 0.08fF
C360 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z4 0.28fF
C361 divider_1/and_0/out1 divider_1/and_0/B 0.18fF
C362 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/R 0.01fF
C363 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_2/Q 0.19fF
C364 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/clk 0.01fF
C365 divbuf_24/IN divbuf_24/OUT5 0.00fF
C366 divbuf_0/OUT3 divbuf_0/OUT2 1.37fF
C367 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/a4 0.12fF
C368 ro_complete_0/a2 ro_complete_0/cbank_0/switch_3/vin 0.09fF
C369 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Qbar 0.01fF
C370 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z4 0.36fF
C371 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/Out 0.05fF
C372 divider_0/nor_0/B divider_0/tspc_1/Z4 0.21fF
C373 divider_0/tspc_0/Z3 divider_0/nor_1/B 0.38fF
C374 divbuf_2/OUT3 divbuf_2/OUT5 0.01fF
C375 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C376 divider_0/nor_0/A divider_0/and_0/B 0.08fF
C377 divbuf_4/a_492_n240# divbuf_4/OUT2 0.42fF
C378 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z2 1.07fF
C379 divbuf_10/OUT3 divbuf_10/OUT5 0.01fF
C380 divbuf_10/OUT2 divbuf_10/OUT 0.06fF
C381 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C382 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C383 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/clk 0.11fF
C384 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/Z3 0.06fF
C385 divider_1/and_0/OUT divider_1/prescaler_0/nand_0/z1 0.01fF
C386 divider_1/nor_0/B divider_1/nor_0/A 1.21fF
C387 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Q 0.91fF
C388 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z3 0.05fF
C389 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z4 0.08fF
C390 pll_full_0/pd_0/DIV pll_full_0/divbuf_1/a_492_n240# 0.00fF
C391 divider_2/tspc_2/a_630_n680# divider_2/nor_0/A 0.35fF
C392 divider_2/prescaler_0/tspc_0/D divider_2/clk 0.29fF
C393 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a5 0.09fF
C394 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C395 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/cbank_0/v 1.30fF
C396 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/D 0.09fF
C397 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Q 0.20fF
C398 divider_0/prescaler_0/tspc_0/Z2 divider_0/clk 0.11fF
C399 divider_2/tspc_1/Q divider_2/tspc_0/Z1 0.01fF
C400 divider_1/mc2 divider_1/nor_0/B 0.06fF
C401 divider_1/tspc_2/Q divider_1/tspc_1/Z2 0.14fF
C402 divider_1/tspc_0/Z2 divider_1/tspc_0/a_630_n680# 0.01fF
C403 divbuf_5/a_492_n240# divbuf_5/OUT5 0.01fF
C404 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_1/Q 0.01fF
C405 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C406 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/Out 0.05fF
C407 pll_full_0/ro_complete_0/a2 pll_full_0/divider_0/clk 0.11fF
C408 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C409 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C410 divider_1/and_0/OUT divider_1/clk 0.04fF
C411 divbuf_8/OUT2 divbuf_8/OUT5 0.02fF
C412 divbuf_8/OUT3 divbuf_8/OUT4 5.16fF
C413 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/Qbar 0.01fF
C414 divbuf_17/OUT3 divbuf_17/OUT2 1.37fF
C415 divider_2/tspc_2/Q divider_2/tspc_1/a_630_n680# 0.01fF
C416 divider_2/prescaler_0/tspc_1/Z2 divider_2/and_0/OUT 0.06fF
C417 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z3 0.33fF
C418 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Q 0.38fF
C419 divider_2/and_0/out1 divider_2/and_0/A 0.01fF
C420 divbuf_25/a_492_n240# divbuf_25/OUT2 0.42fF
C421 ro_complete_1/a4 ro_complete_1/cbank_2/switch_0/vin 0.12fF
C422 ro_complete_0/a5 ro_complete_0/cbank_1/v 0.10fF
C423 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/a0 0.09fF
C424 divbuf_16/a_492_n240# divbuf_16/OUT5 0.01fF
C425 divider_0/tspc_0/Z2 divider_0/tspc_0/Z3 0.16fF
C426 divider_0/tspc_0/a_630_n680# divider_0/tspc_1/Q 0.01fF
C427 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z4 0.36fF
C428 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/Out 0.05fF
C429 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/D 0.09fF
C430 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/nand_1/z1 0.22fF
C431 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/tspc_0/D 0.04fF
C432 divider_1/tspc_2/Q divider_1/nor_0/A 0.55fF
C433 divider_1/nor_0/B divider_1/tspc_1/Z1 0.03fF
C434 divbuf_21/OUT3 divbuf_21/OUT 0.26fF
C435 divbuf_21/OUT4 divbuf_21/OUT5 20.26fF
C436 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.04fF
C437 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C438 pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_0/divider_0/clk 1.58fF
C439 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z2 0.23fF
C440 divider_1/nor_0/A divider_1/and_0/A 0.01fF
C441 pd_1/tspc_r_0/z5 pd_1/tspc_r_0/Z3 0.11fF
C442 divbuf_19/OUT3 divbuf_19/OUT 0.26fF
C443 divbuf_19/OUT4 divbuf_19/OUT5 20.26fF
C444 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/clk 0.01fF
C445 divbuf_14/IN divbuf_14/OUT5 0.00fF
C446 divbuf_1/OUT2 divbuf_1/OUT 0.06fF
C447 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/a0 0.13fF
C448 pll_full_0/divbuf_0/OUT pll_full_0/divbuf_0/OUT2 0.06fF
C449 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a4 0.12fF
C450 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C451 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/a_630_n680# 0.12fF
C452 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z1 1.07fF
C453 divider_0/tspc_1/Q divider_0/tspc_1/a_630_n680# 0.04fF
C454 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z3 0.16fF
C455 divbuf_3/OUT4 divbuf_3/OUT 1.11fF
C456 divbuf_18/OUT divbuf_18/OUT5 43.38fF
C457 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z2 0.01fF
C458 divider_0/nor_0/A divider_0/tspc_2/Z2 0.23fF
C459 divider_1/prescaler_0/m1_2700_2190# divider_1/nor_0/A 0.01fF
C460 divider_1/mc2 divider_1/and_0/A 0.16fF
C461 divider_1/tspc_1/Z2 divider_1/tspc_1/Z3 0.16fF
C462 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/D 0.15fF
C463 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z4 0.15fF
C464 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/nor_1/B 0.22fF
C465 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C466 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C467 pd_0/tspc_r_0/Z3 pd_0/DOWN 0.03fF
C468 divbuf_7/OUT3 divbuf_7/OUT5 0.01fF
C469 divbuf_7/OUT2 divbuf_7/OUT 0.06fF
C470 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/Z1 0.36fF
C471 divbuf_17/OUT5 divbuf_17/IN 0.00fF
C472 divider_2/nor_1/B divider_2/and_0/B 0.29fF
C473 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z4 0.20fF
C474 pd_1/REF pd_1/tspc_r_1/z5 0.04fF
C475 pd_1/tspc_r_1/Z1 pd_1/tspc_r_1/Z2 0.71fF
C476 pll_full_0/pd_0/DOWN pll_full_0/cp_0/a_1710_0# 0.04fF
C477 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a3 0.13fF
C478 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C479 divider_1/prescaler_0/Out divider_1/prescaler_0/m1_2700_2190# 0.11fF
C480 divider_0/tspc_2/Q divider_0/tspc_1/Z4 0.15fF
C481 divider_0/tspc_0/Z4 divider_0/nor_1/B 0.22fF
C482 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z4 0.12fF
C483 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z2 1.07fF
C484 divbuf_4/OUT4 divbuf_4/OUT 1.11fF
C485 divider_1/tspc_2/Q divider_1/tspc_1/Z1 0.01fF
C486 divider_1/tspc_1/a_630_n680# divider_1/nor_0/B 0.35fF
C487 divider_0/and_0/out1 divider_0/and_0/Z1 0.36fF
C488 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C489 divider_1/nor_0/B divider_1/and_0/B 0.31fF
C490 divbuf_6/a_492_n240# divbuf_6/OUT5 0.01fF
C491 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/Z3 0.05fF
C492 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/clk 0.11fF
C493 pd_1/DIV pd_1/tspc_r_0/z5 0.04fF
C494 divbuf_9/OUT2 divbuf_9/OUT5 0.02fF
C495 divbuf_9/OUT3 divbuf_9/OUT4 5.16fF
C496 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/v 1.30fF
C497 divbuf_1/OUT5 divbuf_1/OUT 43.38fF
C498 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/a0 0.09fF
C499 divider_2/tspc_1/Q divider_2/nor_1/B 0.22fF
C500 divider_0/tspc_2/Q divider_0/tspc_2/Z3 0.05fF
C501 divider_0/prescaler_0/tspc_1/Z2 divider_0/clk 0.11fF
C502 divider_2/tspc_1/Q divider_2/tspc_0/Z3 0.45fF
C503 divider_1/tspc_0/Z2 divider_1/tspc_1/Q 0.14fF
C504 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z3 0.06fF
C505 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C506 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C507 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z3 0.05fF
C508 divider_1/nor_0/A divider_1/tspc_2/Z1 0.03fF
C509 divbuf_22/OUT3 divbuf_22/OUT 0.26fF
C510 divbuf_22/OUT4 divbuf_22/OUT5 20.26fF
C511 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z2 0.25fF
C512 divbuf_18/a_492_n240# divbuf_18/IN 0.13fF
C513 divider_2/prescaler_0/tspc_2/Z2 divider_2/and_0/OUT 0.05fF
C514 pll_full_0/pd_0/DIV pll_full_0/divbuf_1/OUT4 1.11fF
C515 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C516 ro_complete_0/a0 ro_complete_0/cbank_2/switch_4/vin 0.13fF
C517 ro_complete_0/cbank_0/v ro_complete_0/cbank_1/v 1.27fF
C518 divider_0/tspc_0/Z2 divider_0/tspc_0/Z4 0.36fF
C519 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z3 0.11fF
C520 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C521 divbuf_3/a_492_n240# divbuf_3/IN 0.13fF
C522 ro_complete_1/cbank_2/switch_2/vin ro_complete_1/cbank_2/v 1.30fF
C523 divbuf_18/OUT4 divbuf_18/OUT5 20.26fF
C524 divider_1/tspc_2/Q divider_1/tspc_1/a_630_n680# 0.01fF
C525 divbuf_20/a_492_n240# divbuf_20/OUT 0.00fF
C526 divider_2/nor_0/Z1 divider_2/nor_0/B 0.06fF
C527 divider_1/tspc_1/Z1 divider_1/tspc_1/Z3 0.06fF
C528 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C529 pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_0/divider_0/clk 1.46fF
C530 divider_1/and_0/A divider_1/and_0/B 0.18fF
C531 divbuf_24/OUT3 divbuf_24/OUT5 0.01fF
C532 divbuf_24/OUT2 divbuf_24/OUT 0.06fF
C533 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/z5 0.11fF
C534 divider_2/tspc_1/Z2 divider_2/nor_0/A 0.15fF
C535 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_0/D 0.32fF
C536 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/clk 0.01fF
C537 divider_2/nor_0/B divider_2/and_0/A 0.26fF
C538 ro_complete_0/a2 ro_complete_0/cbank_2/switch_3/vin 0.09fF
C539 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z4 0.20fF
C540 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C541 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/pd_0/tspc_r_1/Z2 0.71fF
C542 divider_0/mc2 divider_0/nor_0/A 0.04fF
C543 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C544 ro_complete_1/a5 ro_complete_1/cbank_2/switch_0/vin 0.09fF
C545 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/OUT2 0.02fF
C546 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a3 0.13fF
C547 divider_1/nor_0/Z1 divider_1/and_0/B 0.18fF
C548 divbuf_10/OUT4 divbuf_10/OUT 1.11fF
C549 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/Z4 0.00fF
C550 divider_1/prescaler_0/tspc_2/D divider_1/prescaler_0/nand_0/z1 0.24fF
C551 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Z4 0.65fF
C552 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C553 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/clk 0.51fF
C554 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z4 0.12fF
C555 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z2 1.07fF
C556 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_0/D 0.09fF
C557 divbuf_23/a_492_n240# divbuf_23/OUT5 0.01fF
C558 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Out1 0.05fF
C559 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z2 0.01fF
C560 divider_1/Out divider_1/nor_1/B 0.22fF
C561 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C562 divider_0/tspc_1/Z3 divider_0/tspc_1/Z4 0.65fF
C563 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Q 0.04fF
C564 divider_0/prescaler_0/Out divider_0/clk 0.51fF
C565 divbuf_2/OUT2 divbuf_2/OUT 0.06fF
C566 divbuf_5/OUT2 divbuf_5/OUT3 1.37fF
C567 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z3 0.05fF
C568 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z3 0.05fF
C569 divider_2/nor_1/B divider_2/tspc_0/a_630_n680# 0.35fF
C570 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z4 0.65fF
C571 divider_2/nor_0/Z1 divider_2/and_0/A 0.80fF
C572 divider_1/and_0/OUT divider_1/and_0/out1 0.31fF
C573 divider_1/prescaler_0/tspc_2/D divider_1/clk 0.26fF
C574 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C575 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/clk 0.11fF
C576 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z4 0.20fF
C577 pd_0/REF pd_0/tspc_r_1/z5 0.04fF
C578 pd_0/tspc_r_1/Z1 pd_0/tspc_r_1/Z2 0.71fF
C579 divider_2/tspc_1/Z1 divider_2/tspc_1/Z2 1.07fF
C580 divider_2/nor_0/B divider_2/tspc_1/Z3 0.38fF
C581 divider_2/tspc_0/a_630_n680# divider_2/tspc_0/Z3 0.05fF
C582 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z3 0.05fF
C583 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z4 0.08fF
C584 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Q 0.04fF
C585 divbuf_8/OUT3 divbuf_8/OUT 0.26fF
C586 divbuf_8/OUT4 divbuf_8/OUT5 20.26fF
C587 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_1/Qbar 0.02fF
C588 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z3 0.05fF
C589 ro_complete_0/a2 ro_complete_0/cbank_2/v 0.05fF
C590 divbuf_15/OUT divbuf_15/OUT5 43.38fF
C591 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/nand_1/z1 0.01fF
C592 divider_0/prescaler_0/tspc_2/Z2 divider_0/clk 0.11fF
C593 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/IN 0.13fF
C594 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C595 divbuf_21/OUT5 divbuf_21/OUT 43.38fF
C596 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C597 divider_1/nor_0/B divider_1/tspc_1/Q 0.51fF
C598 divbuf_11/a_492_n240# divbuf_11/OUT 0.00fF
C599 divider_2/prescaler_0/Out divider_2/prescaler_0/m1_2700_2190# 0.11fF
C600 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z3 0.06fF
C601 cp_0/a_1710_n2840# cp_0/upbar 0.29fF
C602 pd_1/R pd_1/REF 0.61fF
C603 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/switch_1/vin 0.19fF
C604 divbuf_14/OUT3 divbuf_14/OUT5 0.01fF
C605 divbuf_14/OUT2 divbuf_14/OUT 0.06fF
C606 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar 0.03fF
C607 divbuf_16/a_492_n240# divbuf_16/OUT2 0.42fF
C608 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z4 0.36fF
C609 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C610 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C611 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C612 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/Out 0.04fF
C613 divider_0/tspc_2/Z1 divider_0/tspc_2/Z3 0.06fF
C614 divbuf_10/a_492_n240# divbuf_10/IN 0.13fF
C615 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C616 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C617 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/clk 0.14fF
C618 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/B 0.78fF
C619 divider_1/tspc_1/Z2 divider_1/tspc_1/Z4 0.36fF
C620 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/D 0.05fF
C621 divbuf_7/OUT4 divbuf_7/OUT 1.11fF
C622 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z1 0.09fF
C623 pd_0/DIV pd_0/tspc_r_0/Z2 0.19fF
C624 divbuf_17/OUT5 divbuf_17/OUT2 0.02fF
C625 divider_2/mc2 divider_2/prescaler_0/tspc_2/a_630_n680# 0.33fF
C626 cp_0/upbar cp_0/down 0.02fF
C627 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/z5 0.20fF
C628 divbuf_13/a_492_n240# divbuf_13/OUT5 0.01fF
C629 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Out1 0.05fF
C630 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C631 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z3 0.16fF
C632 divider_0/mc2 divider_0/and_0/B 0.20fF
C633 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/v 1.30fF
C634 pll_full_0/divbuf_0/OUT2 pll_full_0/divbuf_0/a_492_n240# 0.42fF
C635 divider_2/tspc_1/Q divider_2/tspc_0/Z4 0.15fF
C636 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C637 divbuf_6/OUT2 divbuf_6/OUT3 1.37fF
C638 divider_2/nor_1/Z1 divider_2/nor_0/B 0.18fF
C639 divider_1/tspc_1/Z4 divider_1/nor_0/A 0.02fF
C640 pd_0/R pd_0/tspc_r_1/Qbar 0.03fF
C641 divbuf_18/OUT3 divbuf_18/OUT2 1.37fF
C642 pd_1/and_pd_0/Out1 pd_1/and_pd_0/Z1 0.18fF
C643 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/z5 0.03fF
C644 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/R 0.21fF
C645 divider_2/nor_0/A divider_2/and_0/B 0.08fF
C646 divbuf_9/OUT3 divbuf_9/OUT 0.26fF
C647 divbuf_9/OUT4 divbuf_9/OUT5 20.26fF
C648 divider_0/nor_1/Z1 divider_0/nor_0/B 0.18fF
C649 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C650 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z4 0.00fF
C651 divbuf_21/a_492_n240# divbuf_21/OUT2 0.42fF
C652 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z4 0.12fF
C653 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z3 0.45fF
C654 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/nor_1/B 0.40fF
C655 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C656 divbuf_22/OUT5 divbuf_22/OUT 43.38fF
C657 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/B 0.01fF
C658 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z4 0.12fF
C659 divider_1/tspc_2/Z1 divider_1/tspc_2/Z2 1.07fF
C660 divider_1/nor_0/A divider_1/tspc_2/Z3 0.38fF
C661 divbuf_12/a_492_n240# divbuf_12/OUT 0.00fF
C662 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Out1 0.05fF
C663 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/Qbar 0.01fF
C664 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/D 0.09fF
C665 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Q 0.20fF
C666 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Z1 0.07fF
C667 ro_complete_1/a4 ro_complete_1/cbank_1/v 0.05fF
C668 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C669 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z4 0.12fF
C670 divider_0/tspc_1/Q divider_0/tspc_0/Z3 0.45fF
C671 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z4 0.28fF
C672 divider_1/prescaler_0/Out divider_1/tspc_2/Z3 0.45fF
C673 divider_0/and_0/OUT divider_0/and_0/B 0.01fF
C674 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/switch_5/vin 0.20fF
C675 divider_1/tspc_1/Q divider_1/tspc_1/Z3 0.05fF
C676 divider_1/tspc_1/Z1 divider_1/tspc_1/Z4 0.00fF
C677 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z3 0.06fF
C678 divbuf_20/IN divbuf_20/OUT5 0.00fF
C679 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C680 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C681 divbuf_7/a_492_n240# divbuf_7/IN 0.13fF
C682 divbuf_24/OUT4 divbuf_24/OUT 1.11fF
C683 cp_0/a_1710_n2840# cp_0/out 0.61fF
C684 pd_1/DOWN pd_1/and_pd_0/Out1 0.12fF
C685 pd_1/REF pd_1/tspc_r_1/Qbar1 0.12fF
C686 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/nand_1/z1 0.22fF
C687 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/tspc_0/D 0.04fF
C688 ro_complete_0/a2 ro_complete_0/cbank_0/switch_2/vin 0.14fF
C689 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a4 0.09fF
C690 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/a5 0.09fF
C691 pll_full_0/cp_0/upbar pll_full_0/cp_0/down 0.02fF
C692 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C693 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/z5 0.20fF
C694 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT2 0.02fF
C695 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Q 0.91fF
C696 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C697 divbuf_4/a_492_n240# divbuf_4/OUT 0.00fF
C698 divbuf_17/a_492_n240# divbuf_17/OUT5 0.01fF
C699 divbuf_17/OUT4 divbuf_17/OUT3 5.16fF
C700 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/Q 0.04fF
C701 divider_1/prescaler_0/tspc_1/Z3 divider_1/clk 0.45fF
C702 divbuf_23/OUT2 divbuf_23/OUT3 1.37fF
C703 divider_2/tspc_0/Z4 divider_2/tspc_0/a_630_n680# 0.12fF
C704 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z3 0.16fF
C705 divider_2/nor_0/A divider_2/tspc_2/Z2 0.23fF
C706 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/and_pd_0/Z1 0.18fF
C707 divbuf_2/OUT4 divbuf_2/OUT 1.11fF
C708 ro_complete_1/a2 ro_complete_1/cbank_2/v 0.05fF
C709 io_clamp_low[2] io_analog[6] 0.53fF
C710 divider_1/mc2 divider_1/prescaler_0/tspc_2/a_630_n680# 0.33fF
C711 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z4 0.12fF
C712 divbuf_5/OUT2 divbuf_5/OUT5 0.02fF
C713 divbuf_5/OUT3 divbuf_5/OUT4 5.16fF
C714 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C715 divbuf_22/a_492_n240# divbuf_22/OUT2 0.42fF
C716 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C717 divbuf_8/OUT5 divbuf_8/OUT 43.38fF
C718 pd_0/R pd_0/and_pd_0/Z1 0.02fF
C719 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/z5 0.20fF
C720 divider_2/nor_0/B divider_2/tspc_1/Z4 0.21fF
C721 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z4 0.12fF
C722 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z2 1.07fF
C723 divbuf_25/a_492_n240# divbuf_25/OUT 0.00fF
C724 divider_2/and_0/out1 divider_2/and_0/Z1 0.36fF
C725 divbuf_0/a_492_n240# divbuf_0/IN 0.13fF
C726 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/a_492_n240# 0.01fF
C727 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C728 ro_complete_1/cbank_1/switch_5/vin ro_complete_1/cbank_1/v 1.30fF
C729 divbuf_15/a_492_n240# divbuf_15/OUT5 0.01fF
C730 divider_0/prescaler_0/tspc_0/D divider_0/prescaler_0/nand_1/z1 0.21fF
C731 divider_1/prescaler_0/m1_2700_2190# divider_1/and_0/OUT 0.14fF
C732 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z4 0.15fF
C733 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C734 pll_full_0/ro_complete_0/a0 pll_full_0/divider_0/clk 0.11fF
C735 divbuf_11/IN divbuf_11/OUT5 0.00fF
C736 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z4 0.00fF
C737 divbuf_24/a_492_n240# divbuf_24/IN 0.13fF
C738 pd_1/R pd_1/tspc_r_1/Qbar1 0.30fF
C739 pd_1/tspc_r_0/Z3 pd_1/tspc_r_0/Qbar1 0.38fF
C740 pd_0/and_pd_0/Out1 pd_0/and_pd_0/Z1 0.18fF
C741 divider_2/tspc_2/Q divider_2/tspc_2/a_630_n680# 0.04fF
C742 divider_2/prescaler_0/tspc_1/Z2 divider_2/clk 0.11fF
C743 divbuf_14/OUT4 divbuf_14/OUT 1.11fF
C744 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Qbar1 0.12fF
C745 ro_complete_0/a0 ro_complete_0/cbank_2/switch_5/vin 0.09fF
C746 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C747 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a4 0.09fF
C748 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a5 0.09fF
C749 divider_0/tspc_1/Q divider_0/tspc_0/Z4 0.15fF
C750 divider_0/tspc_2/Z1 divider_0/tspc_2/Z4 0.00fF
C751 divider_1/prescaler_0/tspc_2/Z4 divider_1/prescaler_0/tspc_2/D 0.11fF
C752 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C753 pd_0/DIV pd_0/R 0.51fF
C754 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/a_630_n680# 0.19fF
C755 divbuf_13/OUT2 divbuf_13/OUT3 1.37fF
C756 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/tspc_r_0/Z2 0.71fF
C757 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/a2 0.09fF
C758 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/v 1.30fF
C759 pll_full_0/pd_0/DIV pll_full_0/divbuf_1/IN 5.26fF
C760 ro_complete_1/a5 ro_complete_1/cbank_1/v 0.10fF
C761 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_0/vin 0.19fF
C762 divider_1/tspc_0/Z4 divider_1/tspc_0/Z2 0.36fF
C763 divider_1/Out divider_1/tspc_0/Z3 0.05fF
C764 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z4 0.36fF
C765 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C766 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z2 0.01fF
C767 divider_1/prescaler_0/tspc_2/Z3 divider_1/clk 0.45fF
C768 divbuf_6/OUT2 divbuf_6/OUT5 0.02fF
C769 divbuf_6/OUT3 divbuf_6/OUT4 5.16fF
C770 pd_1/DIV pd_1/tspc_r_0/Qbar1 0.12fF
C771 pd_0/REF pd_0/tspc_r_1/Qbar1 0.12fF
C772 divbuf_18/OUT5 divbuf_18/OUT2 0.02fF
C773 divider_2/prescaler_0/Out divider_2/tspc_2/Z3 0.45fF
C774 divbuf_8/a_492_n240# divbuf_8/OUT2 0.42fF
C775 divbuf_9/OUT5 divbuf_9/OUT 43.38fF
C776 filter_0/a_4216_n2998# filter_0/v 0.31fF
C777 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z4 0.14fF
C778 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z2 0.01fF
C779 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/Out 0.21fF
C780 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/a2 0.09fF
C781 ro_complete_1/a4 ro_complete_1/cbank_2/switch_1/vin 0.09fF
C782 ro_complete_1/a0 ro_complete_1/cbank_1/switch_5/vin 0.09fF
C783 divbuf_16/OUT5 divbuf_16/OUT4 20.26fF
C784 pll_full_0/ro_complete_0/a3 pll_full_0/divider_0/clk 0.11fF
C785 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Z4 0.65fF
C786 divider_1/tspc_2/Z2 divider_1/tspc_2/Z3 0.16fF
C787 divider_1/nor_0/A divider_1/tspc_2/Z4 0.21fF
C788 pd_1/DOWN pd_1/tspc_r_0/Z3 0.03fF
C789 divider_2/tspc_1/Z3 divider_2/tspc_1/Z4 0.65fF
C790 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Q 0.04fF
C791 divbuf_12/IN divbuf_12/OUT5 0.00fF
C792 divbuf_14/a_492_n240# divbuf_14/IN 0.13fF
C793 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C794 divider_0/mc2 divider_0/and_0/OUT 0.05fF
C795 divider_0/tspc_0/Z1 divider_0/nor_1/B 0.03fF
C796 divbuf_3/a_492_n240# divbuf_3/OUT5 0.01fF
C797 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/v 1.30fF
C798 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C799 divider_1/prescaler_0/Out divider_1/tspc_2/Z4 0.12fF
C800 divbuf_20/OUT3 divbuf_20/OUT5 0.01fF
C801 divbuf_20/OUT2 divbuf_20/OUT 0.06fF
C802 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C803 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z4 0.00fF
C804 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Q 0.21fF
C805 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z3 0.65fF
C806 divbuf_19/OUT3 divbuf_19/OUT4 5.16fF
C807 divider_1/and_0/B divider_1/and_0/Z1 0.07fF
C808 pd_1/tspc_r_1/Z3 pd_1/UP 0.03fF
C809 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/nand_1/z1 0.01fF
C810 divider_2/prescaler_0/tspc_2/Z2 divider_2/clk 0.11fF
C811 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/D 0.09fF
C812 ro_complete_0/cbank_1/v ro_complete_0/cbank_2/v 1.36fF
C813 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT4 20.26fF
C814 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C815 pll_full_0/filter_0/a_4216_n5230# pll_full_0/divider_0/clk 1.58fF
C816 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C817 divider_1/prescaler_0/tspc_1/Z4 divider_1/clk 0.12fF
C818 pd_0/DOWN pd_0/UP 0.46fF
C819 pd_0/tspc_r_0/Z4 pd_0/tspc_r_0/z5 0.04fF
C820 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z4 0.36fF
C821 divbuf_23/OUT2 divbuf_23/OUT5 0.02fF
C822 divbuf_23/OUT3 divbuf_23/OUT4 5.16fF
C823 divider_2/tspc_2/Z1 divider_2/tspc_2/Z3 0.06fF
C824 divbuf_9/a_492_n240# divbuf_9/OUT2 0.42fF
C825 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_0/vin 0.19fF
C826 divider_0/tspc_0/Z1 divider_0/tspc_0/Z2 1.07fF
C827 divbuf_16/OUT5 divbuf_16/OUT2 0.02fF
C828 divider_1/tspc_0/Z4 divider_1/nor_0/B 0.02fF
C829 divider_1/nor_1/Z1 divider_1/nor_1/B 0.06fF
C830 divbuf_15/IN divbuf_15/OUT5 0.00fF
C831 ro_complete_1/cbank_1/switch_2/vin ro_complete_1/cbank_1/v 1.30fF
C832 divbuf_5/OUT3 divbuf_5/OUT 0.26fF
C833 divbuf_5/OUT4 divbuf_5/OUT5 20.26fF
C834 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C835 divider_2/tspc_1/Q divider_2/tspc_0/a_630_n680# 0.01fF
C836 divider_1/prescaler_0/tspc_1/Q divider_1/clk 0.60fF
C837 pd_1/tspc_r_0/Z1 pd_1/tspc_r_0/Z3 0.09fF
C838 divider_2/tspc_2/Q divider_2/tspc_1/Z2 0.14fF
C839 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C840 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z3 0.16fF
C841 divbuf_25/IN divbuf_25/OUT5 0.00fF
C842 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/v 1.30fF
C843 divider_0/prescaler_0/Out divider_0/prescaler_0/m1_2700_2190# 0.11fF
C844 ro_complete_1/cbank_0/v ro_complete_1/cbank_2/v 0.04fF
C845 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_1/B 0.47fF
C846 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/Z4 0.65fF
C847 divbuf_17/OUT4 divbuf_17/OUT5 20.26fF
C848 divider_1/nor_1/B divider_1/tspc_0/Z1 0.03fF
C849 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_2/D 0.16fF
C850 divbuf_11/OUT3 divbuf_11/OUT5 0.01fF
C851 divbuf_11/OUT2 divbuf_11/OUT 0.06fF
C852 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divider_0/tspc_2/Z4 0.65fF
C853 divider_2/tspc_2/Q divider_2/nor_0/A 0.55fF
C854 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/UP 0.03fF
C855 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_4/vin 0.20fF
C856 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_4/vin 0.20fF
C857 ro_complete_0/a0 ro_complete_0/cbank_2/v 0.05fF
C858 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/a_630_n680# 0.19fF
C859 divider_0/nor_0/B divider_0/nor_1/B 0.47fF
C860 divider_0/tspc_0/Z3 divider_0/tspc_0/Z4 0.65fF
C861 divbuf_15/OUT5 divbuf_15/OUT4 20.26fF
C862 divider_0/tspc_2/Z3 divider_0/tspc_2/Z4 0.65fF
C863 divbuf_10/a_492_n240# divbuf_10/OUT5 0.01fF
C864 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C865 pd_1/DIV pd_1/tspc_r_0/Z1 0.17fF
C866 pd_0/tspc_r_0/Qbar1 pd_0/R 0.01fF
C867 pd_0/DIV pd_0/tspc_r_0/Z4 0.02fF
C868 pd_0/DOWN pd_0/tspc_r_0/Qbar 0.21fF
C869 pll_full_0/pd_0/DIV pll_full_0/divbuf_1/OUT5 43.38fF
C870 divider_2/and_0/OUT divider_2/and_0/B 0.01fF
C871 divbuf_13/OUT2 divbuf_13/OUT5 0.02fF
C872 divbuf_13/OUT3 divbuf_13/OUT4 5.16fF
C873 divbuf_2/OUT2 divbuf_2/a_492_n240# 0.42fF
C874 divider_1/Out divider_1/tspc_0/a_630_n680# 0.04fF
C875 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z2 0.19fF
C876 divbuf_15/OUT2 divbuf_15/OUT5 0.02fF
C877 divider_0/nor_0/B divider_0/tspc_2/a_630_n680# 0.01fF
C878 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C879 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_1/Q 0.14fF
C880 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/Out 0.04fF
C881 divbuf_6/OUT3 divbuf_6/OUT 0.26fF
C882 divbuf_6/OUT4 divbuf_6/OUT5 20.26fF
C883 divider_1/prescaler_0/tspc_2/Z4 divider_1/clk 0.12fF
C884 pd_0/tspc_r_1/Z3 pd_0/UP 0.03fF
C885 divider_2/tspc_1/Z1 divider_2/tspc_2/Q 0.01fF
C886 divider_2/prescaler_0/Out divider_2/tspc_2/Z4 0.12fF
C887 divider_2/nor_0/B divider_2/tspc_1/a_630_n680# 0.35fF
C888 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/a_630_n680# 0.19fF
C889 pll_full_0/pd_0/DOWN pll_full_0/pd_0/REF 1.48fF
C890 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/v 1.30fF
C891 ro_complete_0/a4 ro_complete_0/cbank_2/switch_0/vin 0.12fF
C892 divider_0/tspc_0/Z2 divider_0/nor_0/B 0.20fF
C893 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/Out 0.04fF
C894 ro_complete_1/a0 ro_complete_1/cbank_1/v 0.05fF
C895 ro_complete_1/a3 ro_complete_1/cbank_2/v 0.05fF
C896 divbuf_16/OUT5 divbuf_16/OUT3 0.01fF
C897 divbuf_21/a_492_n240# divbuf_21/OUT 0.00fF
C898 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/B 0.18fF
C899 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C900 divbuf_17/OUT5 divbuf_17/OUT3 0.01fF
C901 divider_1/tspc_2/Z2 divider_1/tspc_2/Z4 0.36fF
C902 divbuf_12/OUT3 divbuf_12/OUT5 0.01fF
C903 divbuf_12/OUT2 divbuf_12/OUT 0.06fF
C904 pll_full_0/pd_0/DIV pll_full_0/pd_0/R 0.51fF
C905 pll_full_0/pd_0/R pll_full_0/pd_0/REF 0.61fF
C906 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/switch_5/vin 0.20fF
C907 ro_complete_0/a3 ro_complete_0/cbank_2/v 0.05fF
C908 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C909 divbuf_3/OUT2 divbuf_3/OUT3 1.37fF
C910 divider_1/prescaler_0/tspc_0/Z3 divider_1/clk 0.64fF
C911 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C912 divbuf_19/OUT2 divbuf_19/OUT5 0.02fF
C913 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Z4 0.65fF
C914 divbuf_20/OUT4 divbuf_20/OUT 1.11fF
C915 divbuf_7/a_492_n240# divbuf_7/OUT5 0.01fF
C916 cp_0/a_10_n50# cp_0/vbias 0.19fF
C917 pd_1/R pd_1/and_pd_0/Out1 0.33fF
C918 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z1 0.09fF
C919 pd_1/REF pd_1/tspc_r_1/Z2 0.19fF
C920 divider_2/prescaler_0/tspc_0/D divider_2/prescaler_0/nand_1/z1 0.21fF
C921 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_0/a_740_n680# 0.21fF
C922 divbuf_1/OUT3 divbuf_1/OUT4 5.16fF
C923 divbuf_4/OUT2 divbuf_4/OUT3 1.37fF
C924 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C925 divbuf_17/OUT divbuf_17/OUT2 0.06fF
C926 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/a_630_n680# 0.04fF
C927 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C928 pd_0/R pd_0/REF 0.61fF
C929 divbuf_23/OUT3 divbuf_23/OUT 0.26fF
C930 divbuf_23/OUT4 divbuf_23/OUT5 20.26fF
C931 io_clamp_low[2] io_clamp_high[2] 0.53fF
C932 divider_2/tspc_2/Z1 divider_2/tspc_2/Z4 0.00fF
C933 ro_complete_0/a3 ro_complete_0/cbank_1/switch_2/vin 0.09fF
C934 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/switch_5/vin 0.20fF
C935 io_clamp_high[1] io_analog[5] 0.53fF
C936 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C937 divider_0/tspc_2/Q divider_0/tspc_2/a_630_n680# 0.04fF
C938 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/D 0.03fF
C939 divbuf_5/OUT5 divbuf_5/OUT 43.38fF
C940 divider_1/tspc_0/Z3 divider_1/nor_1/B 0.38fF
C941 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z3 0.33fF
C942 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z1 0.03fF
C943 pll_full_0/ro_complete_0/a4 pll_full_0/divider_0/clk 0.11fF
C944 divbuf_18/OUT3 divbuf_18/OUT5 0.01fF
C945 divider_2/tspc_0/Z2 divider_2/tspc_0/Z1 1.07fF
C946 divider_1/and_0/OUT divider_1/and_0/Z1 0.04fF
C947 divider_1/prescaler_0/tspc_2/Q divider_1/clk 0.05fF
C948 divbuf_22/a_492_n240# divbuf_22/OUT 0.00fF
C949 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/nor_0/A 0.03fF
C950 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z3 0.05fF
C951 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z4 0.36fF
C952 divbuf_25/OUT3 divbuf_25/OUT5 0.01fF
C953 divbuf_25/OUT2 divbuf_25/OUT 0.06fF
C954 divider_0/nor_0/B divider_0/tspc_1/Z1 0.03fF
C955 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_5/vin 0.20fF
C956 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C957 divider_0/prescaler_0/tspc_1/Q divider_0/nor_0/A 0.03fF
C958 divbuf_20/a_492_n240# divbuf_20/IN 0.13fF
C959 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/nand_0/z1 0.07fF
C960 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z2 0.30fF
C961 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z2 0.19fF
C962 divbuf_11/OUT4 divbuf_11/OUT 1.11fF
C963 pd_1/R pd_1/tspc_r_1/Z2 0.21fF
C964 divbuf_24/a_492_n240# divbuf_24/OUT5 0.01fF
C965 divbuf_0/a_492_n240# divbuf_0/OUT 0.00fF
C966 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z1 0.09fF
C967 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z2 0.19fF
C968 divider_0/nor_0/B divider_0/tspc_1/Z2 0.30fF
C969 divbuf_2/OUT2 divbuf_2/OUT3 1.37fF
C970 ro_complete_1/cbank_2/switch_5/vin ro_complete_1/cbank_2/v 1.30fF
C971 divbuf_16/OUT4 divbuf_16/OUT3 5.16fF
C972 divbuf_15/OUT5 divbuf_15/OUT3 0.01fF
C973 divbuf_10/OUT2 divbuf_10/OUT3 1.37fF
C974 divider_2/nor_1/B divider_2/mc2 0.15fF
C975 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Q 0.05fF
C976 divider_1/prescaler_0/m1_2700_2190# divider_1/clk 0.01fF
C977 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z3 0.45fF
C978 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_0/A 1.21fF
C979 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/z5 0.11fF
C980 divbuf_13/OUT3 divbuf_13/OUT 0.26fF
C981 divbuf_13/OUT4 divbuf_13/OUT5 20.26fF
C982 divbuf_19/a_492_n240# divbuf_19/OUT5 0.01fF
C983 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/a5 0.09fF
C984 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/a1 0.14fF
C985 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/v 1.30fF
C986 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/a3 0.09fF
C987 divider_0/prescaler_0/Out divider_0/tspc_2/Z3 0.45fF
C988 divider_0/nor_0/B divider_0/nor_0/A 1.21fF
C989 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C990 divbuf_5/a_492_n240# divbuf_5/OUT2 0.42fF
C991 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z3 0.16fF
C992 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C993 divbuf_17/OUT divbuf_17/a_492_n240# 0.00fF
C994 divider_1/mc2 divider_1/nor_1/B 0.15fF
C995 divbuf_6/OUT5 divbuf_6/OUT 43.38fF
C996 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z1 0.09fF
C997 pd_0/REF pd_0/tspc_r_1/Z2 0.19fF
C998 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z1 0.17fF
C999 divider_2/prescaler_0/tspc_0/Z3 divider_2/clk 0.64fF
C1000 divbuf_8/a_492_n240# divbuf_8/OUT 0.00fF
C1001 divider_0/tspc_0/Z1 divider_0/tspc_1/Q 0.01fF
C1002 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z3 0.06fF
C1003 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/v 1.30fF
C1004 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/cbank_0/v 1.30fF
C1005 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_1/Q 0.13fF
C1006 divbuf_1/OUT divbuf_1/a_492_n240# 0.00fF
C1007 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT3 1.37fF
C1008 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/IN 0.00fF
C1009 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C1010 divbuf_21/IN divbuf_21/OUT5 0.00fF
C1011 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_2/Q 0.01fF
C1012 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/a_630_n680# 0.35fF
C1013 pll_full_0/ro_complete_0/a1 pll_full_0/divider_0/clk 0.11fF
C1014 divider_2/nor_1/B divider_2/tspc_0/Z2 0.40fF
C1015 divider_1/tspc_0/Z3 divider_1/tspc_0/Z1 0.06fF
C1016 divbuf_11/a_492_n240# divbuf_11/IN 0.13fF
C1017 divider_2/tspc_0/Z2 divider_2/tspc_0/Z3 0.16fF
C1018 pd_1/R pd_1/tspc_r_0/Z3 0.27fF
C1019 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z4 0.02fF
C1020 divbuf_12/OUT4 divbuf_12/OUT 1.11fF
C1021 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar1 0.30fF
C1022 divbuf_14/a_492_n240# divbuf_14/OUT5 0.01fF
C1023 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/a_630_n680# 0.01fF
C1024 divider_0/tspc_1/Z1 divider_0/tspc_2/Q 0.01fF
C1025 divider_0/nor_0/B divider_0/tspc_1/a_630_n680# 0.35fF
C1026 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/v 1.30fF
C1027 divbuf_16/OUT2 divbuf_16/OUT3 1.37fF
C1028 divider_1/prescaler_0/tspc_0/Z4 divider_1/clk 0.12fF
C1029 divbuf_3/OUT2 divbuf_3/OUT5 0.02fF
C1030 divbuf_3/OUT3 divbuf_3/OUT4 5.16fF
C1031 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z2 0.14fF
C1032 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C1033 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z3 0.33fF
C1034 divbuf_7/OUT2 divbuf_7/OUT3 1.37fF
C1035 pd_0/DIV pd_0/tspc_r_0/Z3 0.65fF
C1036 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/B 0.18fF
C1037 divider_0/nor_0/Z1 divider_0/and_0/B 0.18fF
C1038 divider_0/tspc_2/Q divider_0/tspc_1/Z2 0.14fF
C1039 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z2 0.01fF
C1040 divbuf_1/OUT3 divbuf_1/OUT 0.26fF
C1041 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C1042 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1043 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/a3 0.09fF
C1044 divider_1/tspc_1/a_630_n680# divider_1/nor_1/B 0.00fF
C1045 divider_0/and_0/out1 divider_0/and_0/B 0.18fF
C1046 divbuf_4/OUT2 divbuf_4/OUT5 0.02fF
C1047 divbuf_4/OUT3 divbuf_4/OUT4 5.16fF
C1048 divbuf_6/a_492_n240# divbuf_6/OUT2 0.42fF
C1049 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/B 0.31fF
C1050 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/nor_0/A 0.55fF
C1051 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C1052 divider_2/nor_1/B divider_2/Out 0.22fF
C1053 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_2/Q 0.19fF
C1054 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/clk 0.01fF
C1055 divider_1/nor_1/B divider_1/and_0/B 0.29fF
C1056 divbuf_23/OUT5 divbuf_23/OUT 43.38fF
C1057 pd_1/tspc_r_0/Z1 pd_1/tspc_r_0/Z2 0.71fF
C1058 pd_1/DIV pd_1/R 0.51fF
C1059 pd_0/DOWN pd_0/tspc_r_1/Qbar 0.02fF
C1060 pd_0/R pd_0/tspc_r_1/Qbar1 0.30fF
C1061 divider_2/Out divider_2/tspc_0/Z3 0.05fF
C1062 divider_2/tspc_2/Z3 divider_2/tspc_2/Z4 0.65fF
C1063 divbuf_9/a_492_n240# divbuf_9/OUT 0.00fF
C1064 ro_complete_0/a3 ro_complete_0/cbank_2/switch_1/vin 0.13fF
C1065 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1066 divbuf_15/OUT divbuf_15/a_492_n240# 0.00fF
C1067 divider_0/nor_0/B divider_0/and_0/B 0.31fF
C1068 divider_0/tspc_2/Q divider_0/nor_0/A 0.55fF
C1069 divider_0/and_0/OUT divider_0/prescaler_0/nand_0/z1 0.01fF
C1070 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/v 1.30fF
C1071 io_clamp_low[0] io_analog[4] 0.53fF
C1072 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1073 divbuf_19/OUT2 divbuf_19/a_492_n240# 0.42fF
C1074 divider_1/tspc_0/Z2 divider_1/nor_0/B 0.20fF
C1075 divider_1/tspc_0/a_630_n680# divider_1/nor_1/B 0.35fF
C1076 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z3 0.05fF
C1077 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z4 0.08fF
C1078 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Q 0.51fF
C1079 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z4 0.36fF
C1080 divbuf_22/IN divbuf_22/OUT5 0.00fF
C1081 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/clk 0.06fF
C1082 divider_1/tspc_2/a_630_n680# divider_1/nor_0/A 0.35fF
C1083 divider_1/prescaler_0/tspc_0/D divider_1/clk 0.29fF
C1084 divbuf_12/a_492_n240# divbuf_12/IN 0.13fF
C1085 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/DOWN 0.03fF
C1086 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z4 0.12fF
C1087 pll_full_0/cp_0/a_1710_0# pll_full_0/cp_0/down 0.32fF
C1088 divbuf_25/OUT4 divbuf_25/OUT 1.11fF
C1089 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/cbank_1/v 1.43fF
C1090 ro_complete_1/a2 ro_complete_1/cbank_1/switch_3/vin 0.09fF
C1091 ro_complete_0/a4 ro_complete_0/cbank_2/v 0.05fF
C1092 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/v 1.30fF
C1093 divider_0/nor_0/B divider_0/tspc_1/Q 0.51fF
C1094 divider_1/prescaler_0/Out divider_1/tspc_2/a_630_n680# 0.01fF
C1095 divider_0/and_0/OUT divider_0/clk 0.04fF
C1096 divider_1/prescaler_0/tspc_1/Z2 divider_1/and_0/OUT 0.06fF
C1097 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z3 0.33fF
C1098 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Q 0.38fF
C1099 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z3 0.06fF
C1100 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C1101 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/A 0.01fF
C1102 divider_1/and_0/out1 divider_1/and_0/A 0.01fF
C1103 divbuf_24/OUT2 divbuf_24/OUT3 1.37fF
C1104 cp_0/a_10_n50# cp_0/a_1710_0# 0.04fF
C1105 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/R 0.27fF
C1106 divbuf_2/OUT2 divbuf_2/OUT5 0.02fF
C1107 divbuf_2/OUT3 divbuf_2/OUT4 5.16fF
C1108 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/v 1.30fF
C1109 ro_complete_0/cbank_2/switch_2/vin ro_complete_0/cbank_2/v 1.30fF
C1110 divider_0/tspc_1/Z1 divider_0/tspc_1/Z3 0.06fF
C1111 divider_0/tspc_2/Q divider_0/tspc_1/a_630_n680# 0.01fF
C1112 divbuf_18/OUT divbuf_18/a_492_n240# 0.00fF
C1113 divider_1/nor_1/Z1 divider_1/and_0/B 0.78fF
C1114 divider_0/nor_0/A divider_0/and_0/A 0.01fF
C1115 divbuf_4/a_492_n240# divbuf_4/IN 0.13fF
C1116 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/Z2 1.07fF
C1117 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/clk 0.01fF
C1118 divbuf_10/OUT2 divbuf_10/OUT5 0.02fF
C1119 divbuf_10/OUT3 divbuf_10/OUT4 5.16fF
C1120 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/nor_0/A 0.01fF
C1121 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z4 0.12fF
C1122 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z3 0.16fF
C1123 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C1124 divbuf_23/a_492_n240# divbuf_23/OUT2 0.42fF
C1125 pd_0/DOWN pd_0/tspc_r_0/z5 0.03fF
C1126 pd_0/tspc_r_0/Z2 pd_0/R 0.21fF
C1127 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_1/Q 0.13fF
C1128 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z2 0.01fF
C1129 divbuf_13/OUT5 divbuf_13/OUT 43.38fF
C1130 pd_1/tspc_r_1/Z4 pd_1/tspc_r_1/z5 0.04fF
C1131 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/a1 0.14fF
C1132 divbuf_0/OUT5 divbuf_0/IN 0.00fF
C1133 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C1134 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1135 divider_0/prescaler_0/m1_2700_2190# divider_0/nor_0/A 0.01fF
C1136 divider_0/prescaler_0/Out divider_0/tspc_2/Z4 0.12fF
C1137 divider_0/tspc_1/Z2 divider_0/tspc_1/Z3 0.16fF
C1138 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/D 0.15fF
C1139 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1140 divider_2/nor_1/B divider_2/nor_0/B 0.47fF
C1141 divider_2/tspc_0/Z2 divider_2/tspc_0/Z4 0.36fF
C1142 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_0/Z3 0.16fF
C1143 pd_0/DOWN pd_0/and_pd_0/Z1 0.07fF
C1144 divbuf_8/IN divbuf_8/OUT5 0.00fF
C1145 divider_2/mc2 divider_2/nor_0/A 0.04fF
C1146 divider_2/prescaler_0/tspc_0/Z4 divider_2/clk 0.12fF
C1147 divbuf_25/a_492_n240# divbuf_25/IN 0.13fF
C1148 filter_0/a_4216_n5230# filter_0/v 0.19fF
C1149 divbuf_1/IN divbuf_1/OUT5 0.00fF
C1150 divbuf_0/a_492_n240# divbuf_0/OUT5 0.01fF
C1151 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/cbank_0/v 1.30fF
C1152 ro_complete_0/a5 ro_complete_0/cbank_2/switch_0/vin 0.09fF
C1153 divider_0/tspc_0/Z1 divider_0/tspc_0/Z3 0.06fF
C1154 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1155 ro_complete_1/a1 ro_complete_1/cbank_2/v 0.05fF
C1156 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT4 5.16fF
C1157 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1158 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_1/Q 0.21fF
C1159 divider_1/nor_1/B divider_1/tspc_1/Q 0.22fF
C1160 divbuf_21/OUT3 divbuf_21/OUT5 0.01fF
C1161 divbuf_21/OUT2 divbuf_21/OUT 0.06fF
C1162 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C1163 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z3 0.05fF
C1164 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z1 0.03fF
C1165 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/Z3 0.20fF
C1166 divbuf_19/OUT3 divbuf_19/OUT5 0.01fF
C1167 divider_2/nor_0/B divider_2/tspc_2/a_630_n680# 0.01fF
C1168 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/D 0.03fF
C1169 divbuf_14/OUT2 divbuf_14/OUT3 1.37fF
C1170 divbuf_1/OUT2 divbuf_1/OUT5 0.02fF
C1171 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/a3 0.13fF
C1172 ro_complete_0/a1 ro_complete_0/cbank_2/v 0.05fF
C1173 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_0/a_630_n680# 0.04fF
C1174 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z3 0.06fF
C1175 divbuf_3/OUT3 divbuf_3/OUT 0.26fF
C1176 divbuf_3/OUT4 divbuf_3/OUT5 20.26fF
C1177 pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1178 divbuf_17/OUT divbuf_17/OUT4 1.11fF
C1179 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z3 0.05fF
C1180 divider_0/nor_0/A divider_0/tspc_2/Z1 0.03fF
C1181 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z4 0.08fF
C1182 divider_1/prescaler_0/tspc_2/Z2 divider_1/and_0/OUT 0.05fF
C1183 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z3 0.05fF
C1184 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Qbar1 0.38fF
C1185 divbuf_7/OUT2 divbuf_7/OUT5 0.02fF
C1186 divbuf_7/OUT3 divbuf_7/OUT4 5.16fF
C1187 pll_full_0/divider_0/and_0/A pll_full_0/divider_0/and_0/B 0.18fF
C1188 pd_1/REF pd_1/tspc_r_1/Z4 0.02fF
C1189 pd_1/UP pd_1/tspc_r_1/Qbar 0.21fF
C1190 divbuf_13/a_492_n240# divbuf_13/OUT2 0.42fF
C1191 divider_2/prescaler_0/tspc_1/Q divider_2/nor_0/A 0.03fF
C1192 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C1193 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/v 1.30fF
C1194 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C1195 divider_0/mc2 divider_0/and_0/out1 0.06fF
C1196 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z3 0.05fF
C1197 divbuf_4/OUT3 divbuf_4/OUT 0.26fF
C1198 divbuf_4/OUT4 divbuf_4/OUT5 20.26fF
C1199 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_0/B 0.18fF
C1200 divider_1/tspc_2/Q divider_1/nor_0/B 0.22fF
C1201 divider_0/and_0/A divider_0/and_0/B 0.18fF
C1202 divider_1/tspc_1/Z2 divider_1/nor_0/A 0.15fF
C1203 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_0/D 0.32fF
C1204 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/clk 0.01fF
C1205 divider_1/nor_0/B divider_1/and_0/A 0.26fF
C1206 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C1207 pd_1/DIV pd_1/tspc_r_0/Z4 0.02fF
C1208 divider_2/prescaler_0/Out divider_2/tspc_2/a_630_n680# 0.01fF
C1209 divbuf_9/IN divbuf_9/OUT5 0.00fF
C1210 io_clamp_low[1] io_clamp_high[1] 0.53fF
C1211 pll_full_0/pd_0/DOWN pll_full_0/pd_0/R 0.36fF
C1212 divider_0/mc2 divider_0/nor_0/B 0.06fF
C1213 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/a1 0.14fF
C1214 ro_complete_0/a2 ro_complete_0/cbank_1/v 0.05fF
C1215 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/a0 0.13fF
C1216 pll_full_0/pd_0/REF pll_full_0/divbuf_0/OUT5 0.00fF
C1217 divbuf_1/OUT4 divbuf_1/OUT 1.11fF
C1218 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C1219 divider_1/nor_0/Z1 divider_1/nor_0/B 0.06fF
C1220 divider_0/prescaler_0/tspc_2/D divider_0/prescaler_0/nand_0/z1 0.24fF
C1221 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1222 pll_full_0/ro_complete_0/a5 pll_full_0/divider_0/clk 0.15fF
C1223 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z4 0.12fF
C1224 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z2 1.07fF
C1225 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z2 0.01fF
C1226 divbuf_22/OUT3 divbuf_22/OUT5 0.01fF
C1227 divbuf_22/OUT2 divbuf_22/OUT 0.06fF
C1228 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/out1 0.31fF
C1229 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/clk 0.26fF
C1230 pd_0/tspc_r_1/Z4 pd_0/tspc_r_1/z5 0.04fF
C1231 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z1 0.09fF
C1232 divider_2/mc2 divider_2/and_0/B 0.20fF
C1233 pll_full_0/pd_0/DIV pll_full_0/divbuf_1/OUT3 0.26fF
C1234 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Out1 0.12fF
C1235 divider_0/tspc_0/Z1 divider_0/tspc_0/Z4 0.00fF
C1236 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1237 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/a1 0.14fF
C1238 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/v 1.43fF
C1239 pll_full_0/ro_complete_0/a1 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1240 divider_1/prescaler_0/Out divider_1/nor_0/A 0.15fF
C1241 divbuf_15/OUT divbuf_15/OUT4 1.11fF
C1242 divider_0/and_0/OUT divider_0/and_0/out1 0.31fF
C1243 divider_0/prescaler_0/tspc_2/D divider_0/clk 0.26fF
C1244 divbuf_20/a_492_n240# divbuf_20/OUT5 0.01fF
C1245 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_1/Z3 0.05fF
C1246 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z4 0.00fF
C1247 pll_full_0/divbuf_1/IN pll_full_0/divider_0/nor_1/B 0.27fF
C1248 divbuf_17/OUT divbuf_17/OUT3 0.26fF
C1249 divider_1/tspc_1/Q divider_1/tspc_0/Z1 0.01fF
C1250 divider_1/mc2 divider_1/nor_0/A 0.04fF
C1251 divider_1/tspc_1/Z1 divider_1/tspc_1/Z2 1.07fF
C1252 divider_1/nor_0/B divider_1/tspc_1/Z3 0.38fF
C1253 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z3 0.05fF
C1254 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z4 0.08fF
C1255 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Q 0.04fF
C1256 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z4 0.20fF
C1257 divbuf_24/OUT2 divbuf_24/OUT5 0.02fF
C1258 divbuf_24/OUT3 divbuf_24/OUT4 5.16fF
C1259 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/Z4 0.65fF
C1260 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C1261 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C1262 pll_full_0/pd_0/UP pll_full_0/pd_0/tspc_r_1/Qbar 0.21fF
C1263 divbuf_15/OUT2 divbuf_15/OUT 0.06fF
C1264 divider_0/tspc_1/Q divider_0/tspc_1/Z3 0.05fF
C1265 divider_0/tspc_1/Z1 divider_0/tspc_1/Z4 0.00fF
C1266 divider_0/Out divider_0/nor_1/B 0.22fF
C1267 divbuf_2/OUT4 divbuf_2/OUT5 20.26fF
C1268 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/switch_5/vin 0.20fF
C1269 divbuf_19/OUT2 divbuf_19/OUT3 1.37fF
C1270 divider_1/nor_0/Z1 divider_1/and_0/A 0.80fF
C1271 divbuf_10/OUT3 divbuf_10/OUT 0.26fF
C1272 divbuf_10/OUT4 divbuf_10/OUT5 20.26fF
C1273 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z4 0.36fF
C1274 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C1275 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/clk 0.64fF
C1276 pd_0/tspc_r_0/Z2 pd_0/tspc_r_0/Z4 0.14fF
C1277 divider_2/tspc_0/Z4 divider_2/nor_0/B 0.02fF
C1278 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_1/Q 0.21fF
C1279 pd_1/UP pd_1/and_pd_0/Z1 0.06fF
C1280 ro_complete_0/a4 ro_complete_0/cbank_2/switch_1/vin 0.09fF
C1281 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/v 1.30fF
C1282 divider_0/tspc_1/Z2 divider_0/tspc_1/Z4 0.36fF
C1283 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/D 0.05fF
C1284 divider_0/prescaler_0/tspc_0/Z3 divider_0/clk 0.64fF
C1285 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C1286 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/a0 0.13fF
C1287 divbuf_5/a_492_n240# divbuf_5/OUT 0.00fF
C1288 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1289 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1290 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/divider_0/clk 1.46fF
C1291 divider_2/nor_1/Z1 divider_2/nor_1/B 0.06fF
C1292 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z2 0.01fF
C1293 divider_1/tspc_2/Q divider_1/tspc_1/Z3 0.45fF
C1294 divider_1/tspc_0/Z3 divider_1/tspc_0/a_630_n680# 0.05fF
C1295 pll_full_0/divider_0/tspc_1/Z4 pll_full_0/divider_0/nor_0/A 0.02fF
C1296 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_0/Z4 0.36fF
C1297 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/Out 0.05fF
C1298 divbuf_8/OUT3 divbuf_8/OUT5 0.01fF
C1299 divbuf_8/OUT2 divbuf_8/OUT 0.06fF
C1300 pd_1/tspc_r_0/Z2 pd_1/R 0.21fF
C1301 pd_0/R pd_0/and_pd_0/Out1 0.33fF
C1302 pd_0/REF pd_0/tspc_r_1/Z4 0.02fF
C1303 pd_0/UP pd_0/tspc_r_1/Qbar 0.21fF
C1304 divider_2/nor_0/B divider_2/tspc_1/Z2 0.30fF
C1305 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z2 0.01fF
C1306 divider_2/and_0/out1 divider_2/and_0/B 0.18fF
C1307 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1308 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1309 pll_full_0/pd_0/REF pll_full_0/divbuf_0/a_492_n240# 0.13fF
C1310 divider_2/tspc_1/Q divider_2/tspc_0/Z2 0.14fF
C1311 divbuf_16/a_492_n240# divbuf_16/IN 0.13fF
C1312 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/D 0.05fF
C1313 divider_0/tspc_1/Z4 divider_0/nor_0/A 0.02fF
C1314 divbuf_2/a_492_n240# divbuf_2/OUT 0.00fF
C1315 divbuf_21/OUT4 divbuf_21/OUT 1.11fF
C1316 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_0/Z4 0.02fF
C1317 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1318 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/divider_0/clk 1.27fF
C1319 divbuf_11/a_492_n240# divbuf_11/OUT5 0.01fF
C1320 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z4 0.12fF
C1321 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z2 1.07fF
C1322 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z3 0.38fF
C1323 divider_1/nor_0/A divider_1/and_0/B 0.08fF
C1324 pd_1/DOWN pd_1/UP 0.46fF
C1325 pd_1/tspc_r_0/z5 pd_1/tspc_r_0/Qbar1 0.20fF
C1326 divbuf_19/OUT4 divbuf_19/OUT 1.11fF
C1327 divider_2/and_0/OUT divider_2/prescaler_0/nand_0/z1 0.01fF
C1328 divider_2/nor_0/B divider_2/nor_0/A 1.21fF
C1329 ro_complete_1/a4 ro_complete_1/cbank_1/switch_1/vin 0.09fF
C1330 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z2 0.21fF
C1331 divbuf_14/OUT2 divbuf_14/OUT5 0.02fF
C1332 divbuf_14/OUT3 divbuf_14/OUT4 5.16fF
C1333 ro_complete_0/cbank_1/switch_5/vin ro_complete_0/cbank_1/v 1.30fF
C1334 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/Z1 0.06fF
C1335 divider_0/nor_0/B divider_0/tspc_0/Z4 0.02fF
C1336 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1337 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z3 0.05fF
C1338 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z4 0.12fF
C1339 divider_0/tspc_2/Z1 divider_0/tspc_2/Z2 1.07fF
C1340 divider_0/nor_0/A divider_0/tspc_2/Z3 0.38fF
C1341 divbuf_3/OUT5 divbuf_3/OUT 43.38fF
C1342 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C1343 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z4 0.12fF
C1344 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1345 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/D 0.09fF
C1346 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Q 0.20fF
C1347 divider_1/mc2 divider_1/and_0/B 0.20fF
C1348 divbuf_7/OUT3 divbuf_7/OUT 0.26fF
C1349 divbuf_7/OUT4 divbuf_7/OUT5 20.26fF
C1350 pd_0/DIV pd_0/tspc_r_0/Z1 0.17fF
C1351 pd_0/tspc_r_0/Qbar1 pd_0/DOWN 0.11fF
C1352 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/z5 0.11fF
C1353 divider_2/and_0/OUT divider_2/clk 0.04fF
C1354 ro_complete_0/a4 ro_complete_0/cbank_1/switch_1/vin 0.09fF
C1355 pll_full_0/pd_0/UP pll_full_0/pd_0/and_pd_0/Z1 0.06fF
C1356 ro_complete_1/a2 ro_complete_1/cbank_1/v 0.05fF
C1357 divbuf_15/IN divbuf_15/a_492_n240# 0.13fF
C1358 divider_0/mc2 divider_0/and_0/A 0.16fF
C1359 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z4 0.12fF
C1360 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1361 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C1362 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1363 divbuf_4/OUT5 divbuf_4/OUT 43.38fF
C1364 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/Out 0.21fF
C1365 divbuf_6/a_492_n240# divbuf_6/OUT 0.00fF
C1366 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1367 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/clk 0.45fF
C1368 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/nand_1/z1 0.22fF
C1369 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/tspc_0/D 0.04fF
C1370 pd_0/R pd_0/tspc_r_1/Z2 0.21fF
C1371 divider_2/prescaler_0/Out divider_2/nor_0/A 0.15fF
C1372 divider_2/nor_0/B divider_2/tspc_1/Z1 0.03fF
C1373 divbuf_9/OUT3 divbuf_9/OUT5 0.01fF
C1374 divbuf_9/OUT2 divbuf_9/OUT 0.06fF
C1375 divider_2/nor_0/A divider_2/and_0/A 0.01fF
C1376 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C1377 divider_1/prescaler_0/tspc_0/Z2 divider_1/and_0/OUT 0.06fF
C1378 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/Q 0.04fF
C1379 divider_0/prescaler_0/tspc_1/Z3 divider_0/clk 0.45fF
C1380 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1381 divider_1/tspc_0/Z3 divider_1/tspc_1/Q 0.45fF
C1382 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z3 0.16fF
C1383 divbuf_21/a_492_n240# divbuf_21/IN 0.13fF
C1384 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/nor_1/B 0.03fF
C1385 divbuf_22/OUT4 divbuf_22/OUT 1.11fF
C1386 divider_2/tspc_0/Z2 divider_2/tspc_0/a_630_n680# 0.01fF
C1387 divider_1/nor_0/A divider_1/tspc_2/Z2 0.23fF
C1388 divbuf_12/a_492_n240# divbuf_12/OUT5 0.01fF
C1389 pd_1/DOWN pd_1/tspc_r_0/z5 0.03fF
C1390 pd_0/UP pd_0/and_pd_0/Z1 0.06fF
C1391 divider_2/prescaler_0/m1_2700_2190# divider_2/nor_0/A 0.01fF
C1392 divider_2/tspc_1/Z2 divider_2/tspc_1/Z3 0.16fF
C1393 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/D 0.15fF
C1394 ro_complete_1/a2 ro_complete_1/cbank_0/switch_2/vin 0.14fF
C1395 ro_complete_0/a5 ro_complete_0/cbank_2/v 0.08fF
C1396 ro_complete_0/a0 ro_complete_0/cbank_1/switch_5/vin 0.09fF
C1397 divider_0/nor_1/Z1 divider_0/nor_1/B 0.06fF
C1398 divbuf_3/a_492_n240# divbuf_3/OUT2 0.42fF
C1399 divider_1/prescaler_0/Out divider_1/tspc_2/Z2 0.11fF
C1400 divbuf_15/OUT divbuf_15/OUT3 0.26fF
C1401 divider_1/nor_0/B divider_1/tspc_1/Z4 0.21fF
C1402 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z4 0.12fF
C1403 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z2 1.07fF
C1404 divbuf_20/OUT2 divbuf_20/OUT3 1.37fF
C1405 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C1406 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/and_0/OUT 0.14fF
C1407 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/D 0.03fF
C1408 divider_1/and_0/out1 divider_1/and_0/Z1 0.36fF
C1409 divbuf_24/OUT3 divbuf_24/OUT 0.26fF
C1410 divbuf_24/OUT4 divbuf_24/OUT5 20.26fF
C1411 pd_1/tspc_r_0/Z4 pd_1/tspc_r_1/Z4 0.02fF
C1412 pd_1/REF pd_1/tspc_r_1/Z3 0.65fF
C1413 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/z5 0.20fF
C1414 divider_2/nor_0/B divider_2/and_0/B 0.31fF
C1415 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_4/vin 0.20fF
C1416 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1417 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/z5 0.11fF
C1418 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/v 1.30fF
C1419 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C1420 divbuf_15/OUT2 divbuf_15/a_492_n240# 0.42fF
C1421 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_1/Q 0.13fF
C1422 divider_0/prescaler_0/m1_2700_2190# divider_0/and_0/OUT 0.14fF
C1423 divbuf_4/a_492_n240# divbuf_4/OUT5 0.01fF
C1424 divider_1/prescaler_0/tspc_1/Z2 divider_1/clk 0.11fF
C1425 divbuf_10/OUT5 divbuf_10/OUT 43.38fF
C1426 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C1427 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/clk 0.12fF
C1428 divider_2/mc2 divider_2/and_0/OUT 0.05fF
C1429 divider_2/Out divider_2/tspc_0/a_630_n680# 0.04fF
C1430 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z3 0.06fF
C1431 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/D 0.05fF
C1432 divbuf_23/a_492_n240# divbuf_23/OUT 0.00fF
C1433 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z3 0.05fF
C1434 divider_2/nor_0/A divider_2/tspc_2/Z1 0.03fF
C1435 divbuf_2/OUT3 divbuf_2/OUT 0.26fF
C1436 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/a0 0.09fF
C1437 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C1438 divbuf_16/a_492_n240# divbuf_16/OUT 0.00fF
C1439 divider_1/tspc_0/Z4 divider_1/nor_1/B 0.22fF
C1440 divider_0/prescaler_0/tspc_2/Z4 divider_0/prescaler_0/tspc_2/D 0.11fF
C1441 divider_0/prescaler_0/tspc_0/Z4 divider_0/clk 0.12fF
C1442 divbuf_5/IN divbuf_5/OUT5 0.00fF
C1443 divbuf_17/OUT divbuf_17/OUT5 43.38fF
C1444 divider_2/tspc_1/Q divider_2/nor_0/B 0.51fF
C1445 divider_1/tspc_2/Q divider_1/tspc_1/Z4 0.15fF
C1446 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1447 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divbuf_1/IN 0.04fF
C1448 divider_2/nor_0/Z1 divider_2/and_0/B 0.18fF
C1449 divbuf_22/a_492_n240# divbuf_22/IN 0.13fF
C1450 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/clk 0.45fF
C1451 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z4 0.14fF
C1452 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/z5 0.11fF
C1453 divbuf_18/a_492_n240# divbuf_18/OUT2 0.42fF
C1454 divbuf_18/OUT5 divbuf_18/IN 0.00fF
C1455 divider_2/tspc_1/Z1 divider_2/tspc_1/Z3 0.06fF
C1456 divbuf_8/OUT4 divbuf_8/OUT 1.11fF
C1457 divbuf_25/a_492_n240# divbuf_25/OUT5 0.01fF
C1458 divider_2/and_0/A divider_2/and_0/B 0.18fF
C1459 divider_0/tspc_0/a_630_n680# divider_0/Out 0.04fF
C1460 divbuf_0/OUT divbuf_0/OUT5 43.38fF
C1461 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/v 0.08fF
C1462 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C1463 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/D 0.11fF
C1464 divider_0/prescaler_0/tspc_2/Z3 divider_0/clk 0.45fF
C1465 divider_1/tspc_2/Q divider_1/tspc_2/Z3 0.05fF
C1466 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1467 divbuf_11/OUT2 divbuf_11/OUT3 1.37fF
C1468 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z3 0.16fF
C1469 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z4 0.21fF
C1470 pd_1/R pd_1/tspc_r_1/Z3 0.29fF
C1471 divider_2/prescaler_0/tspc_2/D divider_2/prescaler_0/nand_0/z1 0.24fF
C1472 divbuf_14/OUT3 divbuf_14/OUT 0.26fF
C1473 divbuf_14/OUT4 divbuf_14/OUT5 20.26fF
C1474 divbuf_0/OUT3 divbuf_0/OUT 0.26fF
C1475 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z3 0.65fF
C1476 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/Z1 0.00fF
C1477 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1478 ro_complete_0/cbank_0/v ro_complete_0/cbank_2/v 0.04fF
C1479 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT4 5.16fF
C1480 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1481 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1482 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z4 0.12fF
C1483 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/clk 0.14fF
C1484 divider_0/tspc_2/Z2 divider_0/tspc_2/Z3 0.16fF
C1485 divider_0/nor_0/A divider_0/tspc_2/Z4 0.21fF
C1486 divbuf_10/a_492_n240# divbuf_10/OUT2 0.42fF
C1487 divider_1/tspc_1/Z3 divider_1/tspc_1/Z4 0.65fF
C1488 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Q 0.04fF
C1489 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C1490 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1491 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1492 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z2 0.25fF
C1493 divider_2/prescaler_0/tspc_0/Z2 divider_2/and_0/OUT 0.06fF
C1494 divbuf_7/OUT5 divbuf_7/OUT 43.38fF
C1495 pll_full_0/divider_0/and_0/B pll_full_0/divider_0/and_0/Z1 0.07fF
C1496 pd_1/UP pd_1/tspc_r_1/z5 0.03fF
C1497 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/Qbar 0.21fF
C1498 divider_2/and_0/OUT divider_2/and_0/out1 0.31fF
C1499 divider_2/prescaler_0/tspc_2/D divider_2/clk 0.26fF
C1500 divbuf_13/a_492_n240# divbuf_13/OUT 0.00fF
C1501 divbuf_18/OUT4 divbuf_18/OUT 1.11fF
C1502 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1503 divider_0/prescaler_0/Out divider_0/tspc_2/a_630_n680# 0.01fF
C1504 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1505 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Q 0.21fF
C1506 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/nor_0/B 0.20fF
C1507 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Q 0.04fF
C1508 divider_0/and_0/B divider_0/and_0/Z1 0.07fF
C1509 divbuf_6/IN divbuf_6/OUT5 0.00fF
C1510 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/nand_1/z1 0.01fF
C1511 divider_1/prescaler_0/tspc_2/Z2 divider_1/clk 0.11fF
C1512 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/clk 0.12fF
C1513 pd_1/DIV pd_1/tspc_r_0/Z3 0.65fF
C1514 pd_0/REF pd_0/tspc_r_1/Z3 0.65fF
C1515 divider_2/prescaler_0/Out divider_2/tspc_2/Z2 0.11fF
C1516 divbuf_8/a_492_n240# divbuf_8/IN 0.13fF
C1517 io_clamp_low[0] io_clamp_high[0] 0.53fF
C1518 divbuf_9/OUT4 divbuf_9/OUT 1.11fF
C1519 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z3 0.33fF
C1520 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C1521 pll_full_0/pd_0/DIV pll_full_0/divider_0/and_0/OUT 0.01fF
C1522 divider_1/tspc_0/Z4 divider_1/tspc_0/Z1 0.00fF
C1523 divider_0/prescaler_0/tspc_1/Z4 divider_0/clk 0.12fF
C1524 ro_complete_1/a0 ro_complete_1/cbank_2/switch_4/vin 0.13fF
C1525 ro_complete_1/cbank_0/v ro_complete_1/cbank_1/v 1.27fF
C1526 divider_2/tspc_1/Q divider_2/tspc_1/Z3 0.05fF
C1527 divider_1/mc2 divider_1/and_0/OUT 0.05fF
C1528 divider_1/tspc_0/a_630_n680# divider_1/tspc_1/Q 0.01fF
C1529 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z4 0.36fF
C1530 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/D 0.03fF
C1531 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/clk 0.60fF
C1532 divider_1/tspc_2/Z1 divider_1/tspc_2/Z3 0.06fF
C1533 divider_2/tspc_1/Z2 divider_2/tspc_1/Z4 0.36fF
C1534 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/D 0.05fF
C1535 divbuf_12/OUT2 divbuf_12/OUT3 1.37fF
C1536 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/v 1.30fF
C1537 ro_complete_0/a0 ro_complete_0/cbank_1/v 0.05fF
C1538 pll_full_0/divbuf_0/OUT pll_full_0/divbuf_0/OUT3 0.26fF
C1539 divider_0/prescaler_0/tspc_1/Q divider_0/clk 0.60fF
C1540 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_0/B 0.06fF
C1541 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/ro_complete_0/cbank_2/v 0.04fF
C1542 divbuf_20/OUT2 divbuf_20/OUT5 0.02fF
C1543 divbuf_20/OUT3 divbuf_20/OUT4 5.16fF
C1544 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1545 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C1546 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C1547 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C1548 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z3 0.16fF
C1549 divbuf_7/a_492_n240# divbuf_7/OUT2 0.42fF
C1550 divider_2/nor_1/Z1 divider_2/and_0/B 0.78fF
C1551 pd_1/tspc_r_0/z5 pd_1/tspc_r_1/z5 0.02fF
C1552 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Qbar1 0.38fF
C1553 divider_2/tspc_1/Z4 divider_2/nor_0/A 0.02fF
C1554 divbuf_24/OUT5 divbuf_24/OUT 43.38fF
C1555 divbuf_0/OUT divbuf_0/OUT4 1.11fF
C1556 divbuf_0/a_492_n240# divbuf_0/OUT2 0.42fF
C1557 pll_full_0/pd_0/UP pll_full_0/pd_0/tspc_r_1/z5 0.03fF
C1558 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_1/Q 0.21fF
C1559 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_2/D 0.16fF
C1560 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/D 0.03fF
C1561 ro_complete_1/a3 ro_complete_1/cbank_1/switch_2/vin 0.09fF
C1562 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/cbank_0/v 1.30fF
C1563 ro_complete_0/cbank_2/switch_0/vin ro_complete_0/cbank_2/v 1.45fF
C1564 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT3 0.01fF
C1565 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1566 divbuf_16/OUT5 divbuf_16/IN 0.00fF
C1567 divbuf_23/IN divbuf_23/OUT5 0.00fF
C1568 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z4 0.00fF
C1569 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/D 0.11fF
C1570 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Z1 0.02fF
C1571 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z4 0.12fF
C1572 divider_2/tspc_2/Z1 divider_2/tspc_2/Z2 1.07fF
C1573 divider_2/nor_0/A divider_2/tspc_2/Z3 0.38fF
C1574 divbuf_9/a_492_n240# divbuf_9/IN 0.13fF
C1575 ro_complete_0/a2 ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1576 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/v 1.30fF
C1577 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z4 0.01fF
C1578 divbuf_2/OUT5 divbuf_2/OUT 43.38fF
C1579 ro_complete_1/a3 ro_complete_1/cbank_1/v 0.05fF
C1580 io_clamp_high[2] io_analog[6] 0.53fF
C1581 divbuf_5/OUT3 divbuf_5/OUT5 0.01fF
C1582 divbuf_5/OUT2 divbuf_5/OUT 0.06fF
C1583 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/clk 0.12fF
C1584 divider_2/nor_1/B divider_2/tspc_1/a_630_n680# 0.00fF
C1585 divider_1/and_0/OUT divider_1/and_0/B 0.01fF
C1586 pd_0/UP pd_0/tspc_r_1/z5 0.03fF
C1587 divider_2/tspc_1/Z1 divider_2/tspc_1/Z4 0.00fF
C1588 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z3 0.06fF
C1589 divbuf_25/OUT2 divbuf_25/OUT3 1.37fF
C1590 ro_complete_0/a3 ro_complete_0/cbank_1/v 0.05fF
C1591 divider_0/mc2 divider_0/prescaler_0/tspc_2/a_630_n680# 0.33fF
C1592 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Q 0.15fF
C1593 divider_0/prescaler_0/tspc_2/Z4 divider_0/clk 0.12fF
C1594 ro_complete_1/cbank_2/switch_0/vin ro_complete_1/cbank_2/v 1.45fF
C1595 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1596 divbuf_11/OUT2 divbuf_11/OUT5 0.02fF
C1597 divbuf_11/OUT3 divbuf_11/OUT4 5.16fF
C1598 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z4 0.36fF
C1599 divbuf_24/a_492_n240# divbuf_24/OUT2 0.42fF
C1600 pd_1/DOWN pd_1/tspc_r_1/Qbar 0.02fF
C1601 pd_1/R pd_1/UP 0.45fF
C1602 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/Q 0.04fF
C1603 divider_2/prescaler_0/tspc_1/Z3 divider_2/clk 0.45fF
C1604 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Qbar1 0.38fF
C1605 divbuf_14/OUT5 divbuf_14/OUT 43.38fF
C1606 ro_complete_1/a4 ro_complete_1/cbank_2/v 0.05fF
C1607 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/a3 0.09fF
C1608 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT5 0.01fF
C1609 divider_0/tspc_2/Z2 divider_0/tspc_2/Z4 0.36fF
C1610 pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_0/ro_complete_0/cbank_2/v 1.45fF
C1611 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/nor_0/A 0.15fF
C1612 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1613 pll_full_0/ro_complete_0/cbank_2/v pll_full_0/divider_0/clk 1.36fF
C1614 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/Qbar 0.01fF
C1615 pd_0/tspc_r_0/Z3 pd_0/R 0.27fF
C1616 divbuf_13/IN divbuf_13/OUT5 0.00fF
C1617 cp_0/a_1710_0# cp_0/out 0.84fF
C1618 pd_1/tspc_r_1/Z2 pd_1/tspc_r_1/Z4 0.14fF
C1619 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C1620 divbuf_2/IN divbuf_2/a_492_n240# 0.13fF
C1621 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/v 1.30fF
C1622 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1623 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1624 divider_1/tspc_0/Z4 divider_1/tspc_0/Z3 0.65fF
C1625 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z1 0.08fF
C1626 divider_0/prescaler_0/Out divider_0/nor_0/A 0.15fF
C1627 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1628 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/clk 0.14fF
C1629 divider_0/nor_1/Z1 divider_0/and_0/B 0.78fF
C1630 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_1/Q 0.01fF
C1631 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C1632 divider_1/prescaler_0/tspc_0/D divider_1/prescaler_0/nand_1/z1 0.21fF
C1633 divbuf_6/OUT3 divbuf_6/OUT5 0.01fF
C1634 divbuf_6/OUT2 divbuf_6/OUT 0.06fF
C1635 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Qbar1 0.38fF
C1636 divider_2/nor_0/B divider_2/tspc_2/Q 0.22fF
C1637 divider_2/prescaler_0/m1_2700_2190# divider_2/and_0/OUT 0.14fF
C1638 divbuf_0/OUT3 divbuf_0/OUT5 0.01fF
C1639 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z3 0.05fF
C1640 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1641 divbuf_21/a_492_n240# divbuf_21/OUT5 0.01fF
C1642 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divbuf_1/IN 0.05fF
C1643 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C1644 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/A 0.80fF
C1645 pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_0/divider_0/clk 1.46fF
C1646 divider_1/tspc_2/Z1 divider_1/tspc_2/Z4 0.00fF
C1647 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/Z1 0.04fF
C1648 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/clk 0.05fF
C1649 pd_1/DOWN pd_1/tspc_r_0/Qbar1 0.11fF
C1650 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Z1 0.02fF
C1651 divbuf_12/OUT2 divbuf_12/OUT5 0.02fF
C1652 divbuf_12/OUT3 divbuf_12/OUT4 5.16fF
C1653 divider_2/prescaler_0/tspc_2/Z4 divider_2/prescaler_0/tspc_2/D 0.11fF
C1654 divbuf_14/a_492_n240# divbuf_14/OUT2 0.42fF
Xpd_0 vssa1 vssa1 pd_0/REF pd_0/DIV pd_0/UP pd_0/DOWN pd_0/R pd
Xpd_1 VDD vssa1 pd_1/REF pd_1/DIV pd_1/UP pd_1/DOWN pd_1/R pd
Xcp_0 cp_0/vbias vssa1 gnd cp_0/out cp_0/down cp_0/upbar cp
Xfilter_0 vssa1 filter_0/v filter
Xro_complete_0 ro_complete_0/a0 ro_complete_0/a1 ro_complete_0/a5 ro_complete_0/a4
+ ro_complete_0/a3 ro_complete_0/a2 ro_complete
Xro_complete_1 ro_complete_1/a0 ro_complete_1/a1 ro_complete_1/a5 ro_complete_1/a4
+ ro_complete_1/a3 ro_complete_1/a2 ro_complete
Xdivbuf_0 vssa1 divbuf_0/IN divbuf_0/OUT divbuf_0/OUT2 divbuf_0/OUT3 divbuf_0/OUT4
+ divbuf_0/OUT5 vssa1 divbuf
Xdivbuf_1 vssa1 divbuf_1/IN divbuf_1/OUT divbuf_1/OUT2 divbuf_1/OUT3 divbuf_1/OUT4
+ divbuf_1/OUT5 vssa1 divbuf
Xdivbuf_2 vssa1 divbuf_2/IN divbuf_2/OUT divbuf_2/OUT2 divbuf_2/OUT3 divbuf_2/OUT4
+ divbuf_2/OUT5 vssa1 divbuf
Xdivbuf_3 vssa1 divbuf_3/IN divbuf_3/OUT divbuf_3/OUT2 divbuf_3/OUT3 divbuf_3/OUT4
+ divbuf_3/OUT5 vssa1 divbuf
Xdivbuf_4 VDD divbuf_4/IN divbuf_4/OUT divbuf_4/OUT2 divbuf_4/OUT3 divbuf_4/OUT4 divbuf_4/OUT5
+ vssa1 divbuf
Xdivbuf_5 VDD divbuf_5/IN divbuf_5/OUT divbuf_5/OUT2 divbuf_5/OUT3 divbuf_5/OUT4 divbuf_5/OUT5
+ vssa1 divbuf
Xdivbuf_21 vssa1 divbuf_21/IN divbuf_21/OUT divbuf_21/OUT2 divbuf_21/OUT3 divbuf_21/OUT4
+ divbuf_21/OUT5 gnd divbuf
Xdivbuf_20 vssa1 divbuf_20/IN divbuf_20/OUT divbuf_20/OUT2 divbuf_20/OUT3 divbuf_20/OUT4
+ divbuf_20/OUT5 gnd divbuf
Xdivbuf_10 vssa1 divbuf_10/IN divbuf_10/OUT divbuf_10/OUT2 divbuf_10/OUT3 divbuf_10/OUT4
+ divbuf_10/OUT5 gnd divbuf
Xdivbuf_6 VDD divbuf_6/IN divbuf_6/OUT divbuf_6/OUT2 divbuf_6/OUT3 divbuf_6/OUT4 divbuf_6/OUT5
+ vssa1 divbuf
Xdivbuf_22 vssa1 divbuf_22/IN divbuf_22/OUT divbuf_22/OUT2 divbuf_22/OUT3 divbuf_22/OUT4
+ divbuf_22/OUT5 gnd divbuf
Xdivbuf_11 vssa1 divbuf_11/IN divbuf_11/OUT divbuf_11/OUT2 divbuf_11/OUT3 divbuf_11/OUT4
+ divbuf_11/OUT5 gnd divbuf
Xdivbuf_7 VDD divbuf_7/IN divbuf_7/OUT divbuf_7/OUT2 divbuf_7/OUT3 divbuf_7/OUT4 divbuf_7/OUT5
+ vssa1 divbuf
Xdivbuf_23 vssa1 divbuf_23/IN divbuf_23/OUT divbuf_23/OUT2 divbuf_23/OUT3 divbuf_23/OUT4
+ divbuf_23/OUT5 gnd divbuf
Xdivbuf_8 vssa1 divbuf_8/IN divbuf_8/OUT divbuf_8/OUT2 divbuf_8/OUT3 divbuf_8/OUT4
+ divbuf_8/OUT5 vssa1 divbuf
Xdivbuf_12 vssa1 divbuf_12/IN divbuf_12/OUT divbuf_12/OUT2 divbuf_12/OUT3 divbuf_12/OUT4
+ divbuf_12/OUT5 gnd divbuf
Xdivbuf_24 vssa1 divbuf_24/IN divbuf_24/OUT divbuf_24/OUT2 divbuf_24/OUT3 divbuf_24/OUT4
+ divbuf_24/OUT5 gnd divbuf
Xdivbuf_13 vssa1 divbuf_13/IN divbuf_13/OUT divbuf_13/OUT2 divbuf_13/OUT3 divbuf_13/OUT4
+ divbuf_13/OUT5 gnd divbuf
Xdivbuf_9 vssa1 divbuf_9/IN divbuf_9/OUT divbuf_9/OUT2 divbuf_9/OUT3 divbuf_9/OUT4
+ divbuf_9/OUT5 vssa1 divbuf
Xdivbuf_25 vssa1 divbuf_25/IN divbuf_25/OUT divbuf_25/OUT2 divbuf_25/OUT3 divbuf_25/OUT4
+ divbuf_25/OUT5 gnd divbuf
Xdivbuf_14 vssa1 divbuf_14/IN divbuf_14/OUT divbuf_14/OUT2 divbuf_14/OUT3 divbuf_14/OUT4
+ divbuf_14/OUT5 gnd divbuf
Xdivider_0 gnd vdd divider_0/Out divider_0/clk divider_0/mc2 divider
Xdivbuf_15 vssa1 divbuf_15/IN divbuf_15/OUT divbuf_15/OUT2 divbuf_15/OUT3 divbuf_15/OUT4
+ divbuf_15/OUT5 gnd divbuf
Xdivider_1 vssa1 vssa1 divider_1/Out divider_1/clk divider_1/mc2 divider
Xdivbuf_16 vssa1 divbuf_16/IN divbuf_16/OUT divbuf_16/OUT2 divbuf_16/OUT3 divbuf_16/OUT4
+ divbuf_16/OUT5 gnd divbuf
Xdivider_2 vssa1 vssa1 divider_2/Out divider_2/clk divider_2/mc2 divider
Xdivbuf_17 vssa1 divbuf_17/IN divbuf_17/OUT divbuf_17/OUT2 divbuf_17/OUT3 divbuf_17/OUT4
+ divbuf_17/OUT5 gnd divbuf
Xdivbuf_18 vssa1 divbuf_18/IN divbuf_18/OUT divbuf_18/OUT2 divbuf_18/OUT3 divbuf_18/OUT4
+ divbuf_18/OUT5 gnd divbuf
Xdivbuf_19 vssa1 divbuf_19/IN divbuf_19/OUT divbuf_19/OUT2 divbuf_19/OUT3 divbuf_19/OUT4
+ divbuf_19/OUT5 gnd divbuf
Xpll_full_0 vssa1 pll_full
C1655 io_analog[4] gnd 43.96fF
C1656 io_analog[5] gnd 44.13fF
C1657 io_analog[6] gnd 43.46fF
C1658 io_in_3v3[0] gnd 0.61fF
C1659 io_oeb[26] gnd 0.61fF
C1660 io_in[0] gnd 0.61fF
C1661 io_out[26] gnd 0.61fF
C1662 io_out[0] gnd 0.61fF
C1663 io_in[26] gnd 0.61fF
C1664 io_oeb[0] gnd 0.61fF
C1665 io_in_3v3[26] gnd 0.61fF
C1666 io_in_3v3[1] gnd 0.61fF
C1667 io_oeb[25] gnd 0.61fF
C1668 io_in[1] gnd 0.61fF
C1669 io_out[25] gnd 0.61fF
C1670 io_out[1] gnd 0.61fF
C1671 io_in[25] gnd 0.61fF
C1672 io_oeb[1] gnd 0.61fF
C1673 io_in_3v3[25] gnd 0.61fF
C1674 io_in_3v3[2] gnd 0.61fF
C1675 io_oeb[24] gnd 0.61fF
C1676 io_in[2] gnd 0.61fF
C1677 io_out[24] gnd 0.61fF
C1678 io_out[2] gnd 0.61fF
C1679 io_in[24] gnd 0.61fF
C1680 io_oeb[2] gnd 0.61fF
C1681 io_in_3v3[24] gnd 0.61fF
C1682 io_in_3v3[3] gnd 0.61fF
C1683 gpio_noesd[17] gnd 2.32fF
C1684 io_in[3] gnd 0.61fF
C1685 gpio_analog[17] gnd 2.30fF
C1686 io_out[3] gnd 0.61fF
C1687 io_oeb[3] gnd 0.61fF
C1688 io_in_3v3[4] gnd 0.61fF
C1689 io_in[4] gnd 0.61fF
C1690 io_out[4] gnd 0.61fF
C1691 io_oeb[4] gnd 0.61fF
C1692 io_oeb[23] gnd 0.61fF
C1693 io_out[23] gnd 0.61fF
C1694 io_in[23] gnd 0.61fF
C1695 io_in_3v3[23] gnd 0.61fF
C1696 gpio_noesd[16] gnd 2.30fF
C1697 gpio_analog[16] gnd 2.30fF
C1698 io_in_3v3[5] gnd 0.61fF
C1699 io_in[5] gnd 0.61fF
C1700 io_out[5] gnd 0.61fF
C1701 io_oeb[5] gnd 0.61fF
C1702 io_oeb[22] gnd 0.61fF
C1703 io_out[22] gnd 0.61fF
C1704 io_in[22] gnd 0.61fF
C1705 io_in_3v3[22] gnd 0.61fF
C1706 gpio_noesd[15] gnd 2.31fF
C1707 gpio_analog[15] gnd 2.30fF
C1708 io_in_3v3[6] gnd 0.61fF
C1709 io_in[6] gnd 0.61fF
C1710 io_out[6] gnd 0.61fF
C1711 io_oeb[6] gnd 0.61fF
C1712 io_oeb[21] gnd 0.61fF
C1713 io_out[21] gnd 0.61fF
C1714 io_in[21] gnd 0.61fF
C1715 io_in_3v3[21] gnd 0.61fF
C1716 gpio_noesd[14] gnd 2.30fF
C1717 gpio_analog[14] gnd 2.29fF
C1718 vssd2 gnd 38.54fF
C1719 vssd1 gnd 13.04fF
C1720 vdda2 gnd 38.30fF
C1721 io_oeb[20] gnd 0.61fF
C1722 io_out[20] gnd 0.61fF
C1723 io_in[20] gnd 0.61fF
C1724 io_in_3v3[20] gnd 0.61fF
C1725 gpio_noesd[13] gnd 2.31fF
C1726 gpio_analog[13] gnd 2.30fF
C1727 gpio_analog[0] gnd 0.61fF
C1728 gpio_noesd[0] gnd 0.61fF
C1729 io_in_3v3[7] gnd 0.61fF
C1730 io_in[7] gnd 0.61fF
C1731 io_out[7] gnd 0.61fF
C1732 io_oeb[7] gnd 0.61fF
C1733 io_oeb[19] gnd 0.61fF
C1734 io_out[19] gnd 0.61fF
C1735 io_in[19] gnd 0.61fF
C1736 io_in_3v3[19] gnd 0.61fF
C1737 gpio_noesd[12] gnd 2.32fF
C1738 gpio_analog[12] gnd 2.30fF
C1739 gpio_analog[1] gnd 0.61fF
C1740 gpio_noesd[1] gnd 0.61fF
C1741 io_in_3v3[8] gnd 0.61fF
C1742 io_in[8] gnd 0.61fF
C1743 io_out[8] gnd 0.61fF
C1744 io_oeb[8] gnd 0.61fF
C1745 io_oeb[18] gnd 0.61fF
C1746 io_out[18] gnd 0.61fF
C1747 io_in[18] gnd 0.61fF
C1748 io_in_3v3[18] gnd 0.61fF
C1749 gpio_noesd[11] gnd 2.30fF
C1750 gpio_analog[11] gnd 2.29fF
C1751 gpio_analog[2] gnd 0.61fF
C1752 gpio_noesd[2] gnd 0.61fF
C1753 io_in_3v3[9] gnd 0.61fF
C1754 io_in[9] gnd 0.61fF
C1755 io_out[9] gnd 0.61fF
C1756 io_oeb[9] gnd 0.61fF
C1757 io_oeb[17] gnd 0.61fF
C1758 io_out[17] gnd 0.61fF
C1759 io_in[17] gnd 0.61fF
C1760 io_in_3v3[17] gnd 0.61fF
C1761 gpio_noesd[10] gnd 2.31fF
C1762 gpio_analog[10] gnd 2.29fF
C1763 gpio_analog[3] gnd 0.61fF
C1764 gpio_noesd[3] gnd 0.61fF
C1765 io_in_3v3[10] gnd 0.61fF
C1766 io_in[10] gnd 0.61fF
C1767 io_out[10] gnd 0.61fF
C1768 io_oeb[10] gnd 0.61fF
C1769 io_oeb[16] gnd 0.61fF
C1770 io_out[16] gnd 0.61fF
C1771 io_in[16] gnd 0.61fF
C1772 io_in_3v3[16] gnd 0.61fF
C1773 gpio_noesd[9] gnd 2.28fF
C1774 gpio_analog[9] gnd 2.28fF
C1775 gpio_analog[4] gnd 0.61fF
C1776 gpio_noesd[4] gnd 0.61fF
C1777 io_in_3v3[11] gnd 0.61fF
C1778 io_in[11] gnd 0.61fF
C1779 io_out[11] gnd 0.61fF
C1780 io_oeb[11] gnd 0.61fF
C1781 io_oeb[15] gnd 0.61fF
C1782 io_out[15] gnd 0.61fF
C1783 io_in[15] gnd 0.61fF
C1784 io_in_3v3[15] gnd 0.61fF
C1785 gpio_noesd[8] gnd 2.28fF
C1786 gpio_analog[8] gnd 2.26fF
C1787 gpio_analog[5] gnd 0.61fF
C1788 gpio_noesd[5] gnd 0.61fF
C1789 io_in_3v3[12] gnd 0.61fF
C1790 io_in[12] gnd 0.61fF
C1791 io_out[12] gnd 0.61fF
C1792 io_oeb[12] gnd 0.61fF
C1793 io_oeb[14] gnd 0.61fF
C1794 io_out[14] gnd 0.61fF
C1795 io_in[14] gnd 0.61fF
C1796 io_in_3v3[14] gnd 0.61fF
C1797 gpio_noesd[7] gnd 2.30fF
C1798 gpio_analog[7] gnd 2.28fF
C1799 vssa2 gnd 38.35fF
C1800 gpio_analog[6] gnd 5.71fF
C1801 gpio_noesd[6] gnd 5.70fF
C1802 io_in_3v3[13] gnd 0.61fF
C1803 io_in[13] gnd 0.61fF
C1804 io_out[13] gnd 0.61fF
C1805 io_oeb[13] gnd 0.61fF
C1806 vccd1 gnd 39.84fF
C1807 vccd2 gnd 38.46fF
C1808 io_analog[0] gnd 19.99fF
C1809 io_analog[10] gnd 19.36fF
C1810 io_analog[1] gnd 13.17fF
C1811 io_analog[2] gnd 12.57fF
C1812 io_analog[3] gnd 12.83fF
C1813 io_clamp_high[0] gnd 3.58fF
C1814 io_clamp_low[0] gnd 3.58fF
C1815 io_clamp_high[1] gnd 3.58fF
C1816 io_clamp_low[1] gnd 3.58fF
C1817 io_clamp_high[2] gnd 3.58fF
C1818 io_clamp_low[2] gnd 3.58fF
C1819 io_analog[7] gnd 12.74fF
C1820 io_analog[8] gnd 13.08fF
C1821 io_analog[9] gnd 13.08fF
C1822 user_irq[2] gnd 0.63fF
C1823 user_irq[1] gnd 0.63fF
C1824 user_irq[0] gnd 0.63fF
C1825 user_clock2 gnd 0.63fF
C1826 la_oenb[127] gnd 0.63fF
C1827 la_data_out[127] gnd 0.63fF
C1828 la_data_in[127] gnd 0.63fF
C1829 la_oenb[126] gnd 0.63fF
C1830 la_data_out[126] gnd 0.63fF
C1831 la_data_in[126] gnd 0.63fF
C1832 la_oenb[125] gnd 0.63fF
C1833 la_data_out[125] gnd 0.63fF
C1834 la_data_in[125] gnd 0.63fF
C1835 la_oenb[124] gnd 0.63fF
C1836 la_data_out[124] gnd 0.63fF
C1837 la_data_in[124] gnd 0.63fF
C1838 la_oenb[123] gnd 0.63fF
C1839 la_data_out[123] gnd 0.63fF
C1840 la_data_in[123] gnd 0.63fF
C1841 la_oenb[122] gnd 0.63fF
C1842 la_data_out[122] gnd 0.63fF
C1843 la_data_in[122] gnd 0.63fF
C1844 la_oenb[121] gnd 0.63fF
C1845 la_data_out[121] gnd 0.63fF
C1846 la_data_in[121] gnd 0.63fF
C1847 la_oenb[120] gnd 0.63fF
C1848 la_data_out[120] gnd 0.63fF
C1849 la_data_in[120] gnd 0.63fF
C1850 la_oenb[119] gnd 0.63fF
C1851 la_data_out[119] gnd 0.63fF
C1852 la_data_in[119] gnd 0.63fF
C1853 la_oenb[118] gnd 0.63fF
C1854 la_data_out[118] gnd 0.63fF
C1855 la_data_in[118] gnd 0.63fF
C1856 la_oenb[117] gnd 0.63fF
C1857 la_data_out[117] gnd 0.63fF
C1858 la_data_in[117] gnd 0.63fF
C1859 la_oenb[116] gnd 0.63fF
C1860 la_data_out[116] gnd 0.63fF
C1861 la_data_in[116] gnd 0.63fF
C1862 la_oenb[115] gnd 0.63fF
C1863 la_data_out[115] gnd 0.63fF
C1864 la_data_in[115] gnd 0.63fF
C1865 la_oenb[114] gnd 0.63fF
C1866 la_data_out[114] gnd 0.63fF
C1867 la_data_in[114] gnd 0.63fF
C1868 la_oenb[113] gnd 0.63fF
C1869 la_data_out[113] gnd 0.63fF
C1870 la_data_in[113] gnd 0.63fF
C1871 la_oenb[112] gnd 0.63fF
C1872 la_data_out[112] gnd 0.63fF
C1873 la_data_in[112] gnd 0.63fF
C1874 la_oenb[111] gnd 0.63fF
C1875 la_data_out[111] gnd 0.63fF
C1876 la_data_in[111] gnd 0.63fF
C1877 la_oenb[110] gnd 0.63fF
C1878 la_data_out[110] gnd 0.63fF
C1879 la_data_in[110] gnd 0.63fF
C1880 la_oenb[109] gnd 0.63fF
C1881 la_data_out[109] gnd 0.63fF
C1882 la_data_in[109] gnd 0.63fF
C1883 la_oenb[108] gnd 0.63fF
C1884 la_data_out[108] gnd 0.63fF
C1885 la_data_in[108] gnd 0.63fF
C1886 la_oenb[107] gnd 0.63fF
C1887 la_data_out[107] gnd 0.63fF
C1888 la_data_in[107] gnd 0.63fF
C1889 la_oenb[106] gnd 0.63fF
C1890 la_data_out[106] gnd 0.63fF
C1891 la_data_in[106] gnd 0.63fF
C1892 la_oenb[105] gnd 0.63fF
C1893 la_data_out[105] gnd 0.63fF
C1894 la_data_in[105] gnd 0.63fF
C1895 la_oenb[104] gnd 0.63fF
C1896 la_data_out[104] gnd 0.63fF
C1897 la_data_in[104] gnd 0.63fF
C1898 la_oenb[103] gnd 0.63fF
C1899 la_data_out[103] gnd 0.63fF
C1900 la_data_in[103] gnd 0.63fF
C1901 la_oenb[102] gnd 0.63fF
C1902 la_data_out[102] gnd 0.63fF
C1903 la_data_in[102] gnd 0.63fF
C1904 la_oenb[101] gnd 0.63fF
C1905 la_data_out[101] gnd 0.63fF
C1906 la_data_in[101] gnd 0.63fF
C1907 la_oenb[100] gnd 0.63fF
C1908 la_data_out[100] gnd 0.63fF
C1909 la_data_in[100] gnd 0.63fF
C1910 la_oenb[99] gnd 0.63fF
C1911 la_data_out[99] gnd 0.63fF
C1912 la_data_in[99] gnd 0.63fF
C1913 la_oenb[98] gnd 0.63fF
C1914 la_data_out[98] gnd 0.63fF
C1915 la_data_in[98] gnd 0.63fF
C1916 la_oenb[97] gnd 0.63fF
C1917 la_data_out[97] gnd 0.63fF
C1918 la_data_in[97] gnd 0.63fF
C1919 la_oenb[96] gnd 0.63fF
C1920 la_data_out[96] gnd 0.63fF
C1921 la_data_in[96] gnd 0.63fF
C1922 la_oenb[95] gnd 0.63fF
C1923 la_data_out[95] gnd 0.63fF
C1924 la_data_in[95] gnd 0.63fF
C1925 la_oenb[94] gnd 0.63fF
C1926 la_data_out[94] gnd 0.63fF
C1927 la_data_in[94] gnd 0.63fF
C1928 la_oenb[93] gnd 0.63fF
C1929 la_data_out[93] gnd 0.63fF
C1930 la_data_in[93] gnd 0.63fF
C1931 la_oenb[92] gnd 0.63fF
C1932 la_data_out[92] gnd 0.63fF
C1933 la_data_in[92] gnd 0.63fF
C1934 la_oenb[91] gnd 0.63fF
C1935 la_data_out[91] gnd 0.63fF
C1936 la_data_in[91] gnd 0.63fF
C1937 la_oenb[90] gnd 0.63fF
C1938 la_data_out[90] gnd 0.63fF
C1939 la_data_in[90] gnd 0.63fF
C1940 la_oenb[89] gnd 0.63fF
C1941 la_data_out[89] gnd 0.63fF
C1942 la_data_in[89] gnd 0.63fF
C1943 la_oenb[88] gnd 0.63fF
C1944 la_data_out[88] gnd 0.63fF
C1945 la_data_in[88] gnd 0.63fF
C1946 la_oenb[87] gnd 0.63fF
C1947 la_data_out[87] gnd 0.63fF
C1948 la_data_in[87] gnd 0.63fF
C1949 la_oenb[86] gnd 0.63fF
C1950 la_data_out[86] gnd 0.63fF
C1951 la_data_in[86] gnd 0.63fF
C1952 la_oenb[85] gnd 0.63fF
C1953 la_data_out[85] gnd 0.63fF
C1954 la_data_in[85] gnd 0.63fF
C1955 la_oenb[84] gnd 0.63fF
C1956 la_data_out[84] gnd 0.63fF
C1957 la_data_in[84] gnd 0.63fF
C1958 la_oenb[83] gnd 0.63fF
C1959 la_data_out[83] gnd 0.63fF
C1960 la_data_in[83] gnd 0.63fF
C1961 la_oenb[82] gnd 0.63fF
C1962 la_data_out[82] gnd 0.63fF
C1963 la_data_in[82] gnd 0.63fF
C1964 la_oenb[81] gnd 0.63fF
C1965 la_data_out[81] gnd 0.63fF
C1966 la_data_in[81] gnd 0.63fF
C1967 la_oenb[80] gnd 0.63fF
C1968 la_data_out[80] gnd 0.63fF
C1969 la_data_in[80] gnd 0.63fF
C1970 la_oenb[79] gnd 0.63fF
C1971 la_data_out[79] gnd 0.63fF
C1972 la_data_in[79] gnd 0.63fF
C1973 la_oenb[78] gnd 0.63fF
C1974 la_data_out[78] gnd 0.63fF
C1975 la_data_in[78] gnd 0.63fF
C1976 la_oenb[77] gnd 0.63fF
C1977 la_data_out[77] gnd 0.63fF
C1978 la_data_in[77] gnd 0.63fF
C1979 la_oenb[76] gnd 0.63fF
C1980 la_data_out[76] gnd 0.63fF
C1981 la_data_in[76] gnd 0.63fF
C1982 la_oenb[75] gnd 0.63fF
C1983 la_data_out[75] gnd 0.63fF
C1984 la_data_in[75] gnd 0.63fF
C1985 la_oenb[74] gnd 0.63fF
C1986 la_data_out[74] gnd 0.63fF
C1987 la_data_in[74] gnd 0.63fF
C1988 la_oenb[73] gnd 0.63fF
C1989 la_data_out[73] gnd 0.63fF
C1990 la_data_in[73] gnd 0.63fF
C1991 la_oenb[72] gnd 0.63fF
C1992 la_data_out[72] gnd 0.63fF
C1993 la_data_in[72] gnd 0.63fF
C1994 la_oenb[71] gnd 0.63fF
C1995 la_data_out[71] gnd 0.63fF
C1996 la_data_in[71] gnd 0.63fF
C1997 la_oenb[70] gnd 0.63fF
C1998 la_data_out[70] gnd 0.63fF
C1999 la_data_in[70] gnd 0.63fF
C2000 la_oenb[69] gnd 0.63fF
C2001 la_data_out[69] gnd 0.63fF
C2002 la_data_in[69] gnd 0.63fF
C2003 la_oenb[68] gnd 0.63fF
C2004 la_data_out[68] gnd 0.63fF
C2005 la_data_in[68] gnd 0.63fF
C2006 la_oenb[67] gnd 0.63fF
C2007 la_data_out[67] gnd 0.63fF
C2008 la_data_in[67] gnd 0.63fF
C2009 la_oenb[66] gnd 0.63fF
C2010 la_data_out[66] gnd 0.63fF
C2011 la_data_in[66] gnd 0.63fF
C2012 la_oenb[65] gnd 0.63fF
C2013 la_data_out[65] gnd 0.63fF
C2014 la_data_in[65] gnd 0.63fF
C2015 la_oenb[64] gnd 0.63fF
C2016 la_data_out[64] gnd 0.63fF
C2017 la_data_in[64] gnd 0.63fF
C2018 la_oenb[63] gnd 0.63fF
C2019 la_data_out[63] gnd 0.63fF
C2020 la_data_in[63] gnd 0.63fF
C2021 la_oenb[62] gnd 0.63fF
C2022 la_data_out[62] gnd 0.63fF
C2023 la_data_in[62] gnd 0.63fF
C2024 la_oenb[61] gnd 0.63fF
C2025 la_data_out[61] gnd 0.63fF
C2026 la_data_in[61] gnd 0.63fF
C2027 la_oenb[60] gnd 0.63fF
C2028 la_data_out[60] gnd 0.63fF
C2029 la_data_in[60] gnd 0.63fF
C2030 la_oenb[59] gnd 0.63fF
C2031 la_data_out[59] gnd 0.63fF
C2032 la_data_in[59] gnd 0.63fF
C2033 la_oenb[58] gnd 0.63fF
C2034 la_data_out[58] gnd 0.63fF
C2035 la_data_in[58] gnd 0.63fF
C2036 la_oenb[57] gnd 0.63fF
C2037 la_data_out[57] gnd 0.63fF
C2038 la_data_in[57] gnd 0.63fF
C2039 la_oenb[56] gnd 0.63fF
C2040 la_data_out[56] gnd 0.63fF
C2041 la_data_in[56] gnd 0.63fF
C2042 la_oenb[55] gnd 0.63fF
C2043 la_data_out[55] gnd 0.63fF
C2044 la_data_in[55] gnd 0.63fF
C2045 la_oenb[54] gnd 0.63fF
C2046 la_data_out[54] gnd 0.63fF
C2047 la_data_in[54] gnd 0.63fF
C2048 la_oenb[53] gnd 0.63fF
C2049 la_data_out[53] gnd 0.63fF
C2050 la_data_in[53] gnd 0.63fF
C2051 la_oenb[52] gnd 0.63fF
C2052 la_data_out[52] gnd 0.63fF
C2053 la_data_in[52] gnd 0.63fF
C2054 la_oenb[51] gnd 0.63fF
C2055 la_data_out[51] gnd 0.63fF
C2056 la_data_in[51] gnd 0.63fF
C2057 la_oenb[50] gnd 0.63fF
C2058 la_data_out[50] gnd 0.63fF
C2059 la_data_in[50] gnd 0.63fF
C2060 la_oenb[49] gnd 0.63fF
C2061 la_data_out[49] gnd 0.63fF
C2062 la_data_in[49] gnd 0.63fF
C2063 la_oenb[48] gnd 0.63fF
C2064 la_data_out[48] gnd 0.63fF
C2065 la_data_in[48] gnd 0.63fF
C2066 la_oenb[47] gnd 0.63fF
C2067 la_data_out[47] gnd 0.63fF
C2068 la_data_in[47] gnd 0.63fF
C2069 la_oenb[46] gnd 0.63fF
C2070 la_data_out[46] gnd 0.63fF
C2071 la_data_in[46] gnd 0.63fF
C2072 la_oenb[45] gnd 0.63fF
C2073 la_data_out[45] gnd 0.63fF
C2074 la_data_in[45] gnd 0.63fF
C2075 la_oenb[44] gnd 0.63fF
C2076 la_data_out[44] gnd 0.63fF
C2077 la_data_in[44] gnd 0.63fF
C2078 la_oenb[43] gnd 0.63fF
C2079 la_data_out[43] gnd 0.63fF
C2080 la_data_in[43] gnd 0.63fF
C2081 la_oenb[42] gnd 0.63fF
C2082 la_data_out[42] gnd 0.63fF
C2083 la_data_in[42] gnd 0.63fF
C2084 la_oenb[41] gnd 0.63fF
C2085 la_data_out[41] gnd 0.63fF
C2086 la_data_in[41] gnd 0.63fF
C2087 la_oenb[40] gnd 0.63fF
C2088 la_data_out[40] gnd 0.63fF
C2089 la_data_in[40] gnd 0.63fF
C2090 la_oenb[39] gnd 0.63fF
C2091 la_data_out[39] gnd 0.63fF
C2092 la_data_in[39] gnd 0.63fF
C2093 la_oenb[38] gnd 0.63fF
C2094 la_data_out[38] gnd 0.63fF
C2095 la_data_in[38] gnd 0.63fF
C2096 la_oenb[37] gnd 0.63fF
C2097 la_data_out[37] gnd 0.63fF
C2098 la_data_in[37] gnd 0.63fF
C2099 la_oenb[36] gnd 0.63fF
C2100 la_data_out[36] gnd 0.63fF
C2101 la_data_in[36] gnd 0.63fF
C2102 la_oenb[35] gnd 0.63fF
C2103 la_data_out[35] gnd 0.63fF
C2104 la_data_in[35] gnd 0.63fF
C2105 la_oenb[34] gnd 0.63fF
C2106 la_data_out[34] gnd 0.63fF
C2107 la_data_in[34] gnd 0.63fF
C2108 la_oenb[33] gnd 0.63fF
C2109 la_data_out[33] gnd 0.63fF
C2110 la_data_in[33] gnd 0.63fF
C2111 la_oenb[32] gnd 0.63fF
C2112 la_data_out[32] gnd 0.63fF
C2113 la_data_in[32] gnd 0.63fF
C2114 la_oenb[31] gnd 0.63fF
C2115 la_data_out[31] gnd 0.63fF
C2116 la_data_in[31] gnd 0.63fF
C2117 la_oenb[30] gnd 0.63fF
C2118 la_data_out[30] gnd 0.63fF
C2119 la_data_in[30] gnd 0.63fF
C2120 la_oenb[29] gnd 0.63fF
C2121 la_data_out[29] gnd 0.63fF
C2122 la_data_in[29] gnd 0.63fF
C2123 la_oenb[28] gnd 0.63fF
C2124 la_data_out[28] gnd 0.63fF
C2125 la_data_in[28] gnd 0.63fF
C2126 la_oenb[27] gnd 0.63fF
C2127 la_data_out[27] gnd 0.63fF
C2128 la_data_in[27] gnd 0.63fF
C2129 la_oenb[26] gnd 0.63fF
C2130 la_data_out[26] gnd 0.63fF
C2131 la_data_in[26] gnd 0.63fF
C2132 la_oenb[25] gnd 0.63fF
C2133 la_data_out[25] gnd 0.63fF
C2134 la_data_in[25] gnd 0.63fF
C2135 la_oenb[24] gnd 0.63fF
C2136 la_data_out[24] gnd 0.63fF
C2137 la_data_in[24] gnd 0.63fF
C2138 la_oenb[23] gnd 0.63fF
C2139 la_data_out[23] gnd 0.63fF
C2140 la_data_in[23] gnd 0.63fF
C2141 la_oenb[22] gnd 0.63fF
C2142 la_data_out[22] gnd 0.63fF
C2143 la_data_in[22] gnd 0.63fF
C2144 la_oenb[21] gnd 0.63fF
C2145 la_data_out[21] gnd 0.63fF
C2146 la_data_in[21] gnd 0.63fF
C2147 la_oenb[20] gnd 0.63fF
C2148 la_data_out[20] gnd 0.63fF
C2149 la_data_in[20] gnd 0.63fF
C2150 la_oenb[19] gnd 0.63fF
C2151 la_data_out[19] gnd 0.63fF
C2152 la_data_in[19] gnd 0.63fF
C2153 la_oenb[18] gnd 0.63fF
C2154 la_data_out[18] gnd 0.63fF
C2155 la_data_in[18] gnd 0.63fF
C2156 la_oenb[17] gnd 0.63fF
C2157 la_data_out[17] gnd 0.63fF
C2158 la_data_in[17] gnd 0.63fF
C2159 la_oenb[16] gnd 0.63fF
C2160 la_data_out[16] gnd 0.63fF
C2161 la_data_in[16] gnd 0.63fF
C2162 la_oenb[15] gnd 0.63fF
C2163 la_data_out[15] gnd 0.63fF
C2164 la_data_in[15] gnd 0.63fF
C2165 la_oenb[14] gnd 0.63fF
C2166 la_data_out[14] gnd 0.63fF
C2167 la_data_in[14] gnd 0.63fF
C2168 la_oenb[13] gnd 0.63fF
C2169 la_data_out[13] gnd 0.63fF
C2170 la_data_in[13] gnd 0.63fF
C2171 la_oenb[12] gnd 0.63fF
C2172 la_data_out[12] gnd 0.63fF
C2173 la_data_in[12] gnd 0.63fF
C2174 la_oenb[11] gnd 0.63fF
C2175 la_data_out[11] gnd 0.63fF
C2176 la_data_in[11] gnd 0.63fF
C2177 la_oenb[10] gnd 0.63fF
C2178 la_data_out[10] gnd 0.63fF
C2179 la_data_in[10] gnd 0.63fF
C2180 la_oenb[9] gnd 0.63fF
C2181 la_data_out[9] gnd 0.63fF
C2182 la_data_in[9] gnd 0.63fF
C2183 la_oenb[8] gnd 0.63fF
C2184 la_data_out[8] gnd 0.63fF
C2185 la_data_in[8] gnd 0.63fF
C2186 la_oenb[7] gnd 0.63fF
C2187 la_data_out[7] gnd 0.63fF
C2188 la_data_in[7] gnd 0.63fF
C2189 la_oenb[6] gnd 0.63fF
C2190 la_data_out[6] gnd 0.63fF
C2191 la_data_in[6] gnd 0.63fF
C2192 la_oenb[5] gnd 0.63fF
C2193 la_data_out[5] gnd 0.63fF
C2194 la_data_in[5] gnd 0.63fF
C2195 la_oenb[4] gnd 0.63fF
C2196 la_data_out[4] gnd 0.63fF
C2197 la_data_in[4] gnd 0.63fF
C2198 la_oenb[3] gnd 0.63fF
C2199 la_data_out[3] gnd 0.63fF
C2200 la_data_in[3] gnd 0.63fF
C2201 la_oenb[2] gnd 0.63fF
C2202 la_data_out[2] gnd 0.63fF
C2203 la_data_in[2] gnd 0.63fF
C2204 la_oenb[1] gnd 0.63fF
C2205 la_data_out[1] gnd 0.63fF
C2206 la_data_in[1] gnd 0.63fF
C2207 la_oenb[0] gnd 0.63fF
C2208 la_data_out[0] gnd 0.63fF
C2209 la_data_in[0] gnd 0.63fF
C2210 wbs_dat_o[31] gnd 0.63fF
C2211 wbs_dat_i[31] gnd 0.63fF
C2212 wbs_adr_i[31] gnd 0.63fF
C2213 wbs_dat_o[30] gnd 0.63fF
C2214 wbs_dat_i[30] gnd 0.63fF
C2215 wbs_adr_i[30] gnd 0.63fF
C2216 wbs_dat_o[29] gnd 0.63fF
C2217 wbs_dat_i[29] gnd 0.63fF
C2218 wbs_adr_i[29] gnd 0.63fF
C2219 wbs_dat_o[28] gnd 0.63fF
C2220 wbs_dat_i[28] gnd 0.63fF
C2221 wbs_adr_i[28] gnd 0.63fF
C2222 wbs_dat_o[27] gnd 0.63fF
C2223 wbs_dat_i[27] gnd 0.63fF
C2224 wbs_adr_i[27] gnd 0.63fF
C2225 wbs_dat_o[26] gnd 0.63fF
C2226 wbs_dat_i[26] gnd 0.63fF
C2227 wbs_adr_i[26] gnd 0.63fF
C2228 wbs_dat_o[25] gnd 0.63fF
C2229 wbs_dat_i[25] gnd 0.63fF
C2230 wbs_adr_i[25] gnd 0.63fF
C2231 wbs_dat_o[24] gnd 0.63fF
C2232 wbs_dat_i[24] gnd 0.63fF
C2233 wbs_adr_i[24] gnd 0.63fF
C2234 wbs_dat_o[23] gnd 0.63fF
C2235 wbs_dat_i[23] gnd 0.63fF
C2236 wbs_adr_i[23] gnd 0.63fF
C2237 wbs_dat_o[22] gnd 0.63fF
C2238 wbs_dat_i[22] gnd 0.63fF
C2239 wbs_adr_i[22] gnd 0.63fF
C2240 wbs_dat_o[21] gnd 0.63fF
C2241 wbs_dat_i[21] gnd 0.63fF
C2242 wbs_adr_i[21] gnd 0.63fF
C2243 wbs_dat_o[20] gnd 0.63fF
C2244 wbs_dat_i[20] gnd 0.63fF
C2245 wbs_adr_i[20] gnd 0.63fF
C2246 wbs_dat_o[19] gnd 0.63fF
C2247 wbs_dat_i[19] gnd 0.63fF
C2248 wbs_adr_i[19] gnd 0.63fF
C2249 wbs_dat_o[18] gnd 0.63fF
C2250 wbs_dat_i[18] gnd 0.63fF
C2251 wbs_adr_i[18] gnd 0.63fF
C2252 wbs_dat_o[17] gnd 0.63fF
C2253 wbs_dat_i[17] gnd 0.63fF
C2254 wbs_adr_i[17] gnd 0.63fF
C2255 wbs_dat_o[16] gnd 0.63fF
C2256 wbs_dat_i[16] gnd 0.63fF
C2257 wbs_adr_i[16] gnd 0.63fF
C2258 wbs_dat_o[15] gnd 0.63fF
C2259 wbs_dat_i[15] gnd 0.63fF
C2260 wbs_adr_i[15] gnd 0.63fF
C2261 wbs_dat_o[14] gnd 0.63fF
C2262 wbs_dat_i[14] gnd 0.63fF
C2263 wbs_adr_i[14] gnd 0.63fF
C2264 wbs_dat_o[13] gnd 0.63fF
C2265 wbs_dat_i[13] gnd 0.63fF
C2266 wbs_adr_i[13] gnd 0.63fF
C2267 wbs_dat_o[12] gnd 0.63fF
C2268 wbs_dat_i[12] gnd 0.63fF
C2269 wbs_adr_i[12] gnd 0.63fF
C2270 wbs_dat_o[11] gnd 0.63fF
C2271 wbs_dat_i[11] gnd 0.63fF
C2272 wbs_adr_i[11] gnd 0.63fF
C2273 wbs_dat_o[10] gnd 0.63fF
C2274 wbs_dat_i[10] gnd 0.63fF
C2275 wbs_adr_i[10] gnd 0.63fF
C2276 wbs_dat_o[9] gnd 0.63fF
C2277 wbs_dat_i[9] gnd 0.63fF
C2278 wbs_adr_i[9] gnd 0.63fF
C2279 wbs_dat_o[8] gnd 0.63fF
C2280 wbs_dat_i[8] gnd 0.63fF
C2281 wbs_adr_i[8] gnd 0.63fF
C2282 wbs_dat_o[7] gnd 0.63fF
C2283 wbs_dat_i[7] gnd 0.63fF
C2284 wbs_adr_i[7] gnd 0.63fF
C2285 wbs_dat_o[6] gnd 0.63fF
C2286 wbs_dat_i[6] gnd 0.63fF
C2287 wbs_adr_i[6] gnd 0.63fF
C2288 wbs_dat_o[5] gnd 0.63fF
C2289 wbs_dat_i[5] gnd 0.63fF
C2290 wbs_adr_i[5] gnd 0.63fF
C2291 wbs_dat_o[4] gnd 0.63fF
C2292 wbs_dat_i[4] gnd 0.63fF
C2293 wbs_adr_i[4] gnd 0.63fF
C2294 wbs_sel_i[3] gnd 0.63fF
C2295 wbs_dat_o[3] gnd 0.63fF
C2296 wbs_dat_i[3] gnd 0.63fF
C2297 wbs_adr_i[3] gnd 0.63fF
C2298 wbs_sel_i[2] gnd 0.63fF
C2299 wbs_dat_o[2] gnd 0.63fF
C2300 wbs_dat_i[2] gnd 0.63fF
C2301 wbs_adr_i[2] gnd 0.63fF
C2302 wbs_sel_i[1] gnd 0.63fF
C2303 wbs_dat_o[1] gnd 0.63fF
C2304 wbs_dat_i[1] gnd 0.63fF
C2305 wbs_adr_i[1] gnd 0.63fF
C2306 wbs_sel_i[0] gnd 0.63fF
C2307 wbs_dat_o[0] gnd 0.63fF
C2308 wbs_dat_i[0] gnd 0.63fF
C2309 wbs_adr_i[0] gnd 0.63fF
C2310 wbs_we_i gnd 0.63fF
C2311 wbs_stb_i gnd 0.63fF
C2312 wbs_cyc_i gnd 0.63fF
C2313 wbs_ack_o gnd 0.63fF
C2314 wb_rst_i gnd 0.63fF
C2315 wb_clk_i gnd 0.63fF
C2316 m2_494098_659718# gnd 0.80fF **FLOATING
C2317 pll_full_0/divider_0/and_0/Z1 gnd 0.65fF
C2318 pll_full_0/divider_0/and_0/B gnd 2.45fF
C2319 pll_full_0/divider_0/and_0/A gnd 2.35fF
C2320 pll_full_0/divider_0/and_0/out1 gnd 2.99fF
C2321 pll_full_0/divider_0/tspc_2/Z4 gnd 0.86fF
C2322 pll_full_0/divider_0/tspc_2/Z3 gnd 2.26fF
C2323 pll_full_0/divider_0/tspc_2/Z2 gnd 1.46fF
C2324 pll_full_0/divider_0/tspc_2/Z1 gnd 0.99fF
C2325 pll_full_0/divider_0/nor_0/A gnd 7.08fF
C2326 pll_full_0/divider_0/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2327 pll_full_0/divider_0/tspc_1/Z4 gnd 0.86fF
C2328 pll_full_0/divider_0/tspc_1/Z3 gnd 2.26fF
C2329 pll_full_0/divider_0/tspc_1/Z2 gnd 1.46fF
C2330 pll_full_0/divider_0/tspc_1/Z1 gnd 0.99fF
C2331 pll_full_0/divider_0/nor_0/B gnd 7.12fF
C2332 pll_full_0/divider_0/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2333 pll_full_0/divider_0/tspc_2/Q gnd 3.14fF
C2334 pll_full_0/divider_0/tspc_0/Z4 gnd 0.86fF
C2335 pll_full_0/divbuf_1/IN gnd 9.89fF
C2336 pll_full_0/divider_0/tspc_0/Z3 gnd 2.26fF
C2337 pll_full_0/divider_0/tspc_0/Z2 gnd 1.46fF
C2338 pll_full_0/divider_0/tspc_0/Z1 gnd 0.99fF
C2339 pll_full_0/divider_0/nor_1/B gnd 6.48fF
C2340 pll_full_0/divider_0/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2341 pll_full_0/divider_0/tspc_1/Q gnd 3.12fF
C2342 pll_full_0/divider_0/clk gnd 33.52fF
C2343 pll_full_0/divider_0/prescaler_0/nand_1/z1 gnd 0.36fF
C2344 pll_full_0/divider_0/prescaler_0/tspc_0/D gnd 2.64fF
C2345 pll_full_0/divider_0/prescaler_0/tspc_2/Q gnd 3.72fF
C2346 pll_full_0/divider_0/prescaler_0/tspc_1/Q gnd 3.61fF
C2347 pll_full_0/divider_0/prescaler_0/nand_0/z1 gnd 0.36fF
C2348 pll_full_0/divider_0/prescaler_0/tspc_2/D gnd 3.12fF
C2349 pll_full_0/divider_0/and_0/OUT gnd 5.67fF
C2350 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2351 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2352 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 gnd 1.19fF
C2353 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2354 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# gnd 1.47fF **FLOATING
C2355 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2356 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2357 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2358 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2359 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2360 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2361 pll_full_0/divider_0/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2362 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2363 pll_full_0/divider_0/prescaler_0/Out gnd 4.59fF
C2364 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2365 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2366 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2367 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2368 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2369 pll_full_0/divider_0/nor_1/Z1 gnd 1.34fF
C2370 pll_full_0/divider_0/nor_0/Z1 gnd 1.34fF
C2371 pll_full_0/divbuf_1/OUT5 gnd 350.37fF
C2372 pll_full_0/divbuf_1/OUT4 gnd 133.72fF
C2373 pll_full_0/divbuf_1/OUT3 gnd 34.03fF
C2374 pll_full_0/divbuf_1/OUT2 gnd 8.71fF
C2375 pll_full_0/divbuf_1/a_492_n240# gnd 2.46fF **FLOATING
C2376 pll_full_0/divbuf_0/OUT gnd 363.82fF
C2377 pll_full_0/divbuf_0/OUT5 gnd 350.37fF
C2378 pll_full_0/divbuf_0/OUT4 gnd 133.72fF
C2379 pll_full_0/divbuf_0/OUT3 gnd 34.03fF
C2380 pll_full_0/divbuf_0/OUT2 gnd 8.71fF
C2381 pll_full_0/divbuf_0/a_492_n240# gnd 2.46fF **FLOATING
C2382 pll_full_0/ro_complete_0/cbank_2/v gnd 16.46fF
C2383 pll_full_0/ro_complete_0/cbank_2/switch_5/vin gnd 0.78fF
C2384 pll_full_0/ro_complete_0/cbank_2/switch_4/vin gnd 1.50fF
C2385 pll_full_0/ro_complete_0/cbank_2/switch_2/vin gnd 1.30fF
C2386 pll_full_0/ro_complete_0/cbank_2/switch_3/vin gnd 0.56fF
C2387 pll_full_0/ro_complete_0/cbank_2/switch_1/vin gnd 1.14fF
C2388 pll_full_0/ro_complete_0/cbank_2/switch_0/vin gnd 1.02fF
C2389 pll_full_0/ro_complete_0/cbank_1/switch_5/vin gnd 0.78fF
C2390 pll_full_0/ro_complete_0/a0 gnd 5.35fF
C2391 pll_full_0/ro_complete_0/cbank_1/switch_4/vin gnd 1.50fF
C2392 pll_full_0/ro_complete_0/a1 gnd 6.54fF
C2393 pll_full_0/ro_complete_0/cbank_1/switch_2/vin gnd 1.30fF
C2394 pll_full_0/ro_complete_0/a3 gnd 5.96fF
C2395 pll_full_0/ro_complete_0/cbank_1/switch_3/vin gnd 0.56fF
C2396 pll_full_0/ro_complete_0/a2 gnd 5.21fF
C2397 pll_full_0/ro_complete_0/cbank_1/switch_1/vin gnd 1.14fF
C2398 pll_full_0/ro_complete_0/a4 gnd 5.81fF
C2399 pll_full_0/ro_complete_0/cbank_1/switch_0/vin gnd 1.02fF
C2400 pll_full_0/ro_complete_0/a5 gnd 6.74fF
C2401 pll_full_0/ro_complete_0/cbank_0/v gnd 15.14fF
C2402 pll_full_0/ro_complete_0/cbank_0/switch_5/vin gnd 0.78fF
C2403 pll_full_0/ro_complete_0/cbank_0/switch_4/vin gnd 1.50fF
C2404 pll_full_0/ro_complete_0/cbank_0/switch_2/vin gnd 1.30fF
C2405 pll_full_0/ro_complete_0/cbank_0/switch_3/vin gnd 0.56fF
C2406 pll_full_0/ro_complete_0/cbank_0/switch_1/vin gnd 1.14fF
C2407 pll_full_0/ro_complete_0/cbank_0/switch_0/vin gnd 1.02fF
C2408 pll_full_0/ro_complete_0/ro_var_extend_0/vcont gnd 0.27fF
C2409 pll_full_0/filter_0/a_4216_n5230# gnd 418.90fF **FLOATING
C2410 pll_full_0/filter_0/a_4216_n2998# gnd 1.39fF **FLOATING
C2411 pll_full_0/cp_0/down gnd 1.54fF
C2412 pll_full_0/cp_0/upbar gnd 1.79fF
C2413 pll_full_0/cp_0/a_7110_n2840# gnd 0.17fF **FLOATING
C2414 pll_full_0/cp_0/a_3060_n2840# gnd 1.71fF **FLOATING
C2415 pll_full_0/cp_0/a_7110_0# gnd 0.17fF **FLOATING
C2416 pll_full_0/cp_0/a_6370_0# gnd 0.40fF **FLOATING
C2417 pll_full_0/cp_0/a_3060_0# gnd 2.49fF **FLOATING
C2418 pll_full_0/cp_0/a_1710_0# gnd 7.47fF **FLOATING
C2419 pll_full_0/pd_0/and_pd_0/Z1 gnd 0.39fF
C2420 pll_full_0/pd_0/and_pd_0/Out1 gnd 2.22fF
C2421 pll_full_0/pd_0/tspc_r_1/z5 gnd 1.10fF
C2422 pll_full_0/pd_0/tspc_r_1/Z4 gnd 1.07fF
C2423 pll_full_0/pd_0/tspc_r_1/Qbar gnd 0.88fF
C2424 pll_full_0/pd_0/tspc_r_1/Z2 gnd 1.22fF
C2425 pll_full_0/pd_0/tspc_r_1/Z1 gnd 0.67fF
C2426 pll_full_0/pd_0/UP gnd 6.41fF
C2427 pll_full_0/pd_0/tspc_r_1/Qbar1 gnd 1.34fF
C2428 pll_full_0/pd_0/tspc_r_1/Z3 gnd 2.12fF
C2429 pll_full_0/pd_0/REF gnd 6.48fF
C2430 pll_full_0/pd_0/tspc_r_0/z5 gnd 1.10fF
C2431 pll_full_0/pd_0/tspc_r_0/Z4 gnd 1.07fF
C2432 pll_full_0/pd_0/R gnd 3.05fF
C2433 pll_full_0/pd_0/tspc_r_0/Qbar gnd 0.79fF
C2434 pll_full_0/pd_0/tspc_r_0/Z2 gnd 1.22fF
C2435 pll_full_0/pd_0/tspc_r_0/Z1 gnd 0.67fF
C2436 pll_full_0/pd_0/DOWN gnd 7.34fF
C2437 pll_full_0/pd_0/tspc_r_0/Qbar1 gnd 1.34fF
C2438 pll_full_0/pd_0/tspc_r_0/Z3 gnd 2.12fF
C2439 pll_full_0/pd_0/DIV gnd 372.69fF
C2440 divbuf_19/OUT gnd 363.82fF
C2441 divbuf_19/OUT5 gnd 350.37fF
C2442 divbuf_19/OUT4 gnd 133.72fF
C2443 divbuf_19/OUT3 gnd 34.03fF
C2444 divbuf_19/OUT2 gnd 8.71fF
C2445 divbuf_19/IN gnd 0.89fF
C2446 divbuf_19/a_492_n240# gnd 2.46fF **FLOATING
C2447 divbuf_18/OUT gnd 363.82fF
C2448 divbuf_18/OUT5 gnd 350.37fF
C2449 divbuf_18/OUT4 gnd 133.72fF
C2450 divbuf_18/OUT3 gnd 34.03fF
C2451 divbuf_18/OUT2 gnd 8.71fF
C2452 divbuf_18/IN gnd 0.89fF
C2453 divbuf_18/a_492_n240# gnd 2.46fF **FLOATING
C2454 divbuf_17/OUT gnd 363.82fF
C2455 divbuf_17/OUT5 gnd 350.37fF
C2456 divbuf_17/OUT4 gnd 133.72fF
C2457 divbuf_17/OUT3 gnd 34.03fF
C2458 divbuf_17/OUT2 gnd 8.71fF
C2459 divbuf_17/IN gnd 0.89fF
C2460 divbuf_17/a_492_n240# gnd 2.46fF **FLOATING
C2461 divider_2/and_0/Z1 gnd 0.74fF
C2462 divider_2/and_0/B gnd 2.25fF
C2463 divider_2/and_0/A gnd 2.19fF
C2464 divider_2/and_0/out1 gnd 2.93fF
C2465 divider_2/tspc_2/Z4 gnd 0.86fF
C2466 divider_2/tspc_2/Z3 gnd 2.26fF
C2467 divider_2/tspc_2/Z2 gnd 1.46fF
C2468 divider_2/tspc_2/Z1 gnd 0.99fF
C2469 divider_2/nor_0/A gnd 7.04fF
C2470 divider_2/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2471 divider_2/tspc_1/Z4 gnd 0.86fF
C2472 divider_2/tspc_1/Z3 gnd 2.26fF
C2473 divider_2/tspc_1/Z2 gnd 1.46fF
C2474 divider_2/tspc_1/Z1 gnd 0.99fF
C2475 divider_2/nor_0/B gnd 7.05fF
C2476 divider_2/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2477 divider_2/tspc_2/Q gnd 3.14fF
C2478 divider_2/tspc_0/Z4 gnd 0.86fF
C2479 divider_2/Out gnd 1.60fF
C2480 divider_2/tspc_0/Z3 gnd 2.26fF
C2481 divider_2/tspc_0/Z2 gnd 1.46fF
C2482 divider_2/tspc_0/Z1 gnd 0.99fF
C2483 divider_2/nor_1/B gnd 6.33fF
C2484 divider_2/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2485 divider_2/tspc_1/Q gnd 3.12fF
C2486 divider_2/clk gnd 5.63fF
C2487 divider_2/prescaler_0/nand_1/z1 gnd 0.36fF
C2488 divider_2/prescaler_0/tspc_0/D gnd 2.64fF
C2489 divider_2/prescaler_0/tspc_2/Q gnd 3.74fF
C2490 divider_2/prescaler_0/tspc_1/Q gnd 3.61fF
C2491 divider_2/prescaler_0/nand_0/z1 gnd 0.36fF
C2492 divider_2/prescaler_0/tspc_2/D gnd 3.12fF
C2493 divider_2/and_0/OUT gnd 5.62fF
C2494 divider_2/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2495 divider_2/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2496 divider_2/prescaler_0/tspc_2/Z2 gnd 1.46fF
C2497 divider_2/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2498 divider_2/prescaler_0/tspc_2/a_630_n680# gnd 1.14fF **FLOATING
C2499 divider_2/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2500 divider_2/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2501 divider_2/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2502 divider_2/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2503 divider_2/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2504 divider_2/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2505 divider_2/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2506 divider_2/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2507 divider_2/prescaler_0/Out gnd 4.59fF
C2508 divider_2/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2509 divider_2/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2510 divider_2/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2511 divider_2/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2512 divider_2/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2513 divider_2/nor_1/Z1 gnd 1.34fF
C2514 divider_2/mc2 gnd 5.29fF
C2515 divider_2/nor_0/Z1 gnd 1.34fF
C2516 divbuf_16/OUT gnd 363.82fF
C2517 divbuf_16/OUT5 gnd 350.37fF
C2518 divbuf_16/OUT4 gnd 133.72fF
C2519 divbuf_16/OUT3 gnd 34.03fF
C2520 divbuf_16/OUT2 gnd 8.71fF
C2521 divbuf_16/IN gnd 0.89fF
C2522 divbuf_16/a_492_n240# gnd 2.46fF **FLOATING
C2523 divider_1/and_0/Z1 gnd 0.74fF
C2524 divider_1/and_0/B gnd 2.25fF
C2525 divider_1/and_0/A gnd 2.19fF
C2526 divider_1/and_0/out1 gnd 2.93fF
C2527 divider_1/tspc_2/Z4 gnd 0.86fF
C2528 divider_1/tspc_2/Z3 gnd 2.26fF
C2529 divider_1/tspc_2/Z2 gnd 1.46fF
C2530 divider_1/tspc_2/Z1 gnd 0.99fF
C2531 divider_1/nor_0/A gnd 7.04fF
C2532 divider_1/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2533 divider_1/tspc_1/Z4 gnd 0.86fF
C2534 divider_1/tspc_1/Z3 gnd 2.26fF
C2535 divider_1/tspc_1/Z2 gnd 1.46fF
C2536 divider_1/tspc_1/Z1 gnd 0.99fF
C2537 divider_1/nor_0/B gnd 7.05fF
C2538 divider_1/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2539 divider_1/tspc_2/Q gnd 3.14fF
C2540 divider_1/tspc_0/Z4 gnd 0.86fF
C2541 divider_1/Out gnd 1.60fF
C2542 divider_1/tspc_0/Z3 gnd 2.26fF
C2543 divider_1/tspc_0/Z2 gnd 1.46fF
C2544 divider_1/tspc_0/Z1 gnd 0.99fF
C2545 divider_1/nor_1/B gnd 6.33fF
C2546 divider_1/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2547 divider_1/tspc_1/Q gnd 3.12fF
C2548 divider_1/clk gnd 5.63fF
C2549 divider_1/prescaler_0/nand_1/z1 gnd 0.36fF
C2550 divider_1/prescaler_0/tspc_0/D gnd 2.64fF
C2551 divider_1/prescaler_0/tspc_2/Q gnd 3.74fF
C2552 divider_1/prescaler_0/tspc_1/Q gnd 3.61fF
C2553 divider_1/prescaler_0/nand_0/z1 gnd 0.36fF
C2554 divider_1/prescaler_0/tspc_2/D gnd 3.12fF
C2555 divider_1/and_0/OUT gnd 5.62fF
C2556 divider_1/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2557 divider_1/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2558 divider_1/prescaler_0/tspc_2/Z2 gnd 1.46fF
C2559 divider_1/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2560 divider_1/prescaler_0/tspc_2/a_630_n680# gnd 1.14fF **FLOATING
C2561 divider_1/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2562 divider_1/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2563 divider_1/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2564 divider_1/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2565 divider_1/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2566 divider_1/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2567 divider_1/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2568 divider_1/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2569 divider_1/prescaler_0/Out gnd 4.59fF
C2570 divider_1/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2571 divider_1/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2572 divider_1/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2573 divider_1/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2574 divider_1/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2575 divider_1/nor_1/Z1 gnd 1.34fF
C2576 divider_1/mc2 gnd 5.29fF
C2577 divider_1/nor_0/Z1 gnd 1.34fF
C2578 divbuf_15/OUT gnd 363.82fF
C2579 divbuf_15/OUT5 gnd 350.37fF
C2580 divbuf_15/OUT4 gnd 133.72fF
C2581 divbuf_15/OUT3 gnd 34.03fF
C2582 divbuf_15/OUT2 gnd 8.71fF
C2583 divbuf_15/IN gnd 0.89fF
C2584 divbuf_15/a_492_n240# gnd 2.46fF **FLOATING
C2585 divider_0/and_0/Z1 gnd 0.74fF
C2586 divider_0/and_0/B gnd 2.25fF
C2587 divider_0/and_0/A gnd 2.19fF
C2588 divider_0/and_0/out1 gnd 2.93fF
C2589 divider_0/tspc_2/Z4 gnd 0.86fF
C2590 divider_0/tspc_2/Z3 gnd 2.26fF
C2591 divider_0/tspc_2/Z2 gnd 1.46fF
C2592 divider_0/tspc_2/Z1 gnd 0.99fF
C2593 divider_0/nor_0/A gnd 7.04fF
C2594 divider_0/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2595 divider_0/tspc_1/Z4 gnd 0.86fF
C2596 divider_0/tspc_1/Z3 gnd 2.26fF
C2597 divider_0/tspc_1/Z2 gnd 1.46fF
C2598 divider_0/tspc_1/Z1 gnd 0.99fF
C2599 divider_0/nor_0/B gnd 7.05fF
C2600 divider_0/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2601 divider_0/tspc_2/Q gnd 3.14fF
C2602 divider_0/tspc_0/Z4 gnd 0.86fF
C2603 divider_0/Out gnd 1.60fF
C2604 divider_0/tspc_0/Z3 gnd 2.26fF
C2605 divider_0/tspc_0/Z2 gnd 1.46fF
C2606 divider_0/tspc_0/Z1 gnd 0.99fF
C2607 divider_0/nor_1/B gnd 6.33fF
C2608 divider_0/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2609 divider_0/tspc_1/Q gnd 3.12fF
C2610 divider_0/clk gnd 5.63fF
C2611 divider_0/prescaler_0/nand_1/z1 gnd 0.36fF
C2612 divider_0/prescaler_0/tspc_0/D gnd 2.64fF
C2613 divider_0/prescaler_0/tspc_2/Q gnd 3.64fF
C2614 divider_0/prescaler_0/tspc_1/Q gnd 3.61fF
C2615 divider_0/prescaler_0/nand_0/z1 gnd 0.36fF
C2616 divider_0/prescaler_0/tspc_2/D gnd 3.12fF
C2617 divider_0/and_0/OUT gnd 5.62fF
C2618 divider_0/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2619 divider_0/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2620 divider_0/prescaler_0/tspc_2/Z2 gnd 1.46fF
C2621 divider_0/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2622 divider_0/prescaler_0/tspc_2/a_630_n680# gnd 1.14fF **FLOATING
C2623 divider_0/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2624 divider_0/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2625 divider_0/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2626 divider_0/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2627 divider_0/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2628 divider_0/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2629 divider_0/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2630 divider_0/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2631 divider_0/prescaler_0/Out gnd 4.59fF
C2632 divider_0/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2633 divider_0/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2634 divider_0/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2635 divider_0/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2636 divider_0/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2637 divider_0/nor_1/Z1 gnd 1.34fF
C2638 divider_0/mc2 gnd 5.29fF
C2639 divider_0/nor_0/Z1 gnd 1.34fF
C2640 divbuf_14/OUT gnd 363.82fF
C2641 divbuf_14/OUT5 gnd 350.37fF
C2642 divbuf_14/OUT4 gnd 133.72fF
C2643 divbuf_14/OUT3 gnd 34.03fF
C2644 divbuf_14/OUT2 gnd 8.71fF
C2645 divbuf_14/IN gnd 0.89fF
C2646 divbuf_14/a_492_n240# gnd 2.46fF **FLOATING
C2647 divbuf_25/OUT gnd 363.82fF
C2648 divbuf_25/OUT5 gnd 350.37fF
C2649 divbuf_25/OUT4 gnd 133.72fF
C2650 divbuf_25/OUT3 gnd 34.03fF
C2651 divbuf_25/OUT2 gnd 8.71fF
C2652 divbuf_25/IN gnd 0.89fF
C2653 divbuf_25/a_492_n240# gnd 2.46fF **FLOATING
C2654 divbuf_9/OUT gnd 363.82fF
C2655 divbuf_9/OUT5 gnd 350.37fF
C2656 divbuf_9/OUT4 gnd 133.72fF
C2657 divbuf_9/OUT3 gnd 34.03fF
C2658 divbuf_9/OUT2 gnd 8.71fF
C2659 divbuf_9/IN gnd 0.89fF
C2660 divbuf_9/a_492_n240# gnd 2.46fF **FLOATING
C2661 divbuf_13/OUT gnd 363.82fF
C2662 divbuf_13/OUT5 gnd 350.37fF
C2663 divbuf_13/OUT4 gnd 133.72fF
C2664 divbuf_13/OUT3 gnd 34.03fF
C2665 divbuf_13/OUT2 gnd 8.71fF
C2666 divbuf_13/IN gnd 0.89fF
C2667 divbuf_13/a_492_n240# gnd 2.46fF **FLOATING
C2668 divbuf_24/OUT gnd 363.82fF
C2669 divbuf_24/OUT5 gnd 350.37fF
C2670 divbuf_24/OUT4 gnd 133.72fF
C2671 divbuf_24/OUT3 gnd 34.03fF
C2672 divbuf_24/OUT2 gnd 8.71fF
C2673 divbuf_24/IN gnd 0.89fF
C2674 divbuf_24/a_492_n240# gnd 2.46fF **FLOATING
C2675 divbuf_12/OUT gnd 363.82fF
C2676 divbuf_12/OUT5 gnd 350.37fF
C2677 divbuf_12/OUT4 gnd 133.72fF
C2678 divbuf_12/OUT3 gnd 34.03fF
C2679 divbuf_12/OUT2 gnd 8.71fF
C2680 divbuf_12/IN gnd 0.89fF
C2681 divbuf_12/a_492_n240# gnd 2.46fF **FLOATING
C2682 divbuf_8/OUT gnd 363.82fF
C2683 divbuf_8/OUT5 gnd 350.37fF
C2684 divbuf_8/OUT4 gnd 133.72fF
C2685 divbuf_8/OUT3 gnd 34.03fF
C2686 divbuf_8/OUT2 gnd 8.71fF
C2687 divbuf_8/IN gnd 0.89fF
C2688 divbuf_8/a_492_n240# gnd 2.46fF **FLOATING
C2689 divbuf_23/OUT gnd 363.82fF
C2690 divbuf_23/OUT5 gnd 350.37fF
C2691 divbuf_23/OUT4 gnd 133.72fF
C2692 divbuf_23/OUT3 gnd 34.03fF
C2693 divbuf_23/OUT2 gnd 8.71fF
C2694 divbuf_23/IN gnd 0.89fF
C2695 divbuf_23/a_492_n240# gnd 2.46fF **FLOATING
C2696 divbuf_7/OUT gnd 363.82fF
C2697 divbuf_7/OUT5 gnd 350.37fF
C2698 divbuf_7/OUT4 gnd 133.72fF
C2699 divbuf_7/OUT3 gnd 34.03fF
C2700 divbuf_7/OUT2 gnd 8.71fF
C2701 divbuf_7/IN gnd 0.89fF
C2702 divbuf_7/a_492_n240# gnd 2.46fF **FLOATING
C2703 divbuf_11/OUT gnd 363.82fF
C2704 divbuf_11/OUT5 gnd 350.37fF
C2705 divbuf_11/OUT4 gnd 133.72fF
C2706 divbuf_11/OUT3 gnd 34.03fF
C2707 divbuf_11/OUT2 gnd 8.71fF
C2708 divbuf_11/IN gnd 0.89fF
C2709 divbuf_11/a_492_n240# gnd 2.46fF **FLOATING
C2710 divbuf_22/OUT gnd 363.82fF
C2711 divbuf_22/OUT5 gnd 350.37fF
C2712 divbuf_22/OUT4 gnd 133.72fF
C2713 divbuf_22/OUT3 gnd 34.03fF
C2714 divbuf_22/OUT2 gnd 8.71fF
C2715 divbuf_22/IN gnd 0.89fF
C2716 divbuf_22/a_492_n240# gnd 2.46fF **FLOATING
C2717 divbuf_6/OUT gnd 363.82fF
C2718 divbuf_6/OUT5 gnd 350.37fF
C2719 divbuf_6/OUT4 gnd 133.72fF
C2720 divbuf_6/OUT3 gnd 34.03fF
C2721 divbuf_6/OUT2 gnd 8.71fF
C2722 divbuf_6/IN gnd 0.89fF
C2723 divbuf_6/a_492_n240# gnd 2.46fF **FLOATING
C2724 divbuf_10/OUT gnd 363.82fF
C2725 divbuf_10/OUT5 gnd 350.37fF
C2726 divbuf_10/OUT4 gnd 133.72fF
C2727 divbuf_10/OUT3 gnd 34.03fF
C2728 divbuf_10/OUT2 gnd 8.71fF
C2729 divbuf_10/IN gnd 0.89fF
C2730 divbuf_10/a_492_n240# gnd 2.46fF **FLOATING
C2731 divbuf_20/OUT gnd 363.82fF
C2732 divbuf_20/OUT5 gnd 350.37fF
C2733 divbuf_20/OUT4 gnd 133.72fF
C2734 divbuf_20/OUT3 gnd 34.03fF
C2735 divbuf_20/OUT2 gnd 8.71fF
C2736 divbuf_20/IN gnd 0.89fF
C2737 divbuf_20/a_492_n240# gnd 2.46fF **FLOATING
C2738 divbuf_21/OUT gnd 363.82fF
C2739 divbuf_21/OUT5 gnd 350.37fF
C2740 divbuf_21/OUT4 gnd 133.72fF
C2741 divbuf_21/OUT3 gnd 34.03fF
C2742 divbuf_21/OUT2 gnd 8.71fF
C2743 divbuf_21/IN gnd 0.89fF
C2744 divbuf_21/a_492_n240# gnd 2.46fF **FLOATING
C2745 divbuf_5/OUT gnd 363.82fF
C2746 divbuf_5/OUT5 gnd 350.37fF
C2747 divbuf_5/OUT4 gnd 133.72fF
C2748 divbuf_5/OUT3 gnd 34.03fF
C2749 divbuf_5/OUT2 gnd 8.71fF
C2750 divbuf_5/IN gnd 0.89fF
C2751 divbuf_5/a_492_n240# gnd 2.46fF **FLOATING
C2752 divbuf_4/OUT gnd 363.82fF
C2753 divbuf_4/OUT5 gnd 350.37fF
C2754 divbuf_4/OUT4 gnd 133.72fF
C2755 divbuf_4/OUT3 gnd 34.03fF
C2756 divbuf_4/OUT2 gnd 8.71fF
C2757 divbuf_4/IN gnd 0.89fF
C2758 divbuf_4/a_492_n240# gnd 2.46fF **FLOATING
C2759 divbuf_3/OUT gnd 363.82fF
C2760 divbuf_3/OUT5 gnd 350.37fF
C2761 divbuf_3/OUT4 gnd 133.72fF
C2762 divbuf_3/OUT3 gnd 34.03fF
C2763 divbuf_3/OUT2 gnd 8.71fF
C2764 divbuf_3/IN gnd 0.89fF
C2765 divbuf_3/a_492_n240# gnd 2.46fF **FLOATING
C2766 divbuf_2/OUT gnd 363.82fF
C2767 divbuf_2/OUT5 gnd 350.37fF
C2768 divbuf_2/OUT4 gnd 133.72fF
C2769 divbuf_2/OUT3 gnd 34.03fF
C2770 divbuf_2/OUT2 gnd 8.71fF
C2771 divbuf_2/IN gnd 0.89fF
C2772 divbuf_2/a_492_n240# gnd 2.46fF **FLOATING
C2773 divbuf_1/OUT gnd 363.82fF
C2774 divbuf_1/OUT5 gnd 350.37fF
C2775 divbuf_1/OUT4 gnd 133.72fF
C2776 divbuf_1/OUT3 gnd 34.03fF
C2777 divbuf_1/OUT2 gnd 8.71fF
C2778 divbuf_1/IN gnd 0.89fF
C2779 divbuf_1/a_492_n240# gnd 2.46fF **FLOATING
C2780 divbuf_0/OUT gnd 363.82fF
C2781 divbuf_0/OUT5 gnd 350.37fF
C2782 divbuf_0/OUT4 gnd 133.72fF
C2783 divbuf_0/OUT3 gnd 34.03fF
C2784 divbuf_0/OUT2 gnd 8.71fF
C2785 divbuf_0/IN gnd 0.89fF
C2786 divbuf_0/a_492_n240# gnd 2.46fF **FLOATING
C2787 ro_complete_1/cbank_2/v gnd 16.43fF
C2788 ro_complete_1/cbank_2/switch_5/vin gnd 0.78fF
C2789 ro_complete_1/cbank_2/switch_4/vin gnd 1.50fF
C2790 ro_complete_1/cbank_2/switch_2/vin gnd 1.30fF
C2791 ro_complete_1/cbank_2/switch_3/vin gnd 0.56fF
C2792 ro_complete_1/cbank_2/switch_1/vin gnd 1.14fF
C2793 ro_complete_1/cbank_2/switch_0/vin gnd 1.02fF
C2794 ro_complete_1/cbank_1/v gnd 16.43fF
C2795 ro_complete_1/cbank_1/switch_5/vin gnd 0.78fF
C2796 ro_complete_1/a0 gnd 5.35fF
C2797 ro_complete_1/cbank_1/switch_4/vin gnd 1.50fF
C2798 ro_complete_1/a1 gnd 6.54fF
C2799 ro_complete_1/cbank_1/switch_2/vin gnd 1.30fF
C2800 ro_complete_1/a3 gnd 5.96fF
C2801 ro_complete_1/cbank_1/switch_3/vin gnd 0.56fF
C2802 ro_complete_1/a2 gnd 5.21fF
C2803 ro_complete_1/cbank_1/switch_1/vin gnd 1.14fF
C2804 ro_complete_1/a4 gnd 5.81fF
C2805 ro_complete_1/cbank_1/switch_0/vin gnd 1.02fF
C2806 ro_complete_1/a5 gnd 6.74fF
C2807 ro_complete_1/cbank_0/v gnd 15.12fF
C2808 ro_complete_1/cbank_0/switch_5/vin gnd 0.78fF
C2809 ro_complete_1/cbank_0/switch_4/vin gnd 1.50fF
C2810 ro_complete_1/cbank_0/switch_2/vin gnd 1.30fF
C2811 ro_complete_1/cbank_0/switch_3/vin gnd 0.56fF
C2812 ro_complete_1/cbank_0/switch_1/vin gnd 1.14fF
C2813 ro_complete_1/cbank_0/switch_0/vin gnd 1.02fF
C2814 ro_complete_1/ro_var_extend_0/vcont gnd 0.27fF
C2815 ro_complete_0/cbank_2/v gnd 16.43fF
C2816 ro_complete_0/cbank_2/switch_5/vin gnd 0.78fF
C2817 ro_complete_0/cbank_2/switch_4/vin gnd 1.50fF
C2818 ro_complete_0/cbank_2/switch_2/vin gnd 1.30fF
C2819 ro_complete_0/cbank_2/switch_3/vin gnd 0.56fF
C2820 ro_complete_0/cbank_2/switch_1/vin gnd 1.14fF
C2821 ro_complete_0/cbank_2/switch_0/vin gnd 1.02fF
C2822 ro_complete_0/cbank_1/v gnd 16.46fF
C2823 ro_complete_0/cbank_1/switch_5/vin gnd 0.78fF
C2824 ro_complete_0/a0 gnd 5.35fF
C2825 ro_complete_0/cbank_1/switch_4/vin gnd 1.50fF
C2826 ro_complete_0/a1 gnd 6.54fF
C2827 ro_complete_0/cbank_1/switch_2/vin gnd 1.30fF
C2828 ro_complete_0/a3 gnd 5.96fF
C2829 ro_complete_0/cbank_1/switch_3/vin gnd 0.56fF
C2830 ro_complete_0/a2 gnd 5.21fF
C2831 ro_complete_0/cbank_1/switch_1/vin gnd 1.14fF
C2832 ro_complete_0/a4 gnd 5.81fF
C2833 ro_complete_0/cbank_1/switch_0/vin gnd 1.02fF
C2834 ro_complete_0/a5 gnd 6.74fF
C2835 ro_complete_0/cbank_0/v gnd 15.12fF
C2836 ro_complete_0/cbank_0/switch_5/vin gnd 0.78fF
C2837 ro_complete_0/cbank_0/switch_4/vin gnd 1.50fF
C2838 ro_complete_0/cbank_0/switch_2/vin gnd 1.30fF
C2839 ro_complete_0/cbank_0/switch_3/vin gnd 0.56fF
C2840 ro_complete_0/cbank_0/switch_1/vin gnd 1.14fF
C2841 ro_complete_0/cbank_0/switch_0/vin gnd 1.02fF
C2842 ro_complete_0/ro_var_extend_0/vcont gnd 0.27fF
C2843 filter_0/v gnd 85.69fF
C2844 filter_0/a_4216_n5230# gnd 418.47fF **FLOATING
C2845 filter_0/a_4216_n2998# gnd 1.03fF **FLOATING
C2846 cp_0/down gnd 1.54fF
C2847 cp_0/vbias gnd 2.41fF
C2848 cp_0/out gnd 5.30fF
C2849 cp_0/upbar gnd 1.50fF
C2850 cp_0/a_7110_n2840# gnd 0.17fF **FLOATING
C2851 cp_0/a_3060_n2840# gnd 1.71fF **FLOATING
C2852 cp_0/a_7110_0# gnd 0.17fF **FLOATING
C2853 cp_0/a_6370_0# gnd 0.40fF **FLOATING
C2854 cp_0/a_3060_0# gnd 1.65fF **FLOATING
C2855 cp_0/a_1710_0# gnd 5.76fF **FLOATING
C2856 cp_0/a_1710_n2840# gnd 4.89fF **FLOATING
C2857 cp_0/a_10_n50# gnd 2.96fF **FLOATING
C2858 pd_1/and_pd_0/Z1 gnd 0.39fF
C2859 pd_1/and_pd_0/Out1 gnd 2.22fF
C2860 pd_1/tspc_r_1/z5 gnd 1.10fF
C2861 pd_1/tspc_r_1/Z4 gnd 1.07fF
C2862 pd_1/tspc_r_1/Qbar gnd 0.88fF
C2863 pd_1/tspc_r_1/Z2 gnd 1.22fF
C2864 pd_1/tspc_r_1/Z1 gnd 0.67fF
C2865 pd_1/UP gnd 2.21fF
C2866 pd_1/tspc_r_1/Qbar1 gnd 1.34fF
C2867 pd_1/tspc_r_1/Z3 gnd 2.12fF
C2868 pd_1/REF gnd 1.80fF
C2869 pd_1/tspc_r_0/z5 gnd 1.10fF
C2870 pd_1/tspc_r_0/Z4 gnd 1.07fF
C2871 pd_1/R gnd 3.05fF
C2872 pd_1/tspc_r_0/Qbar gnd 0.79fF
C2873 pd_1/tspc_r_0/Z2 gnd 1.22fF
C2874 pd_1/tspc_r_0/Z1 gnd 0.67fF
C2875 pd_1/DOWN gnd 3.08fF
C2876 pd_1/tspc_r_0/Qbar1 gnd 1.34fF
C2877 pd_1/tspc_r_0/Z3 gnd 2.12fF
C2878 pd_1/DIV gnd 1.82fF
C2879 pd_0/and_pd_0/Z1 gnd 0.39fF
C2880 pd_0/and_pd_0/Out1 gnd 2.22fF
C2881 pd_0/tspc_r_1/z5 gnd 1.10fF
C2882 pd_0/tspc_r_1/Z4 gnd 1.07fF
C2883 pd_0/tspc_r_1/Qbar gnd 0.88fF
C2884 pd_0/tspc_r_1/Z2 gnd 1.22fF
C2885 pd_0/tspc_r_1/Z1 gnd 0.67fF
C2886 pd_0/UP gnd 2.21fF
C2887 pd_0/tspc_r_1/Qbar1 gnd 1.34fF
C2888 pd_0/tspc_r_1/Z3 gnd 2.12fF
C2889 pd_0/REF gnd 1.80fF
C2890 pd_0/tspc_r_0/z5 gnd 1.10fF
C2891 pd_0/tspc_r_0/Z4 gnd 1.07fF
C2892 pd_0/R gnd 3.05fF
C2893 pd_0/tspc_r_0/Qbar gnd 0.79fF
C2894 pd_0/tspc_r_0/Z2 gnd 1.22fF
C2895 pd_0/tspc_r_0/Z1 gnd 0.67fF
C2896 pd_0/DOWN gnd 3.08fF
C2897 pd_0/tspc_r_0/Qbar1 gnd 1.34fF
C2898 pd_0/tspc_r_0/Z3 gnd 2.12fF
C2899 pd_0/DIV gnd 1.82fF
.ends
