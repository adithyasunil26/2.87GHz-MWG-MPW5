* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[5] io_analog[6] io_analog[7]
+ io_analog[8] io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
C0 divbuf_16/OUT2 divbuf_16/OUT 0.06fF
C1 divider_0/and_0/OUT divider_0/and_0/Z1 0.04fF
C2 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z2 0.01fF
C3 divider_0/prescaler_0/tspc_2/Q divider_0/clk 0.05fF
C4 divbuf_3/a_492_n240# divbuf_3/OUT 0.00fF
C5 divbuf_21/OUT4 divbuf_21/OUT5 20.26fF
C6 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_1/B 0.00fF
C7 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C8 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C9 divider_1/nor_0/B divider_1/tspc_1/Z4 0.21fF
C10 divider_1/tspc_0/Z2 divider_1/tspc_0/a_630_n680# 0.01fF
C11 divbuf_19/OUT5 divbuf_19/OUT3 0.01fF
C12 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Q 0.15fF
C13 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/B 0.18fF
C14 pd_1/DOWN pd_1/and_pd_0/Z1 0.07fF
C15 pd_1/R pd_1/tspc_r_1/Qbar1 0.30fF
C16 divider_2/prescaler_0/tspc_2/Z3 divider_2/clk 0.45fF
C17 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C18 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C19 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/and_0/OUT 0.06fF
C20 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/tspc_r_1/Z4 0.14fF
C21 divider_0/tspc_1/a_630_n680# divider_0/nor_1/B 0.00fF
C22 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/nand_0/z1 0.07fF
C23 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/D 0.05fF
C24 ro_complete_1/a3 ro_complete_1/cbank_2/switch_1/vin 0.13fF
C25 pll_full_0/divbuf_0/OUT2 pll_full_0/divbuf_0/a_492_n240# 0.42fF
C26 divider_1/tspc_0/Z1 divider_1/nor_1/B 0.03fF
C27 divider_0/and_0/out1 divider_0/and_0/B 0.18fF
C28 pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C29 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C30 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C31 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/clk 0.01fF
C32 divider_2/nor_0/B divider_2/tspc_1/Z3 0.38fF
C33 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/Out 0.21fF
C34 divbuf_23/OUT3 divbuf_23/OUT5 0.01fF
C35 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Z4 0.65fF
C36 divider_2/nor_0/Z1 divider_2/and_0/A 0.80fF
C37 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C38 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_5/vin 0.20fF
C39 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C40 divider_0/nor_0/B divider_0/tspc_2/a_630_n680# 0.01fF
C41 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Q 0.05fF
C42 divider_0/prescaler_0/m1_2700_2190# divider_0/clk 0.01fF
C43 ro_complete_1/a5 ro_complete_1/cbank_2/v 0.08fF
C44 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/IN 0.00fF
C45 divider_1/tspc_1/Z1 divider_1/tspc_1/Z3 0.06fF
C46 divbuf_5/OUT4 divbuf_5/OUT 1.11fF
C47 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z3 0.06fF
C48 divbuf_22/a_492_n240# divbuf_22/OUT5 0.01fF
C49 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z3 0.25fF
C50 pd_0/tspc_r_1/Z2 pd_0/tspc_r_1/Z4 0.14fF
C51 divider_2/mc2 divider_2/nor_0/A 0.04fF
C52 divider_2/tspc_2/Q divider_2/tspc_1/Z4 0.15fF
C53 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z4 0.00fF
C54 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Q 0.21fF
C55 pll_full_1/divbuf_1/a_492_n240# pll_full_1/divbuf_1/OUT 0.00fF
C56 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C57 filter_0/a_4216_n2998# filter_0/v 0.36fF
C58 pll_full_1/pd_0/tspc_r_0/Z1 pll_full_1/pd_0/DIV 0.17fF
C59 pll_full_0/pd_0/DOWN pll_full_0/pd_0/REF 1.48fF
C60 divbuf_19/OUT2 divbuf_19/OUT3 1.37fF
C61 divider_2/and_0/B divider_2/and_0/Z1 0.07fF
C62 divbuf_25/OUT2 divbuf_25/OUT5 0.02fF
C63 divbuf_25/OUT3 divbuf_25/OUT4 5.16fF
C64 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_0/Z4 0.65fF
C65 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C66 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C67 divbuf_1/OUT2 divbuf_1/OUT 0.06fF
C68 divbuf_1/OUT3 divbuf_1/OUT5 0.01fF
C69 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_0/vin 0.19fF
C70 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/v 1.30fF
C71 divider_0/tspc_1/Z1 divider_0/tspc_1/Z3 0.06fF
C72 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z4 0.01fF
C73 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.19fF
C74 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/clk 0.01fF
C75 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/DIV 0.04fF
C76 pll_full_0/pd_0/DIV pll_full_0/divider_0/and_0/OUT 0.01fF
C77 ro_complete_1/a0 ro_complete_1/cbank_2/switch_5/vin 0.09fF
C78 io_clamp_low[1] io_clamp_high[1] 0.53fF
C79 divbuf_18/OUT2 divbuf_18/OUT3 1.37fF
C80 divider_1/tspc_0/Z2 divider_1/nor_0/B 0.20fF
C81 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/clk 0.14fF
C82 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C83 divbuf_11/OUT3 divbuf_11/OUT 0.26fF
C84 divbuf_11/OUT4 divbuf_11/OUT5 20.26fF
C85 divider_2/nor_0/B divider_2/and_0/B 0.31fF
C86 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z3 0.11fF
C87 divider_1/and_0/out1 divider_1/and_0/A 0.01fF
C88 pd_1/tspc_r_0/Qbar1 pd_1/R 0.01fF
C89 divider_2/tspc_2/Q divider_2/tspc_2/Z3 0.05fF
C90 divider_2/nor_1/B divider_2/tspc_0/Z2 0.40fF
C91 divider_2/prescaler_0/tspc_1/Z4 divider_2/clk 0.12fF
C92 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C93 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C94 pll_full_0/cp_0/a_1710_0# pll_full_0/cp_0/down 0.32fF
C95 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C96 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/UP 0.11fF
C97 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z1 0.17fF
C98 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/nor_0/B 0.03fF
C99 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_1/a_630_n680# 0.05fF
C100 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/nor_1/B 0.35fF
C101 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C102 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C103 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_0/Qbar1 0.20fF
C104 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT4 5.16fF
C105 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C106 divbuf_15/OUT divbuf_15/a_492_n240# 0.00fF
C107 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Q 0.15fF
C108 divider_0/prescaler_0/tspc_0/Z2 divider_0/and_0/OUT 0.06fF
C109 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z2 0.23fF
C110 pll_full_1/divider_0/prescaler_0/tspc_0/D pll_full_1/divider_0/clk 0.29fF
C111 divbuf_19/OUT5 divbuf_19/IN 0.00fF
C112 divider_1/prescaler_0/tspc_0/Z3 divider_1/clk 0.64fF
C113 divbuf_10/a_492_n240# divbuf_10/OUT 0.00fF
C114 pll_full_1/pd_0/DOWN pll_full_1/pd_0/UP 4.58fF
C115 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C116 pd_1/DIV pd_1/tspc_r_0/Z2 0.19fF
C117 pd_0/DOWN pd_0/R 0.36fF
C118 pd_0/tspc_r_0/Z1 pd_0/tspc_r_0/Z2 0.71fF
C119 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z4 0.20fF
C120 pd_0/DIV pd_0/tspc_r_0/z5 0.04fF
C121 divbuf_13/OUT2 divbuf_13/OUT 0.06fF
C122 divbuf_13/OUT3 divbuf_13/OUT5 0.01fF
C123 pd_1/R pd_1/and_pd_0/Z1 0.02fF
C124 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/z5 0.20fF
C125 divider_2/tspc_2/a_630_n680# divider_2/nor_0/A 0.35fF
C126 divider_2/prescaler_0/tspc_1/Q divider_2/clk 0.60fF
C127 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_4/vin 0.20fF
C128 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/nor_1/B 0.47fF
C129 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/and_0/OUT 0.06fF
C130 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C131 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.38fF
C132 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.11fF
C133 divbuf_20/OUT divbuf_20/OUT2 0.06fF
C134 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C135 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/clk 0.01fF
C136 divbuf_5/a_492_n240# divbuf_5/IN 0.13fF
C137 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/Z4 0.65fF
C138 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C139 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C140 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z3 0.33fF
C141 divider_1/prescaler_0/tspc_1/Q divider_1/nor_0/A 0.03fF
C142 divbuf_6/OUT4 divbuf_6/OUT 1.11fF
C143 pll_full_1/divbuf_1/OUT2 pll_full_1/divbuf_1/OUT5 0.02fF
C144 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C145 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/clk 0.01fF
C146 divbuf_8/a_492_n240# divbuf_8/OUT5 0.01fF
C147 pd_0/tspc_r_0/Z4 pd_0/tspc_r_1/Z4 0.02fF
C148 pd_0/DOWN pd_0/and_pd_0/Out1 0.12fF
C149 pd_0/tspc_r_1/Qbar1 pd_0/UP 0.11fF
C150 pd_0/REF pd_0/tspc_r_1/Z1 0.17fF
C151 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C152 divider_2/tspc_1/Z3 divider_2/tspc_1/a_630_n680# 0.05fF
C153 divider_2/nor_1/B divider_2/tspc_0/Z1 0.03fF
C154 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_2/D 0.16fF
C155 divider_2/prescaler_0/Out divider_2/clk 0.51fF
C156 divbuf_21/OUT ro_complete_0/cbank_1/v 0.05fF
C157 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z4 0.12fF
C158 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z2 1.07fF
C159 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/Z1 0.01fF
C160 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C161 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/nor_0/A 1.21fF
C162 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/and_pd_0/Z1 0.02fF
C163 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C164 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C165 divbuf_17/OUT3 divbuf_17/OUT 0.26fF
C166 divbuf_17/OUT5 divbuf_17/OUT2 0.02fF
C167 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_2/Q 0.19fF
C168 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/clk 0.01fF
C169 divider_1/tspc_1/Z1 divider_1/nor_0/B 0.03fF
C170 divider_1/tspc_1/Z3 divider_1/tspc_1/a_630_n680# 0.05fF
C171 divider_1/nor_1/B divider_1/tspc_0/Z2 0.40fF
C172 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z4 0.08fF
C173 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z3 0.05fF
C174 divider_1/mc2 divider_1/and_0/B 0.20fF
C175 divbuf_20/OUT2 divbuf_20/OUT3 1.37fF
C176 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/nor_0/B 0.03fF
C177 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/a_630_n680# 0.05fF
C178 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/nor_1/B 0.35fF
C179 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C180 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C181 pll_full_1/pd_0/UP pll_full_1/pd_0/tspc_r_1/z5 0.03fF
C182 pll_full_1/pd_0/R pll_full_1/pd_0/tspc_r_1/Qbar1 0.30fF
C183 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z2 0.23fF
C184 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/clk 0.29fF
C185 divbuf_12/OUT3 divbuf_12/OUT 0.26fF
C186 divbuf_12/OUT4 divbuf_12/OUT5 20.26fF
C187 pd_1/DOWN pd_1/R 0.36fF
C188 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z3 0.29fF
C189 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/divider_0/clk 1.46fF
C190 divbuf_0/OUT2 divbuf_0/OUT5 0.02fF
C191 divider_0/tspc_1/Z1 divider_0/nor_0/B 0.03fF
C192 divider_0/tspc_1/Z3 divider_0/tspc_1/a_630_n680# 0.05fF
C193 divider_0/tspc_0/a_630_n680# divider_0/nor_1/B 0.35fF
C194 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z4 0.08fF
C195 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z3 0.05fF
C196 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/out1 0.31fF
C197 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/and_0/B 0.29fF
C198 divbuf_3/IN divbuf_3/OUT5 0.00fF
C199 ro_complete_1/cbank_1/v ro_complete_1/cbank_2/v 1.36fF
C200 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/Z4 0.20fF
C201 divbuf_17/OUT4 divbuf_17/OUT 1.11fF
C202 divider_1/prescaler_0/tspc_2/Z2 divider_1/clk 0.11fF
C203 divider_0/nor_0/A divider_0/tspc_2/Z2 0.23fF
C204 divider_0/prescaler_0/tspc_0/D divider_0/clk 0.29fF
C205 divider_1/prescaler_0/Out divider_1/tspc_2/a_630_n680# 0.01fF
C206 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_1/B 0.47fF
C207 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C208 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C209 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C210 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C211 divbuf_7/a_492_n240# divbuf_7/OUT 0.00fF
C212 divider_2/tspc_0/Z1 divider_2/tspc_0/Z2 1.07fF
C213 divider_2/prescaler_0/tspc_2/Z4 divider_2/clk 0.12fF
C214 divbuf_18/OUT divbuf_18/a_492_n240# 0.00fF
C215 divbuf_0/OUT2 divbuf_0/OUT3 1.37fF
C216 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/nor_0/B 0.35fF
C217 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/Z4 0.36fF
C218 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/nor_1/B 0.22fF
C219 divbuf_1/IN divbuf_1/OUT5 0.00fF
C220 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C221 divider_0/mc2 divider_0/and_0/out1 0.06fF
C222 divider_0/nor_0/B divider_0/nor_1/B 0.47fF
C223 divider_0/prescaler_0/tspc_1/Z2 divider_0/and_0/OUT 0.06fF
C224 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z3 0.33fF
C225 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Q 0.38fF
C226 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_0/D 0.11fF
C227 divider_0/nor_0/Z1 divider_0/and_0/A 0.80fF
C228 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/and_0/B 0.08fF
C229 divbuf_4/IN divbuf_4/OUT5 0.00fF
C230 divider_2/nor_0/B divider_2/tspc_1/Q 0.51fF
C231 divider_1/prescaler_0/tspc_1/Z3 divider_1/clk 0.45fF
C232 divbuf_6/a_492_n240# divbuf_6/IN 0.13fF
C233 pll_full_1/divbuf_0/OUT3 pll_full_1/divbuf_0/OUT2 1.37fF
C234 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/R 0.21fF
C235 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z1 0.01fF
C236 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C237 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_0/A 1.21fF
C238 pd_0/R pd_0/tspc_r_1/Z3 0.29fF
C239 divbuf_9/a_492_n240# divbuf_9/OUT5 0.01fF
C240 cp_0/a_10_n50# cp_0/vbias 0.19fF
C241 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_0/Z4 0.04fF
C242 divider_0/Out divider_0/tspc_0/a_630_n680# 0.04fF
C243 divbuf_23/OUT ro_complete_0/cbank_1/switch_0/vin 0.09fF
C244 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/v 1.30fF
C245 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/and_0/OUT 0.05fF
C246 divbuf_21/OUT divbuf_21/a_492_n240# 0.00fF
C247 ro_complete_1/a1 ro_complete_1/cbank_1/v 0.05fF
C248 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/a_630_n680# 0.01fF
C249 divider_0/tspc_1/Q divider_0/tspc_0/Z1 0.01fF
C250 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/clk 0.01fF
C251 divider_0/nor_0/B divider_0/nor_0/A 1.21fF
C252 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/divider_0/clk 1.46fF
C253 divbuf_17/OUT5 divbuf_17/IN 0.00fF
C254 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Q 0.15fF
C255 divider_1/nor_0/A divider_1/tspc_2/Z1 0.03fF
C256 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z3 0.05fF
C257 divbuf_22/OUT2 divbuf_22/OUT3 1.37fF
C258 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/out1 0.31fF
C259 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/B 0.29fF
C260 pd_1/tspc_r_0/Qbar pd_1/tspc_r_0/Qbar1 0.01fF
C261 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Z4 0.65fF
C262 divider_2/prescaler_0/tspc_0/Z3 divider_2/clk 0.64fF
C263 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/OUT2 0.02fF
C264 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C265 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C266 divbuf_18/OUT divbuf_18/OUT5 43.38fF
C267 divbuf_25/OUT3 divbuf_25/OUT 0.26fF
C268 divbuf_25/OUT4 divbuf_25/OUT5 20.26fF
C269 filter_0/a_4216_n5230# filter_0/v 0.91fF
C270 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C271 divbuf_19/OUT ro_complete_0/cbank_1/v 0.05fF
C272 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/tspc_0/D 0.32fF
C273 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C274 ro_complete_1/a0 ro_complete_1/cbank_2/v 0.05fF
C275 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/D 0.03fF
C276 divider_0/and_0/OUT divider_0/and_0/out1 0.31fF
C277 divider_0/nor_1/B divider_0/and_0/B 0.29fF
C278 divbuf_21/a_492_n240# divbuf_21/OUT2 0.42fF
C279 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_0/B 0.35fF
C280 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z4 0.36fF
C281 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_1/B 0.22fF
C282 divider_1/tspc_1/a_630_n680# divider_1/nor_0/B 0.35fF
C283 divider_1/tspc_0/Z1 divider_1/tspc_0/Z4 0.00fF
C284 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_1/Q 0.13fF
C285 divider_1/prescaler_0/m1_2700_2190# divider_1/and_0/OUT 0.14fF
C286 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z4 0.28fF
C287 divbuf_11/OUT5 divbuf_11/OUT 43.38fF
C288 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/B 0.08fF
C289 pd_1/tspc_r_1/Z1 pd_1/tspc_r_1/Z3 0.09fF
C290 pd_1/tspc_r_1/Z2 pd_1/REF 0.19fF
C291 pd_1/tspc_r_0/Z3 pd_1/tspc_r_0/z5 0.11fF
C292 divbuf_24/a_492_n240# divbuf_24/OUT 0.00fF
C293 divbuf_20/OUT ro_complete_0/cbank_1/switch_3/vin 0.09fF
C294 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/nor_0/B 0.38fF
C295 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_1/a_630_n680# 0.04fF
C296 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C297 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C298 pll_full_1/ro_complete_0/cbank_1/switch_4/vin pll_full_1/divider_0/clk 1.46fF
C299 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/tspc_r_1/z5 0.02fF
C300 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z2 0.25fF
C301 divider_0/tspc_1/a_630_n680# divider_0/nor_0/B 0.35fF
C302 divider_0/tspc_1/Z2 divider_0/tspc_1/Z4 0.36fF
C303 divider_0/tspc_1/Q divider_0/nor_1/B 0.22fF
C304 divbuf_2/IN divbuf_2/OUT5 0.00fF
C305 ro_complete_1/a4 ro_complete_1/cbank_2/switch_0/vin 0.12fF
C306 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z3 0.06fF
C307 divbuf_16/OUT4 divbuf_16/OUT5 20.26fF
C308 divider_0/nor_0/A divider_0/and_0/B 0.08fF
C309 divbuf_10/IN divbuf_10/OUT5 0.00fF
C310 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/a4 0.12fF
C311 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/and_0/OUT 0.05fF
C312 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/D 0.03fF
C313 divider_1/prescaler_0/tspc_0/Z4 divider_1/clk 0.12fF
C314 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/z5 0.20fF
C315 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z3 0.65fF
C316 divider_2/tspc_0/Z4 divider_2/nor_1/B 0.22fF
C317 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Q 0.91fF
C318 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z3 0.33fF
C319 divbuf_23/a_492_n240# divbuf_23/IN 0.13fF
C320 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C321 cp_0/a_1710_n2840# cp_0/out 0.61fF
C322 divider_2/and_0/OUT divider_2/and_0/Z1 0.04fF
C323 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z2 0.01fF
C324 divider_2/prescaler_0/tspc_2/Q divider_2/clk 0.05fF
C325 divbuf_13/OUT4 divbuf_13/OUT 1.11fF
C326 divbuf_21/OUT divbuf_22/OUT 2.71fF
C327 divbuf_16/OUT2 divbuf_16/OUT3 1.37fF
C328 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C329 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C330 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.04fF
C331 divider_1/tspc_2/Q divider_1/tspc_1/Z2 0.14fF
C332 divider_0/prescaler_0/tspc_2/Z2 divider_0/and_0/OUT 0.05fF
C333 divbuf_20/OUT divbuf_20/OUT4 1.11fF
C334 divbuf_2/OUT5 divbuf_2/a_492_n240# 0.01fF
C335 ro_complete_1/a3 ro_complete_1/cbank_2/switch_2/vin 0.09fF
C336 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Z2 0.19fF
C337 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C338 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C339 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/and_pd_0/Out1 0.05fF
C340 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C341 divider_1/tspc_0/Z1 divider_1/tspc_1/Q 0.01fF
C342 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z3 0.16fF
C343 pll_full_1/divbuf_1/OUT3 pll_full_1/divbuf_1/OUT 0.26fF
C344 pll_full_1/divbuf_1/OUT4 pll_full_1/divbuf_1/OUT5 20.26fF
C345 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C346 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C347 pd_1/DIV pd_1/tspc_r_0/z5 0.04fF
C348 pd_1/tspc_r_0/Qbar pd_1/DOWN 0.21fF
C349 pd_0/tspc_r_0/z5 pd_0/tspc_r_1/z5 0.02fF
C350 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z2 0.25fF
C351 divider_2/tspc_1/Q divider_2/tspc_1/a_630_n680# 0.04fF
C352 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/nand_0/z1 0.07fF
C353 divbuf_8/OUT2 divbuf_8/OUT3 1.37fF
C354 divider_2/and_0/out1 divider_2/and_0/B 0.18fF
C355 divbuf_19/OUT divbuf_18/OUT 2.98fF
C356 divbuf_1/a_492_n240# divbuf_1/IN 0.13fF
C357 divbuf_22/OUT ro_complete_0/cbank_2/switch_2/vin 0.09fF
C358 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z3 0.16fF
C359 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/tspc_0/Z1 0.00fF
C360 divider_2/nor_1/Z1 divider_2/nor_0/B 0.18fF
C361 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_0/D 0.32fF
C362 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/clk 0.01fF
C363 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/v 1.30fF
C364 divbuf_20/OUT2 divbuf_20/OUT5 0.02fF
C365 divbuf_20/OUT3 divbuf_20/OUT4 5.16fF
C366 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/nor_0/B 0.38fF
C367 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.04fF
C368 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C369 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C370 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/divider_0/clk 1.46fF
C371 divider_1/nor_1/B divider_1/tspc_1/a_630_n680# 0.00fF
C372 divider_1/tspc_1/Z3 divider_1/nor_0/B 0.38fF
C373 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z4 0.12fF
C374 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z2 1.07fF
C375 divbuf_11/a_492_n240# divbuf_11/OUT2 0.42fF
C376 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT2 0.06fF
C377 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z3 0.06fF
C378 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/Z3 0.06fF
C379 divider_1/nor_0/A divider_1/and_0/A 0.01fF
C380 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Qbar1 0.38fF
C381 divider_2/tspc_0/Z4 divider_2/tspc_0/Z2 0.36fF
C382 divider_2/Out divider_2/tspc_0/Z3 0.05fF
C383 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Q 0.05fF
C384 divider_2/prescaler_0/m1_2700_2190# divider_2/clk 0.01fF
C385 divider_2/mc2 divider_2/and_0/B 0.20fF
C386 divbuf_12/OUT5 divbuf_12/OUT 43.38fF
C387 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C388 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/switch_0/vin 0.19fF
C389 pll_full_0/pd_0/R pll_full_0/pd_0/UP 0.46fF
C390 divbuf_14/a_492_n240# divbuf_14/OUT 0.00fF
C391 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_1/Q 0.05fF
C392 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C393 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/nor_1/B 0.06fF
C394 divbuf_0/OUT4 divbuf_0/OUT5 20.26fF
C395 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/v 1.30fF
C396 divider_1/tspc_0/Z3 divider_1/tspc_0/Z1 0.06fF
C397 divider_0/tspc_1/Z3 divider_0/nor_0/B 0.38fF
C398 divider_0/tspc_1/Q divider_0/tspc_1/a_630_n680# 0.04fF
C399 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z4 0.12fF
C400 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z2 1.07fF
C401 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C402 divider_0/tspc_2/Z1 divider_0/tspc_2/Z3 0.06fF
C403 divbuf_3/OUT2 divbuf_3/OUT 0.06fF
C404 divbuf_3/OUT3 divbuf_3/OUT5 0.01fF
C405 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C406 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C407 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C408 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C409 divider_1/prescaler_0/Out divider_1/nor_0/A 0.15fF
C410 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Q 0.21fF
C411 divbuf_7/IN divbuf_7/OUT5 0.00fF
C412 pd_0/DIV pd_0/tspc_r_0/Qbar1 0.12fF
C413 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Out1 0.05fF
C414 divbuf_13/a_492_n240# divbuf_13/IN 0.13fF
C415 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C416 divbuf_0/OUT4 divbuf_0/OUT3 5.16fF
C417 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_4/vin 0.20fF
C418 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/IN 5.26fF
C419 pll_full_0/pd_0/UP pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C420 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/nor_1/B 0.22fF
C421 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z4 0.08fF
C422 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z3 0.05fF
C423 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Q 0.04fF
C424 divider_1/mc2 divider_1/and_0/OUT 0.05fF
C425 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C426 divbuf_4/OUT2 divbuf_4/OUT 0.06fF
C427 divbuf_4/OUT3 divbuf_4/OUT5 0.01fF
C428 pll_full_0/filter_0/a_4216_n5230# pll_full_0/divider_0/clk 1.58fF
C429 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/a3 0.13fF
C430 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z1 0.00fF
C431 divider_2/nor_0/B divider_2/tspc_2/Q 0.22fF
C432 divider_1/tspc_1/Z4 divider_1/nor_0/A 0.02fF
C433 divider_1/tspc_0/Z2 divider_1/tspc_0/Z4 0.36fF
C434 divider_1/prescaler_0/tspc_1/Z4 divider_1/clk 0.12fF
C435 pd_0/R pd_0/UP 0.45fF
C436 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C437 divider_2/tspc_0/Z4 divider_2/tspc_0/Z1 0.00fF
C438 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_1/Q 0.13fF
C439 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/DOWN 0.11fF
C440 divbuf_9/OUT2 divbuf_9/OUT3 1.37fF
C441 pll_full_1/filter_0/a_4216_n5230# pll_full_1/divider_0/clk 1.58fF
C442 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divbuf_0/IN 0.05fF
C443 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT2 0.02fF
C444 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C445 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.20fF
C446 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.09fF
C447 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/clk 0.11fF
C448 divbuf_1/OUT4 divbuf_1/OUT5 20.26fF
C449 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z4 0.36fF
C450 divider_0/tspc_0/Z4 divider_0/tspc_0/Z1 0.00fF
C451 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C452 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/a_740_n680# 0.19fF
C453 divider_2/nor_0/B divider_2/nor_0/Z1 0.06fF
C454 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z1 0.08fF
C455 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Q 0.05fF
C456 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C457 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_1/B 0.06fF
C458 divbuf_22/OUT2 divbuf_22/OUT5 0.02fF
C459 divbuf_22/OUT3 divbuf_22/OUT4 5.16fF
C460 pll_full_1/divbuf_0/OUT3 pll_full_1/divbuf_0/OUT4 5.16fF
C461 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/Z2 0.36fF
C462 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_0/Z3 0.05fF
C463 divider_1/nor_0/A divider_1/tspc_2/Z3 0.38fF
C464 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z4 0.12fF
C465 divider_1/tspc_2/Z1 divider_1/tspc_2/Z2 1.07fF
C466 divbuf_12/a_492_n240# divbuf_12/OUT2 0.42fF
C467 pd_0/UP pd_0/and_pd_0/Out1 0.33fF
C468 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z1 0.09fF
C469 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z2 0.19fF
C470 divbuf_25/OUT5 divbuf_25/OUT 43.38fF
C471 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z2 0.14fF
C472 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_1/Q 0.01fF
C473 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C474 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/Out 0.05fF
C475 pll_full_1/ro_complete_0/a2 pll_full_1/divider_0/clk 0.11fF
C476 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/a_492_n240# 0.42fF
C477 divider_0/tspc_1/Z3 divider_0/tspc_1/Q 0.05fF
C478 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z1 0.08fF
C479 divider_0/mc2 divider_0/nor_1/B 0.15fF
C480 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/and_0/B 0.31fF
C481 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/nand_1/z1 0.22fF
C482 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/prescaler_0/tspc_0/D 0.04fF
C483 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C484 io_clamp_low[0] io_clamp_high[0] 0.53fF
C485 divider_1/nor_1/B divider_1/tspc_0/a_630_n680# 0.35fF
C486 divider_1/tspc_0/Z2 divider_1/tspc_1/Q 0.14fF
C487 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_1/Q 0.21fF
C488 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_2/D 0.16fF
C489 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/nor_1/B 0.22fF
C490 divider_1/and_0/out1 divider_1/and_0/Z1 0.36fF
C491 divbuf_24/IN divbuf_24/OUT5 0.00fF
C492 cp_0/a_1710_0# cp_0/a_10_n50# 0.04fF
C493 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/OUT4 20.26fF
C494 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/R 0.27fF
C495 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_2/Q 0.19fF
C496 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/clk 0.01fF
C497 divider_2/nor_1/B divider_2/and_0/B 0.29fF
C498 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z2 1.07fF
C499 ro_complete_0/cbank_0/switch_0/vin divbuf_21/OUT 0.12fF
C500 divbuf_20/OUT ro_complete_0/cbank_0/switch_3/vin 0.09fF
C501 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Qbar 0.01fF
C502 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/nor_0/B 0.51fF
C503 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C504 pll_full_1/ro_complete_0/cbank_1/switch_0/vin pll_full_1/divider_0/clk 1.58fF
C505 divbuf_2/OUT3 divbuf_2/OUT5 0.01fF
C506 pll_full_0/pd_0/DIV pll_full_0/divider_0/clk 2.26fF
C507 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C508 divider_0/mc2 divider_0/nor_0/A 0.04fF
C509 divider_0/tspc_0/Z4 divider_0/nor_1/B 0.22fF
C510 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z4 0.00fF
C511 divbuf_4/a_492_n240# divbuf_4/OUT2 0.42fF
C512 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/Out 0.21fF
C513 divider_1/nor_1/Z1 divider_1/and_0/B 0.78fF
C514 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divbuf_0/IN 0.05fF
C515 divider_1/and_0/OUT divider_1/prescaler_0/nand_0/z1 0.01fF
C516 divbuf_10/OUT2 divbuf_10/OUT 0.06fF
C517 divbuf_10/OUT3 divbuf_10/OUT5 0.01fF
C518 pll_full_1/pd_0/DOWN pll_full_1/pd_0/R 0.36fF
C519 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C520 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C521 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/clk 0.11fF
C522 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C523 divider_2/tspc_0/a_630_n680# divider_2/nor_1/B 0.35fF
C524 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z4 0.08fF
C525 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z3 0.05fF
C526 divider_2/nor_0/A divider_2/tspc_2/Z2 0.23fF
C527 divider_2/prescaler_0/tspc_0/D divider_2/clk 0.29fF
C528 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a4 0.12fF
C529 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C530 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C531 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C532 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C533 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/cbank_0/v 1.30fF
C534 pll_full_1/cp_0/a_1710_0# pll_full_1/pd_0/DOWN 0.04fF
C535 divider_1/tspc_0/Z3 divider_1/tspc_0/Z2 0.16fF
C536 divbuf_15/OUT divbuf_15/OUT3 0.26fF
C537 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Q 0.20fF
C538 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/D 0.09fF
C539 divider_0/prescaler_0/tspc_0/Z2 divider_0/clk 0.11fF
C540 divbuf_5/a_492_n240# divbuf_5/OUT5 0.01fF
C541 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z4 0.36fF
C542 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/Out 0.05fF
C543 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z2 0.14fF
C544 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_1/Q 0.01fF
C545 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C546 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/Out 0.05fF
C547 pll_full_0/ro_complete_0/a2 pll_full_0/divider_0/clk 0.11fF
C548 divider_1/and_0/OUT divider_1/clk 0.04fF
C549 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/B 0.31fF
C550 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C551 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C552 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/Qbar 0.01fF
C553 divbuf_8/OUT2 divbuf_8/OUT5 0.02fF
C554 divbuf_8/OUT3 divbuf_8/OUT4 5.16fF
C555 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C556 divider_2/tspc_2/Q divider_2/tspc_1/a_630_n680# 0.01fF
C557 divider_2/prescaler_0/tspc_1/Z2 divider_2/and_0/OUT 0.06fF
C558 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z3 0.33fF
C559 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Q 0.38fF
C560 divbuf_25/a_492_n240# divbuf_25/OUT2 0.42fF
C561 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/a2 0.09fF
C562 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C563 pll_full_0/pd_0/DOWN pll_full_0/pd_0/R 0.36fF
C564 divider_0/tspc_2/Q divider_0/tspc_1/Z2 0.14fF
C565 divider_0/tspc_0/a_630_n680# divider_0/tspc_1/Q 0.01fF
C566 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z4 0.36fF
C567 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/Out 0.05fF
C568 divbuf_23/OUT ro_complete_0/cbank_1/v 0.10fF
C569 ro_complete_0/cbank_0/switch_5/vin divbuf_18/OUT 0.09fF
C570 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/clk 0.11fF
C571 divbuf_15/OUT5 divbuf_15/OUT4 20.26fF
C572 divider_0/nor_0/B divider_0/and_0/B 0.31fF
C573 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/nand_1/z1 0.22fF
C574 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/tspc_0/D 0.04fF
C575 divbuf_20/OUT4 divbuf_20/OUT5 20.26fF
C576 divider_1/nor_1/B divider_1/nor_0/B 0.47fF
C577 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z3 0.16fF
C578 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_0/B 0.51fF
C579 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C580 pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_0/divider_0/clk 1.58fF
C581 divider_2/prescaler_0/Out divider_2/prescaler_0/m1_2700_2190# 0.11fF
C582 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/clk 0.01fF
C583 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z4 0.00fF
C584 io_clamp_high[2] io_analog[6] 0.53fF
C585 pll_full_1/ro_complete_0/cbank_0/switch_5/vin pll_full_1/ro_complete_0/a0 0.09fF
C586 divider_2/tspc_0/a_630_n680# divider_2/tspc_0/Z2 0.01fF
C587 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/clk 0.01fF
C588 divbuf_14/IN divbuf_14/OUT5 0.00fF
C589 filter_0/v divbuf_0/OUT2 0.06fF
C590 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C591 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C592 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Out1 0.12fF
C593 divider_0/tspc_1/Q divider_0/nor_0/B 0.51fF
C594 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z3 0.16fF
C595 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/a0 0.13fF
C596 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a4 0.12fF
C597 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C598 divbuf_3/OUT4 divbuf_3/OUT 1.11fF
C599 divbuf_16/a_492_n240# divbuf_16/OUT5 0.01fF
C600 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/clk 0.01fF
C601 divider_0/tspc_2/Z1 divider_0/tspc_2/Z4 0.00fF
C602 divider_1/prescaler_0/Out divider_1/tspc_2/Z2 0.11fF
C603 pll_full_1/pd_0/REF pll_full_1/divbuf_1/OUT5 0.00fF
C604 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C605 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C606 pd_0/tspc_r_0/Z3 pd_0/DOWN 0.03fF
C607 divbuf_7/OUT2 divbuf_7/OUT 0.06fF
C608 divbuf_7/OUT3 divbuf_7/OUT5 0.01fF
C609 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT4 1.11fF
C610 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/tspc_r_1/z5 0.20fF
C611 pd_1/REF pd_1/tspc_r_1/Z3 0.65fF
C612 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/tspc_r_0/Z2 0.71fF
C613 divbuf_18/OUT5 divbuf_18/a_492_n240# 0.01fF
C614 divider_2/and_0/OUT divider_2/and_0/out1 0.31fF
C615 ro_complete_0/cbank_0/switch_1/vin divbuf_22/OUT 0.13fF
C616 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.06fF
C617 pll_full_1/ro_complete_0/cbank_1/switch_5/vin pll_full_1/divider_0/clk 1.46fF
C618 pll_full_0/cp_0/upbar pll_full_0/cp_0/down 0.02fF
C619 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z4 0.12fF
C620 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z2 1.07fF
C621 ro_complete_1/a4 ro_complete_1/cbank_1/v 0.05fF
C622 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C623 divbuf_23/OUT divbuf_23/OUT3 0.26fF
C624 divbuf_4/OUT4 divbuf_4/OUT 1.11fF
C625 pll_full_1/pd_0/REF pll_full_1/pd_0/R 0.61fF
C626 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C627 divbuf_6/a_492_n240# divbuf_6/OUT5 0.01fF
C628 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/clk 0.11fF
C629 divider_2/mc2 divider_2/and_0/OUT 0.05fF
C630 divider_2/prescaler_0/Out divider_2/tspc_2/Z3 0.45fF
C631 divider_2/tspc_1/Z1 divider_2/tspc_1/Z3 0.06fF
C632 divider_2/nor_1/B divider_2/tspc_1/Q 0.22fF
C633 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/D 0.03fF
C634 divbuf_9/OUT2 divbuf_9/OUT5 0.02fF
C635 divbuf_9/OUT3 divbuf_9/OUT4 5.16fF
C636 pll_full_0/pd_0/DOWN pll_full_0/cp_0/a_1710_0# 0.04fF
C637 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/R 0.21fF
C638 divider_2/nor_0/A divider_2/and_0/B 0.08fF
C639 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C640 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/v 1.30fF
C641 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.04fF
C642 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/clk 0.51fF
C643 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT3 0.26fF
C644 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT4 20.26fF
C645 divider_0/prescaler_0/tspc_1/Z2 divider_0/clk 0.11fF
C646 divbuf_21/OUT divbuf_21/OUT2 0.06fF
C647 divbuf_1/OUT5 divbuf_1/OUT 43.38fF
C648 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/UP 0.03fF
C649 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/a0 0.09fF
C650 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Qbar1 0.12fF
C651 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C652 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C653 divbuf_17/OUT divbuf_17/OUT2 0.06fF
C654 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/a_630_n680# 0.19fF
C655 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z3 0.11fF
C656 divbuf_22/OUT4 divbuf_22/OUT5 20.26fF
C657 divider_1/nor_0/A divider_1/tspc_2/Z4 0.21fF
C658 divider_1/tspc_2/Z2 divider_1/tspc_2/Z3 0.16fF
C659 divider_2/prescaler_0/tspc_2/Z2 divider_2/and_0/OUT 0.05fF
C660 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/nor_0/B 0.18fF
C661 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Z4 0.12fF
C662 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C663 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z3 0.11fF
C664 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/v 1.30fF
C665 divbuf_18/OUT ro_complete_0/cbank_2/switch_4/vin 0.13fF
C666 ro_complete_0/cbank_0/v ro_complete_0/cbank_1/v 1.27fF
C667 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/prescaler_0/nand_1/z1 0.01fF
C668 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/clk 0.11fF
C669 pll_full_0/pd_0/DIV pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C670 divbuf_3/a_492_n240# divbuf_3/IN 0.13fF
C671 ro_complete_1/cbank_2/switch_2/vin ro_complete_1/cbank_2/v 1.30fF
C672 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C673 pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_0/divider_0/clk 1.46fF
C674 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Q 0.04fF
C675 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/nand_0/z1 0.07fF
C676 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/D 0.05fF
C677 divider_1/and_0/A divider_1/and_0/B 0.18fF
C678 pd_1/tspc_r_1/Qbar pd_1/UP 0.21fF
C679 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z4 0.20fF
C680 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C681 divider_2/tspc_1/Q divider_2/tspc_0/Z2 0.14fF
C682 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_0/D 0.32fF
C683 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/clk 0.01fF
C684 divbuf_24/OUT2 divbuf_24/OUT 0.06fF
C685 divbuf_24/OUT3 divbuf_24/OUT5 0.01fF
C686 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C687 divbuf_20/OUT ro_complete_0/cbank_2/switch_3/vin 0.09fF
C688 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/pd_0/tspc_r_1/Z2 0.71fF
C689 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z4 0.20fF
C690 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C691 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z3 0.16fF
C692 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/nor_0/B 0.02fF
C693 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z4 0.15fF
C694 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C695 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C696 divbuf_0/a_492_n240# divbuf_0/IN 0.13fF
C697 ro_complete_1/a5 ro_complete_1/cbank_2/switch_0/vin 0.09fF
C698 pll_full_1/divider_0/tspc_2/Z3 pll_full_1/divider_0/tspc_2/Z4 0.65fF
C699 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a3 0.13fF
C700 divider_1/nor_0/Z1 divider_1/and_0/A 0.80fF
C701 divbuf_10/OUT4 divbuf_10/OUT 1.11fF
C702 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/a4 0.09fF
C703 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/a5 0.09fF
C704 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C705 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/clk 0.51fF
C706 divbuf_16/OUT5 divbuf_16/OUT 43.38fF
C707 divider_1/nor_0/B divider_1/tspc_2/a_630_n680# 0.01fF
C708 divider_1/prescaler_0/tspc_2/D divider_1/prescaler_0/nand_0/z1 0.24fF
C709 divider_1/prescaler_0/m1_2700_2190# divider_1/clk 0.01fF
C710 divbuf_23/a_492_n240# divbuf_23/OUT5 0.01fF
C711 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z4 0.12fF
C712 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z2 1.07fF
C713 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C714 pll_full_0/pd_0/tspc_r_0/Qbar pll_full_0/pd_0/DOWN 0.21fF
C715 divider_2/tspc_2/Z1 divider_2/tspc_2/Z3 0.06fF
C716 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_2/Z3 0.05fF
C717 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_0/Z2 0.16fF
C718 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.06fF
C719 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C720 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/clk 0.14fF
C721 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/and_0/B 0.78fF
C722 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Q 0.04fF
C723 divider_0/prescaler_0/Out divider_0/clk 0.51fF
C724 divbuf_2/OUT2 divbuf_2/OUT 0.06fF
C725 divbuf_16/OUT4 divbuf_16/OUT 1.11fF
C726 divbuf_5/OUT2 divbuf_5/OUT3 1.37fF
C727 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/and_pd_0/Out1 0.18fF
C728 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/UP 0.21fF
C729 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_0/B 0.18fF
C730 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z4 0.12fF
C731 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C732 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/clk 0.11fF
C733 divbuf_18/IN divbuf_18/a_492_n240# 0.13fF
C734 divider_1/tspc_0/a_630_n680# divider_1/tspc_0/Z4 0.12fF
C735 divider_1/prescaler_0/tspc_2/D divider_1/clk 0.26fF
C736 divbuf_8/OUT3 divbuf_8/OUT 0.26fF
C737 divbuf_8/OUT4 divbuf_8/OUT5 20.26fF
C738 pd_0/tspc_r_1/Z1 pd_0/tspc_r_1/Z2 0.71fF
C739 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z4 0.20fF
C740 pd_0/REF pd_0/tspc_r_1/z5 0.04fF
C741 divider_2/tspc_1/Q divider_2/tspc_0/Z1 0.01fF
C742 divider_2/tspc_1/Z2 divider_2/tspc_1/Z4 0.36fF
C743 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z4 0.08fF
C744 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z3 0.05fF
C745 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Q 0.04fF
C746 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/a_492_n240# 0.01fF
C747 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/z5 0.20fF
C748 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C749 divbuf_20/OUT ro_complete_0/cbank_2/v 0.05fF
C750 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/Z2 0.25fF
C751 divider_0/mc2 divider_0/nor_0/B 0.06fF
C752 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z4 0.12fF
C753 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/nand_1/z1 0.01fF
C754 divider_0/prescaler_0/tspc_2/Z2 divider_0/clk 0.11fF
C755 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C756 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/Out 0.04fF
C757 divider_2/nor_1/Z1 divider_2/nor_1/B 0.06fF
C758 divider_1/tspc_1/Z3 divider_1/tspc_1/Q 0.05fF
C759 divider_1/prescaler_0/tspc_0/Z2 divider_1/and_0/OUT 0.06fF
C760 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z4 0.36fF
C761 pll_full_1/pd_0/DIV pll_full_1/pd_0/tspc_r_0/Z3 0.65fF
C762 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/nor_0/B 0.02fF
C763 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z4 0.15fF
C764 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C765 divbuf_11/a_492_n240# divbuf_11/OUT 0.00fF
C766 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divider_0/tspc_2/Z4 0.65fF
C767 pd_1/tspc_r_1/Z2 pd_1/R 0.21fF
C768 io_clamp_low[1] io_analog[5] 0.53fF
C769 divider_2/tspc_2/Q divider_2/tspc_2/a_630_n680# 0.04fF
C770 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C771 filter_0/v divbuf_0/OUT4 1.11fF
C772 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/switch_1/vin 0.19fF
C773 pll_full_1/pd_0/tspc_r_0/Z1 pll_full_1/pd_0/tspc_r_0/Z2 0.71fF
C774 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar 0.03fF
C775 divbuf_14/OUT2 divbuf_14/OUT 0.06fF
C776 divbuf_14/OUT3 divbuf_14/OUT5 0.01fF
C777 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/Z4 0.15fF
C778 pll_full_1/divbuf_0/IN pll_full_1/divider_0/nor_1/B 0.27fF
C779 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C780 divbuf_1/a_492_n240# divbuf_1/OUT 0.00fF
C781 ro_complete_1/a2 ro_complete_1/cbank_2/v 0.05fF
C782 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C783 ro_complete_1/a4 ro_complete_1/cbank_2/switch_1/vin 0.09fF
C784 pll_full_1/cp_0/a_1710_0# pll_full_1/cp_0/down 0.32fF
C785 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C786 divider_0/tspc_0/Z4 divider_0/nor_0/B 0.02fF
C787 divider_0/tspc_2/Q divider_0/tspc_1/Z4 0.15fF
C788 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z4 0.36fF
C789 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/B 0.01fF
C790 divider_0/tspc_2/Z3 divider_0/tspc_2/Z4 0.65fF
C791 divbuf_22/OUT divbuf_22/OUT3 0.26fF
C792 divbuf_18/IN divbuf_18/OUT5 0.00fF
C793 divider_1/tspc_1/Q divider_1/tspc_0/a_630_n680# 0.01fF
C794 divbuf_10/a_492_n240# divbuf_10/IN 0.13fF
C795 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Qbar1 0.38fF
C796 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/Z3 0.05fF
C797 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/Z2 0.16fF
C798 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C799 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C800 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/clk 0.14fF
C801 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/B 0.78fF
C802 divbuf_7/OUT4 divbuf_7/OUT 1.11fF
C803 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z1 0.09fF
C804 pd_0/DIV pd_0/tspc_r_0/Z2 0.19fF
C805 divider_2/tspc_0/Z4 divider_2/tspc_0/a_630_n680# 0.12fF
C806 divbuf_13/a_492_n240# divbuf_13/OUT5 0.01fF
C807 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Qbar1 0.38fF
C808 divbuf_20/OUT ro_complete_0/cbank_1/switch_2/vin 0.14fF
C809 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Out1 0.05fF
C810 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.91fF
C811 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C812 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z2 0.01fF
C813 divbuf_15/OUT2 divbuf_15/OUT5 0.02fF
C814 divider_0/tspc_2/Q divider_0/tspc_2/Z3 0.05fF
C815 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C816 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z3 0.16fF
C817 divider_0/mc2 divider_0/and_0/B 0.20fF
C818 divbuf_23/OUT divbuf_23/OUT5 43.38fF
C819 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C820 divider_1/nor_0/B divider_1/tspc_0/Z4 0.02fF
C821 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/clk 0.01fF
C822 divbuf_6/OUT2 divbuf_6/OUT3 1.37fF
C823 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C824 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_0/Qbar 0.21fF
C825 divbuf_19/OUT divbuf_19/OUT4 1.11fF
C826 pd_0/R pd_0/tspc_r_1/Qbar 0.03fF
C827 divbuf_18/OUT3 divbuf_18/OUT4 5.16fF
C828 divider_2/prescaler_0/Out divider_2/tspc_2/Z4 0.12fF
C829 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/D 0.05fF
C830 divbuf_9/OUT3 divbuf_9/OUT 0.26fF
C831 divbuf_9/OUT4 divbuf_9/OUT5 20.26fF
C832 pd_1/and_pd_0/Out1 pd_1/and_pd_0/Z1 0.18fF
C833 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z4 0.14fF
C834 divbuf_21/OUT divbuf_21/OUT4 1.11fF
C835 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C836 divider_1/tspc_0/Z3 divider_1/tspc_0/a_630_n680# 0.05fF
C837 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z4 0.28fF
C838 divbuf_20/a_492_n240# divbuf_20/OUT2 0.42fF
C839 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z4 0.15fF
C840 pll_full_0/divbuf_0/IN pll_full_0/divider_0/nor_1/B 0.27fF
C841 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C842 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z2 0.01fF
C843 divider_1/tspc_2/Z2 divider_1/tspc_2/Z4 0.36fF
C844 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/a_492_n240# 0.00fF
C845 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/B 0.01fF
C846 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Out1 0.05fF
C847 divbuf_12/a_492_n240# divbuf_12/OUT 0.00fF
C848 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Q 0.20fF
C849 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/D 0.09fF
C850 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C851 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C852 divider_0/tspc_1/Q divider_0/tspc_0/Z4 0.15fF
C853 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z4 0.28fF
C854 pll_full_1/divider_0/prescaler_0/tspc_0/D pll_full_1/divider_0/prescaler_0/nand_1/z1 0.21fF
C855 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/switch_5/vin 0.20fF
C856 divider_0/and_0/OUT divider_0/and_0/B 0.01fF
C857 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z3 0.05fF
C858 divider_1/nor_0/B divider_1/tspc_1/Q 0.51fF
C859 divider_1/prescaler_0/tspc_1/Z2 divider_1/and_0/OUT 0.06fF
C860 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/a_630_n680# 0.19fF
C861 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Q 0.38fF
C862 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/D 0.11fF
C863 divbuf_21/IN divbuf_21/OUT5 0.00fF
C864 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C865 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C866 divbuf_7/a_492_n240# divbuf_7/IN 0.13fF
C867 pd_1/DOWN pd_1/and_pd_0/Out1 0.12fF
C868 divbuf_24/OUT4 divbuf_24/OUT 1.11fF
C869 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/nand_1/z1 0.22fF
C870 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/tspc_0/D 0.04fF
C871 ro_complete_1/a2 ro_complete_1/cbank_2/switch_3/vin 0.09fF
C872 divbuf_20/OUT ro_complete_0/cbank_0/switch_2/vin 0.14fF
C873 ro_complete_0/cbank_0/switch_1/vin divbuf_21/OUT 0.09fF
C874 ro_complete_0/cbank_0/switch_0/vin divbuf_23/OUT 0.09fF
C875 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.15fF
C876 pll_full_1/ro_complete_0/a0 pll_full_1/divider_0/clk 0.11fF
C877 pll_full_0/pd_0/REF pll_full_0/divbuf_1/OUT5 0.00fF
C878 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C879 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/z5 0.20fF
C880 divbuf_17/OUT5 divbuf_17/OUT 43.38fF
C881 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Q 0.91fF
C882 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C883 divbuf_4/a_492_n240# divbuf_4/OUT 0.00fF
C884 divider_1/mc2 divider_1/prescaler_0/tspc_2/a_630_n680# 0.33fF
C885 divider_1/nor_1/B divider_1/tspc_0/Z4 0.22fF
C886 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/Q 0.04fF
C887 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/clk 0.01fF
C888 divider_1/nor_0/B divider_1/nor_0/A 1.21fF
C889 divider_2/tspc_0/Z4 divider_2/tspc_1/Q 0.15fF
C890 divider_2/prescaler_0/tspc_0/Z2 divider_2/and_0/OUT 0.06fF
C891 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z3 0.16fF
C892 divbuf_23/OUT2 divbuf_23/OUT3 1.37fF
C893 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C894 divider_2/tspc_2/Z1 divider_2/tspc_2/Z4 0.00fF
C895 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/v 1.30fF
C896 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a5 0.09fF
C897 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C898 pll_full_0/pd_0/REF pll_full_0/divbuf_1/a_492_n240# 0.13fF
C899 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/and_pd_0/Z1 0.18fF
C900 divbuf_2/OUT4 divbuf_2/OUT 1.11fF
C901 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_0/Z3 0.20fF
C902 divbuf_5/OUT2 divbuf_5/OUT5 0.02fF
C903 divbuf_5/OUT3 divbuf_5/OUT4 5.16fF
C904 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C905 divbuf_22/a_492_n240# divbuf_22/OUT2 0.42fF
C906 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C907 pd_0/R pd_0/and_pd_0/Z1 0.02fF
C908 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/z5 0.20fF
C909 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z4 0.12fF
C910 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z2 1.07fF
C911 divbuf_8/OUT5 divbuf_8/OUT 43.38fF
C912 divbuf_25/a_492_n240# divbuf_25/OUT 0.00fF
C913 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C914 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C915 ro_complete_1/cbank_1/switch_5/vin ro_complete_1/cbank_1/v 1.30fF
C916 divider_0/prescaler_0/tspc_0/D divider_0/prescaler_0/nand_1/z1 0.21fF
C917 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C918 pll_full_0/ro_complete_0/a0 pll_full_0/divider_0/clk 0.11fF
C919 divider_1/tspc_1/Z2 divider_1/tspc_1/Z4 0.36fF
C920 divider_1/nor_1/B divider_1/tspc_1/Q 0.22fF
C921 divbuf_11/IN divbuf_11/OUT5 0.00fF
C922 pd_1/tspc_r_0/Z3 pd_1/tspc_r_0/Qbar1 0.38fF
C923 pd_0/and_pd_0/Out1 pd_0/and_pd_0/Z1 0.18fF
C924 divider_2/tspc_2/Q divider_2/nor_0/A 0.55fF
C925 divider_2/prescaler_0/tspc_1/Z2 divider_2/clk 0.11fF
C926 divbuf_24/a_492_n240# divbuf_24/IN 0.13fF
C927 divbuf_19/OUT divbuf_19/a_492_n240# 0.00fF
C928 divbuf_14/OUT4 divbuf_14/OUT 1.11fF
C929 pll_full_1/ro_complete_0/a3 pll_full_1/divider_0/clk 0.11fF
C930 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Qbar1 0.12fF
C931 divbuf_0/OUT3 divbuf_0/OUT5 0.01fF
C932 divbuf_18/OUT ro_complete_0/cbank_2/switch_5/vin 0.09fF
C933 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C934 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a4 0.09fF
C935 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a5 0.09fF
C936 divbuf_22/OUT divbuf_22/OUT5 43.38fF
C937 pll_full_1/pd_0/REF pll_full_1/pd_0/DOWN 1.48fF
C938 pll_full_1/divbuf_0/OUT3 pll_full_1/divbuf_0/OUT5 0.01fF
C939 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C940 divider_1/prescaler_0/tspc_2/Z4 divider_1/prescaler_0/tspc_2/D 0.11fF
C941 pd_0/DIV pd_0/R 0.51fF
C942 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/a_630_n680# 0.19fF
C943 pd_1/R pd_1/and_pd_0/Out1 0.33fF
C944 pd_1/tspc_r_1/Qbar1 pd_1/UP 0.11fF
C945 pd_1/REF pd_1/tspc_r_1/Z4 0.02fF
C946 divbuf_13/OUT2 divbuf_13/OUT3 1.37fF
C947 divbuf_21/OUT divbuf_23/OUT 1.95fF
C948 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C949 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/v 1.30fF
C950 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.09fF
C951 divider_1/tspc_0/Z3 divider_1/nor_1/B 0.38fF
C952 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/Out 0.04fF
C953 divbuf_15/OUT2 divbuf_15/a_492_n240# 0.42fF
C954 divider_0/tspc_0/Z3 divider_0/tspc_0/Z1 0.06fF
C955 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z4 0.36fF
C956 ro_complete_1/a5 ro_complete_1/cbank_1/v 0.10fF
C957 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_0/vin 0.19fF
C958 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/A 0.01fF
C959 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_0/Z2 1.07fF
C960 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C961 divbuf_16/a_492_n240# divbuf_16/OUT 0.00fF
C962 divbuf_6/OUT2 divbuf_6/OUT5 0.02fF
C963 divbuf_6/OUT3 divbuf_6/OUT4 5.16fF
C964 divbuf_17/OUT2 divbuf_17/a_492_n240# 0.42fF
C965 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/clk 0.01fF
C966 divbuf_8/a_492_n240# divbuf_8/OUT2 0.42fF
C967 pd_1/DIV pd_1/tspc_r_0/Qbar1 0.12fF
C968 pd_0/REF pd_0/tspc_r_1/Qbar1 0.12fF
C969 divider_2/tspc_1/Z1 divider_2/tspc_2/Q 0.01fF
C970 divider_2/tspc_1/Z3 divider_2/tspc_1/Q 0.05fF
C971 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT5 43.38fF
C972 divbuf_9/OUT5 divbuf_9/OUT 43.38fF
C973 pll_full_1/divbuf_0/IN pll_full_1/divider_0/tspc_0/a_630_n680# 0.04fF
C974 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_4/vin 0.20fF
C975 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/Out 0.21fF
C976 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z2 0.01fF
C977 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/a_492_n240# 0.01fF
C978 divbuf_16/OUT3 divbuf_16/OUT5 0.01fF
C979 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/D 0.15fF
C980 ro_complete_1/a0 ro_complete_1/cbank_1/switch_5/vin 0.09fF
C981 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/R 0.29fF
C982 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/z5 0.04fF
C983 pll_full_0/ro_complete_0/a3 pll_full_0/divider_0/clk 0.11fF
C984 divbuf_12/IN divbuf_12/OUT5 0.00fF
C985 pd_1/DOWN pd_1/tspc_r_0/Z3 0.03fF
C986 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Q 0.04fF
C987 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C988 divbuf_14/a_492_n240# divbuf_14/IN 0.13fF
C989 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z2 1.07fF
C990 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C991 divbuf_16/OUT3 divbuf_16/OUT4 5.16fF
C992 divider_0/mc2 divider_0/and_0/OUT 0.05fF
C993 divider_0/tspc_0/Z3 divider_0/nor_1/B 0.38fF
C994 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/nor_0/A 0.03fF
C995 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_0/Z2 0.40fF
C996 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/DOWN 0.03fF
C997 divbuf_3/a_492_n240# divbuf_3/OUT5 0.01fF
C998 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/v 1.30fF
C999 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/Qbar1 0.38fF
C1000 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C1001 divbuf_21/OUT3 divbuf_21/OUT5 0.01fF
C1002 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C1003 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z4 0.08fF
C1004 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Q 0.04fF
C1005 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/A 0.01fF
C1006 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z2 1.07fF
C1007 divbuf_19/OUT5 divbuf_19/OUT2 0.02fF
C1008 divbuf_19/OUT4 divbuf_19/OUT3 5.16fF
C1009 divider_1/and_0/B divider_1/and_0/Z1 0.07fF
C1010 pd_1/R pd_1/tspc_r_1/Z3 0.29fF
C1011 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/nand_1/z1 0.01fF
C1012 divider_2/prescaler_0/tspc_2/Z2 divider_2/clk 0.11fF
C1013 pll_full_1/divbuf_0/a_492_n240# pll_full_1/divbuf_0/IN 0.13fF
C1014 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/a5 0.09fF
C1015 divbuf_19/OUT divbuf_19/OUT3 0.26fF
C1016 ro_complete_0/cbank_1/v ro_complete_0/cbank_2/v 1.36fF
C1017 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/D 0.09fF
C1018 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1019 divider_0/and_0/out1 divider_0/and_0/A 0.01fF
C1020 divider_0/tspc_0/Z1 divider_0/tspc_0/Z2 1.07fF
C1021 pll_full_1/divbuf_0/OUT3 pll_full_1/pd_0/DIV 0.26fF
C1022 pll_full_0/divbuf_0/IN pll_full_0/divider_0/tspc_0/a_630_n680# 0.04fF
C1023 divider_2/nor_0/B divider_2/tspc_1/Z2 0.30fF
C1024 divbuf_23/OUT2 divbuf_23/OUT5 0.02fF
C1025 divbuf_23/OUT3 divbuf_23/OUT4 5.16fF
C1026 pd_0/DOWN pd_0/UP 0.46fF
C1027 pd_0/tspc_r_0/Z4 pd_0/tspc_r_0/z5 0.04fF
C1028 divbuf_17/a_492_n240# divbuf_17/IN 0.13fF
C1029 divider_2/tspc_0/a_630_n680# divider_2/tspc_1/Q 0.01fF
C1030 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z4 0.36fF
C1031 divbuf_18/OUT divbuf_18/OUT3 0.26fF
C1032 divbuf_9/a_492_n240# divbuf_9/OUT2 0.42fF
C1033 pd_1/UP pd_1/and_pd_0/Z1 0.06fF
C1034 divider_2/tspc_2/Z3 divider_2/tspc_2/Z4 0.65fF
C1035 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/nor_0/B 0.06fF
C1036 divbuf_0/OUT2 divbuf_0/a_492_n240# 0.42fF
C1037 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1038 divider_0/tspc_0/Z3 divider_0/Out 0.05fF
C1039 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/nor_0/A 0.15fF
C1040 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/Z3 0.45fF
C1041 ro_complete_1/cbank_1/switch_2/vin ro_complete_1/cbank_1/v 1.30fF
C1042 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_1/z5 0.02fF
C1043 divider_1/tspc_1/Z1 divider_1/tspc_1/Z2 1.07fF
C1044 divider_1/prescaler_0/Out divider_1/prescaler_0/m1_2700_2190# 0.11fF
C1045 divbuf_5/OUT3 divbuf_5/OUT 0.26fF
C1046 divbuf_5/OUT4 divbuf_5/OUT5 20.26fF
C1047 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/R 0.03fF
C1048 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/UP 0.06fF
C1049 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z2 1.07fF
C1050 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C1051 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT5 43.38fF
C1052 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/nor_0/A 0.03fF
C1053 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_0/Z2 0.40fF
C1054 divider_1/tspc_2/a_630_n680# divider_1/nor_0/A 0.35fF
C1055 divider_1/prescaler_0/tspc_1/Q divider_1/clk 0.60fF
C1056 pd_1/tspc_r_0/Z1 pd_1/tspc_r_0/Z3 0.09fF
C1057 pll_full_1/pd_0/DIV pll_full_1/divider_0/and_0/OUT 0.01fF
C1058 pll_full_1/divbuf_1/a_492_n240# pll_full_1/divbuf_1/OUT5 0.01fF
C1059 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1060 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C1061 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z3 0.16fF
C1062 divbuf_25/IN divbuf_25/OUT5 0.00fF
C1063 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/Out 0.04fF
C1064 divbuf_1/OUT2 divbuf_1/OUT5 0.02fF
C1065 divbuf_1/OUT3 divbuf_1/OUT4 5.16fF
C1066 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/v 1.30fF
C1067 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/pd_0/tspc_r_1/Z2 0.71fF
C1068 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT3 1.37fF
C1069 divider_0/tspc_1/Z1 divider_0/tspc_1/Z2 1.07fF
C1070 divider_0/prescaler_0/Out divider_0/prescaler_0/m1_2700_2190# 0.11fF
C1071 ro_complete_1/cbank_0/v ro_complete_1/cbank_2/v 0.04fF
C1072 divider_0/prescaler_0/tspc_1/Q divider_0/nor_0/A 0.03fF
C1073 divider_0/nor_1/B divider_0/tspc_0/Z2 0.40fF
C1074 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/IN 0.13fF
C1075 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/tspc_r_1/Qbar1 0.01fF
C1076 divbuf_11/OUT2 divbuf_11/OUT 0.06fF
C1077 divbuf_11/OUT3 divbuf_11/OUT5 0.01fF
C1078 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z2 0.19fF
C1079 divider_2/nor_0/B divider_2/and_0/A 0.26fF
C1080 pd_1/DOWN pd_1/UP 0.46fF
C1081 pd_1/tspc_r_0/Z3 pd_1/R 0.27fF
C1082 io_clamp_high[0] io_analog[4] 0.53fF
C1083 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/UP 0.03fF
C1084 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/and_0/B 0.18fF
C1085 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/a_630_n680# 0.01fF
C1086 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1087 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_4/vin 0.20fF
C1088 divbuf_18/OUT ro_complete_0/cbank_2/v 0.05fF
C1089 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z1 0.03fF
C1090 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z3 0.05fF
C1091 divbuf_15/OUT4 divbuf_15/OUT3 5.16fF
C1092 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_1/Z4 0.02fF
C1093 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_0/B 0.06fF
C1094 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Q 0.20fF
C1095 divider_1/prescaler_0/tspc_0/Z2 divider_1/clk 0.11fF
C1096 divbuf_10/a_492_n240# divbuf_10/OUT5 0.01fF
C1097 pll_full_1/divbuf_1/OUT2 pll_full_1/divbuf_1/a_492_n240# 0.42fF
C1098 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_0/A 0.15fF
C1099 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z3 0.45fF
C1100 pd_1/DIV pd_1/tspc_r_0/Z1 0.17fF
C1101 pd_0/tspc_r_0/Qbar1 pd_0/R 0.01fF
C1102 pd_0/DIV pd_0/tspc_r_0/Z4 0.02fF
C1103 pd_0/DOWN pd_0/tspc_r_0/Qbar 0.21fF
C1104 divbuf_18/OUT divbuf_18/OUT2 0.06fF
C1105 divbuf_13/OUT2 divbuf_13/OUT5 0.02fF
C1106 divbuf_13/OUT3 divbuf_13/OUT4 5.16fF
C1107 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/z5 0.11fF
C1108 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1109 divider_2/and_0/OUT divider_2/and_0/B 0.01fF
C1110 ro_complete_0/cbank_1/switch_3/vin divbuf_19/OUT 0.14fF
C1111 divbuf_2/OUT2 divbuf_2/a_492_n240# 0.42fF
C1112 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1113 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z3 0.06fF
C1114 divider_0/tspc_1/Z2 divider_0/nor_0/A 0.15fF
C1115 divider_0/prescaler_0/Out divider_0/tspc_2/Z3 0.45fF
C1116 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/Out 0.04fF
C1117 divider_2/nor_0/B divider_2/tspc_1/Z4 0.21fF
C1118 divider_2/nor_1/Z1 divider_2/and_0/B 0.78fF
C1119 divider_1/nor_0/B divider_1/and_0/B 0.31fF
C1120 divider_1/tspc_1/Q divider_1/tspc_0/Z4 0.15fF
C1121 divider_1/prescaler_0/tspc_2/Z4 divider_1/clk 0.12fF
C1122 divbuf_6/OUT3 divbuf_6/OUT 0.26fF
C1123 divbuf_6/OUT4 divbuf_6/OUT5 20.26fF
C1124 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1125 pd_1/DIV pd_1/R 0.51fF
C1126 pd_0/tspc_r_1/Z3 pd_0/UP 0.03fF
C1127 divider_2/tspc_1/Z3 divider_2/tspc_2/Q 0.45fF
C1128 divider_2/tspc_1/Z2 divider_2/tspc_1/a_630_n680# 0.01fF
C1129 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1130 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C1131 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/Out 0.04fF
C1132 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/cbank_1/v 1.43fF
C1133 divbuf_21/OUT ro_complete_0/cbank_2/switch_0/vin 0.12fF
C1134 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/tspc_2/D 0.03fF
C1135 ro_complete_1/a0 ro_complete_1/cbank_1/v 0.05fF
C1136 ro_complete_1/a3 ro_complete_1/cbank_2/v 0.05fF
C1137 divider_1/tspc_2/Q divider_1/tspc_1/Z4 0.15fF
C1138 divider_1/Out divider_1/tspc_0/a_630_n680# 0.04fF
C1139 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/D 0.05fF
C1140 divider_1/nor_0/Z1 divider_1/nor_0/B 0.06fF
C1141 divider_1/mc2 divider_1/and_0/A 0.16fF
C1142 divider_1/tspc_1/Z2 divider_1/tspc_1/a_630_n680# 0.01fF
C1143 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C1144 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/B 0.18fF
C1145 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C1146 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1147 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z1 0.03fF
C1148 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z3 0.05fF
C1149 divbuf_12/OUT2 divbuf_12/OUT 0.06fF
C1150 divbuf_12/OUT3 divbuf_12/OUT5 0.01fF
C1151 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C1152 ro_complete_1/a2 ro_complete_1/cbank_1/switch_3/vin 0.09fF
C1153 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/Z3 0.16fF
C1154 pll_full_1/ro_complete_0/a4 pll_full_1/divider_0/clk 0.01fF
C1155 pll_full_0/pd_0/R pll_full_0/pd_0/REF 0.61fF
C1156 divider_0/tspc_1/Z2 divider_0/tspc_1/a_630_n680# 0.01fF
C1157 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1158 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/switch_5/vin 0.20fF
C1159 divbuf_22/OUT ro_complete_0/cbank_2/v 0.05fF
C1160 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/OUT2 0.02fF
C1161 divbuf_3/OUT2 divbuf_3/OUT3 1.37fF
C1162 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1163 divbuf_17/OUT5 divbuf_17/a_492_n240# 0.01fF
C1164 divider_1/tspc_2/Q divider_1/tspc_2/Z3 0.05fF
C1165 divider_1/tspc_0/Z3 divider_1/tspc_0/Z4 0.65fF
C1166 divider_0/nor_0/A divider_0/tspc_2/Z1 0.03fF
C1167 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z3 0.05fF
C1168 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z4 0.12fF
C1169 pll_full_1/pd_0/DIV pll_full_1/pd_0/tspc_r_0/Qbar1 0.12fF
C1170 divbuf_7/a_492_n240# divbuf_7/OUT5 0.01fF
C1171 pd_1/R pd_1/UP 0.45fF
C1172 divider_2/prescaler_0/tspc_0/D divider_2/prescaler_0/nand_1/z1 0.21fF
C1173 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1174 divbuf_1/OUT2 divbuf_1/a_492_n240# 0.42fF
C1175 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z4 0.00fF
C1176 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/and_0/A 0.01fF
C1177 divbuf_23/OUT divbuf_23/a_492_n240# 0.00fF
C1178 divbuf_4/OUT2 divbuf_4/OUT3 1.37fF
C1179 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C1180 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z4 0.08fF
C1181 divider_1/prescaler_0/tspc_1/Z2 divider_1/clk 0.11fF
C1182 divider_1/nor_1/B divider_1/and_0/B 0.29fF
C1183 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/UP 0.33fF
C1184 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C1185 pd_0/R pd_0/REF 0.61fF
C1186 divider_2/nor_0/Z1 divider_2/and_0/B 0.18fF
C1187 divider_2/prescaler_0/Out divider_2/tspc_2/a_630_n680# 0.01fF
C1188 divbuf_23/OUT4 divbuf_23/OUT5 20.26fF
C1189 divider_0/tspc_0/Z3 divider_0/tspc_0/a_630_n680# 0.05fF
C1190 divbuf_22/OUT ro_complete_0/cbank_1/switch_2/vin 0.09fF
C1191 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/nor_0/A 0.01fF
C1192 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/Z4 0.12fF
C1193 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Z2 0.01fF
C1194 divbuf_17/OUT3 divbuf_17/OUT4 5.16fF
C1195 divider_1/tspc_0/Z3 divider_1/tspc_1/Q 0.45fF
C1196 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/a_740_n680# 0.33fF
C1197 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/D 0.03fF
C1198 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/switch_5/vin 0.20fF
C1199 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C1200 divbuf_5/OUT5 divbuf_5/OUT 43.38fF
C1201 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z3 0.16fF
C1202 pll_full_0/ro_complete_0/a4 pll_full_0/divider_0/clk 0.01fF
C1203 divider_1/tspc_1/Z2 divider_1/tspc_1/Z3 0.16fF
C1204 divider_1/and_0/OUT divider_1/and_0/Z1 0.04fF
C1205 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z2 0.01fF
C1206 divider_1/prescaler_0/tspc_2/Q divider_1/clk 0.05fF
C1207 divbuf_19/IN divbuf_19/a_492_n240# 0.13fF
C1208 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z4 0.12fF
C1209 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z4 0.36fF
C1210 divider_2/prescaler_0/tspc_0/Z2 divider_2/clk 0.11fF
C1211 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C1212 divbuf_25/OUT2 divbuf_25/OUT 0.06fF
C1213 divbuf_25/OUT3 divbuf_25/OUT5 0.01fF
C1214 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C1215 divider_0/tspc_1/Z2 divider_0/tspc_1/Z3 0.16fF
C1216 divbuf_1/OUT3 divbuf_1/OUT 0.26fF
C1217 filter_0/v divbuf_0/OUT5 43.38fF
C1218 ro_complete_1/a4 ro_complete_1/cbank_1/switch_1/vin 0.09fF
C1219 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_5/vin 0.20fF
C1220 pll_full_1/divider_0/tspc_1/Z4 pll_full_1/divider_0/nor_0/A 0.02fF
C1221 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_0/Z2 0.20fF
C1222 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT4 5.16fF
C1223 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1224 divbuf_21/a_492_n240# divbuf_21/IN 0.13fF
C1225 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/tspc_r_1/Z4 0.14fF
C1226 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z4 0.00fF
C1227 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C1228 divbuf_11/OUT4 divbuf_11/OUT 1.11fF
C1229 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/A 0.01fF
C1230 divider_1/and_0/out1 divider_1/and_0/B 0.18fF
C1231 pd_1/tspc_r_1/Z1 pd_1/REF 0.17fF
C1232 pd_1/tspc_r_0/Z3 pd_1/tspc_r_0/Z4 0.20fF
C1233 divider_2/nor_1/B divider_2/tspc_0/Z3 0.38fF
C1234 divbuf_24/a_492_n240# divbuf_24/OUT5 0.01fF
C1235 pll_full_1/divbuf_1/OUT5 pll_full_1/divbuf_1/OUT 43.38fF
C1236 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/IN 0.00fF
C1237 pll_full_1/ro_complete_0/cbank_1/switch_4/vin pll_full_1/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C1238 filter_0/v divbuf_0/OUT3 0.26fF
C1239 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z1 0.09fF
C1240 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z2 0.19fF
C1241 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/nor_0/B 0.30fF
C1242 pll_full_1/ro_complete_0/a1 pll_full_1/divider_0/clk 0.11fF
C1243 divider_0/tspc_1/Z1 divider_0/tspc_1/Z4 0.00fF
C1244 divbuf_2/OUT2 divbuf_2/OUT3 1.37fF
C1245 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z3 0.38fF
C1246 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z4 0.12fF
C1247 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z2 1.07fF
C1248 divider_0/nor_0/A divider_0/and_0/A 0.01fF
C1249 ro_complete_1/cbank_2/switch_5/vin ro_complete_1/cbank_2/v 1.30fF
C1250 divbuf_10/OUT2 divbuf_10/OUT3 1.37fF
C1251 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/R 0.27fF
C1252 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/nor_0/A 0.01fF
C1253 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z4 0.12fF
C1254 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z2 0.01fF
C1255 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Q 0.04fF
C1256 divider_1/prescaler_0/Out divider_1/clk 0.51fF
C1257 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/z5 0.11fF
C1258 divider_2/Out divider_2/nor_1/B 0.22fF
C1259 pd_1/UP pd_1/tspc_r_1/z5 0.03fF
C1260 divbuf_13/OUT3 divbuf_13/OUT 0.26fF
C1261 divbuf_13/OUT4 divbuf_13/OUT5 20.26fF
C1262 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/a1 0.14fF
C1263 ro_complete_0/cbank_0/switch_3/vin divbuf_19/OUT 0.14fF
C1264 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/v 1.30fF
C1265 ro_complete_0/cbank_0/switch_2/vin divbuf_22/OUT 0.09fF
C1266 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_2/a_630_n680# 0.04fF
C1267 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_1/Z4 0.12fF
C1268 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C1269 divider_1/tspc_2/Q divider_1/tspc_1/Z1 0.01fF
C1270 divider_1/Out divider_1/nor_1/B 0.22fF
C1271 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z4 0.00fF
C1272 divider_0/prescaler_0/m1_2700_2190# divider_0/nor_0/A 0.01fF
C1273 divider_0/prescaler_0/Out divider_0/tspc_2/Z4 0.12fF
C1274 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z2 0.01fF
C1275 divbuf_20/OUT divbuf_20/OUT3 0.26fF
C1276 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/Z1 0.36fF
C1277 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/DIV 0.02fF
C1278 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C1279 divbuf_5/a_492_n240# divbuf_5/OUT2 0.42fF
C1280 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C1281 divbuf_6/OUT5 divbuf_6/OUT 43.38fF
C1282 pll_full_1/divbuf_1/OUT2 pll_full_1/divbuf_1/OUT 0.06fF
C1283 pll_full_1/divbuf_1/OUT3 pll_full_1/divbuf_1/OUT5 0.01fF
C1284 pll_full_0/divider_0/tspc_1/Z4 pll_full_0/divider_0/nor_0/A 0.02fF
C1285 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_0/Z2 0.20fF
C1286 divbuf_8/a_492_n240# divbuf_8/OUT 0.00fF
C1287 pd_1/DIV pd_1/tspc_r_0/Z4 0.02fF
C1288 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z1 0.09fF
C1289 pd_0/REF pd_0/tspc_r_1/Z2 0.19fF
C1290 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/a1 0.14fF
C1291 pll_full_1/ro_complete_0/cbank_0/switch_2/vin pll_full_1/ro_complete_0/a3 0.09fF
C1292 divider_2/prescaler_0/tspc_0/Z4 divider_2/clk 0.12fF
C1293 divider_2/and_0/out1 divider_2/and_0/A 0.01fF
C1294 divider_2/tspc_0/Z2 divider_2/tspc_0/Z3 0.16fF
C1295 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/v 1.30fF
C1296 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/v 1.30fF
C1297 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/cbank_0/v 1.30fF
C1298 divider_0/tspc_0/Z3 divider_0/tspc_1/Q 0.45fF
C1299 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z3 0.06fF
C1300 divider_0/nor_0/Z1 divider_0/nor_0/B 0.06fF
C1301 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/Z2 0.14fF
C1302 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/nand_0/z1 0.01fF
C1303 divbuf_15/OUT2 divbuf_15/OUT3 1.37fF
C1304 divider_0/tspc_1/Z4 divider_0/nor_0/A 0.02fF
C1305 divider_0/nor_0/B divider_0/tspc_0/Z2 0.20fF
C1306 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C1307 divider_1/tspc_1/Z2 divider_1/nor_0/B 0.30fF
C1308 divbuf_20/IN divbuf_20/OUT5 0.00fF
C1309 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_0/B 0.30fF
C1310 pll_full_0/ro_complete_0/a1 pll_full_0/divider_0/clk 0.11fF
C1311 divbuf_11/a_492_n240# divbuf_11/IN 0.13fF
C1312 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z3 0.38fF
C1313 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z4 0.12fF
C1314 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z2 1.07fF
C1315 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/Z2 1.07fF
C1316 divbuf_12/OUT4 divbuf_12/OUT 1.11fF
C1317 pll_full_1/ro_complete_0/cbank_0/switch_5/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1318 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Qbar1 0.12fF
C1319 divider_2/mc2 divider_2/and_0/A 0.16fF
C1320 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar1 0.30fF
C1321 divbuf_14/a_492_n240# divbuf_14/OUT5 0.01fF
C1322 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/v 1.30fF
C1323 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/OUT3 0.01fF
C1324 divider_0/tspc_1/Z2 divider_0/nor_0/B 0.30fF
C1325 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/clk 0.06fF
C1326 divbuf_16/OUT3 divbuf_16/OUT 0.26fF
C1327 divider_1/prescaler_0/tspc_2/Z3 divider_1/clk 0.45fF
C1328 divider_0/nor_0/A divider_0/tspc_2/Z3 0.38fF
C1329 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z4 0.12fF
C1330 divider_0/tspc_2/Z1 divider_0/tspc_2/Z2 1.07fF
C1331 divbuf_22/OUT divbuf_22/a_492_n240# 0.00fF
C1332 divbuf_3/OUT2 divbuf_3/OUT5 0.02fF
C1333 divbuf_3/OUT3 divbuf_3/OUT4 5.16fF
C1334 pll_full_1/divbuf_1/OUT2 pll_full_1/divbuf_1/OUT3 1.37fF
C1335 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/z5 0.11fF
C1336 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C1337 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Z2 0.25fF
C1338 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/a_630_n680# 0.04fF
C1339 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z4 0.12fF
C1340 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C1341 pd_0/DIV pd_0/tspc_r_0/Z3 0.65fF
C1342 divbuf_7/OUT2 divbuf_7/OUT3 1.37fF
C1343 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/IN 5.26fF
C1344 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/Z1 0.36fF
C1345 divider_2/prescaler_0/tspc_1/Q divider_2/nor_0/A 0.03fF
C1346 divider_2/tspc_0/Z1 divider_2/tspc_0/Z3 0.06fF
C1347 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_1/Z4 0.65fF
C1348 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C1349 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1350 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/a3 0.09fF
C1351 divbuf_15/OUT divbuf_15/OUT4 1.11fF
C1352 divider_0/nor_0/Z1 divider_0/and_0/B 0.18fF
C1353 divider_0/tspc_2/Q divider_0/tspc_2/a_630_n680# 0.04fF
C1354 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z4 0.12fF
C1355 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z2 0.01fF
C1356 divider_0/and_0/out1 divider_0/and_0/Z1 0.36fF
C1357 divbuf_4/OUT2 divbuf_4/OUT5 0.02fF
C1358 divbuf_4/OUT3 divbuf_4/OUT4 5.16fF
C1359 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/DOWN 0.02fF
C1360 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_2/Q 0.19fF
C1361 divbuf_6/a_492_n240# divbuf_6/OUT2 0.42fF
C1362 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z2 0.14fF
C1363 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C1364 pd_1/tspc_r_0/Z1 pd_1/tspc_r_0/Z2 0.71fF
C1365 pd_0/DOWN pd_0/tspc_r_1/Qbar 0.02fF
C1366 pd_0/R pd_0/tspc_r_1/Qbar1 0.30fF
C1367 divbuf_18/OUT3 divbuf_18/OUT5 0.01fF
C1368 divider_2/prescaler_0/Out divider_2/nor_0/A 0.15fF
C1369 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C1370 divbuf_9/a_492_n240# divbuf_9/OUT 0.00fF
C1371 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/a3 0.13fF
C1372 divbuf_22/OUT ro_complete_0/cbank_2/switch_1/vin 0.13fF
C1373 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1374 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/REF 0.65fF
C1375 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.15fF
C1376 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/v 1.30fF
C1377 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1378 divider_1/tspc_2/Q divider_1/tspc_1/a_630_n680# 0.01fF
C1379 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/a_630_n680# 0.05fF
C1380 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z4 0.00fF
C1381 divbuf_15/OUT5 divbuf_15/a_492_n240# 0.01fF
C1382 divider_0/tspc_1/Q divider_0/tspc_0/Z2 0.14fF
C1383 divider_0/and_0/OUT divider_0/prescaler_0/nand_0/z1 0.01fF
C1384 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/R 0.02fF
C1385 divbuf_18/OUT2 divbuf_18/a_492_n240# 0.42fF
C1386 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/Z1 0.00fF
C1387 divider_1/nor_0/A divider_1/tspc_2/Z2 0.23fF
C1388 divider_1/prescaler_0/tspc_0/D divider_1/clk 0.29fF
C1389 divbuf_22/IN divbuf_22/OUT5 0.00fF
C1390 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/clk 0.06fF
C1391 pd_1/tspc_r_0/Z2 pd_1/R 0.21fF
C1392 divbuf_12/a_492_n240# divbuf_12/IN 0.13fF
C1393 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C1394 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1395 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z1 0.17fF
C1396 divbuf_25/OUT4 divbuf_25/OUT 1.11fF
C1397 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z1 0.01fF
C1398 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1399 pll_full_0/pd_0/DOWN pll_full_0/pd_0/UP 4.58fF
C1400 divbuf_21/OUT ro_complete_0/cbank_2/v 0.05fF
C1401 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/v 1.30fF
C1402 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/and_0/A 0.26fF
C1403 divider_0/and_0/OUT divider_0/clk 0.04fF
C1404 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Q 0.91fF
C1405 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Z4 0.65fF
C1406 pd_1/tspc_r_1/Z2 pd_1/tspc_r_1/Z3 0.25fF
C1407 pd_1/tspc_r_0/Qbar1 pd_1/tspc_r_0/z5 0.20fF
C1408 divbuf_24/OUT2 divbuf_24/OUT3 1.37fF
C1409 pll_full_1/pd_0/DIV pll_full_1/divider_0/clk 2.26fF
C1410 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1411 pll_full_0/pd_0/DIV pll_full_0/pd_0/R 0.51fF
C1412 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C1413 divbuf_2/OUT2 divbuf_2/OUT5 0.02fF
C1414 divbuf_2/OUT3 divbuf_2/OUT4 5.16fF
C1415 ro_complete_0/cbank_2/switch_2/vin ro_complete_0/cbank_2/v 1.30fF
C1416 divider_0/tspc_1/Z3 divider_0/tspc_1/Z4 0.65fF
C1417 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z4 0.21fF
C1418 pll_full_1/divider_0/tspc_2/Z2 pll_full_1/divider_0/tspc_2/Z3 0.16fF
C1419 divbuf_4/a_492_n240# divbuf_4/IN 0.13fF
C1420 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z3 0.33fF
C1421 divbuf_10/OUT2 divbuf_10/OUT5 0.02fF
C1422 divbuf_10/OUT3 divbuf_10/OUT4 5.16fF
C1423 divbuf_18/OUT2 divbuf_18/OUT5 0.02fF
C1424 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C1425 pd_0/tspc_r_0/Z2 pd_0/R 0.21fF
C1426 pd_0/DOWN pd_0/tspc_r_0/z5 0.03fF
C1427 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_1/Q 0.21fF
C1428 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z2 0.01fF
C1429 divbuf_23/a_492_n240# divbuf_23/OUT2 0.42fF
C1430 pd_1/tspc_r_1/Z4 pd_1/tspc_r_1/z5 0.04fF
C1431 divbuf_13/OUT5 divbuf_13/OUT 43.38fF
C1432 pll_full_1/ro_complete_0/cbank_2/switch_2/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C1433 divider_2/nor_0/A divider_2/tspc_2/Z1 0.03fF
C1434 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z3 0.05fF
C1435 ro_complete_0/cbank_1/switch_1/vin divbuf_22/OUT 0.14fF
C1436 ro_complete_0/cbank_2/switch_3/vin divbuf_19/OUT 0.14fF
C1437 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/nor_0/A 0.55fF
C1438 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Z4 0.21fF
C1439 divbuf_20/OUT divbuf_20/OUT5 43.38fF
C1440 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C1441 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1442 divider_1/tspc_2/Q divider_1/tspc_1/Z3 0.45fF
C1443 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/D 0.15fF
C1444 pll_full_1/divider_0/and_0/A pll_full_1/divider_0/and_0/B 0.18fF
C1445 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z1 0.01fF
C1446 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1447 divider_1/and_0/OUT divider_1/and_0/out1 0.31fF
C1448 pll_full_1/divbuf_1/OUT4 pll_full_1/divbuf_1/OUT 1.11fF
C1449 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/A 0.26fF
C1450 pd_0/DOWN pd_0/and_pd_0/Z1 0.07fF
C1451 divbuf_8/IN divbuf_8/OUT5 0.00fF
C1452 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/a1 0.14fF
C1453 divbuf_25/a_492_n240# divbuf_25/IN 0.13fF
C1454 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT2 0.06fF
C1455 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/R 0.01fF
C1456 ro_complete_0/cbank_1/switch_4/vin divbuf_18/OUT 0.13fF
C1457 divider_0/tspc_2/Q divider_0/tspc_1/Z1 0.01fF
C1458 divider_0/tspc_0/Z3 divider_0/tspc_0/Z4 0.65fF
C1459 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1460 divbuf_23/OUT ro_complete_0/cbank_2/switch_0/vin 0.09fF
C1461 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/tspc_0/Z2 0.36fF
C1462 pll_full_1/divider_0/prescaler_0/tspc_2/D pll_full_1/divider_0/prescaler_0/nand_0/z1 0.24fF
C1463 ro_complete_1/a1 ro_complete_1/cbank_2/v 0.05fF
C1464 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1465 divider_0/nor_0/B divider_0/and_0/A 0.26fF
C1466 divbuf_20/OUT3 divbuf_20/OUT5 0.01fF
C1467 pll_full_1/pd_0/REF pll_full_1/divbuf_1/a_492_n240# 0.13fF
C1468 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C1469 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z3 0.06fF
C1470 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_0/Z3 0.16fF
C1471 divider_1/nor_0/A divider_1/and_0/B 0.08fF
C1472 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z4 0.21fF
C1473 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z3 0.16fF
C1474 pd_1/DOWN pd_1/tspc_r_0/z5 0.03fF
C1475 io_clamp_low[2] io_analog[6] 0.53fF
C1476 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/DOWN 0.03fF
C1477 divider_2/tspc_1/Z2 divider_2/nor_0/A 0.15fF
C1478 divider_2/tspc_0/Z4 divider_2/tspc_0/Z3 0.65fF
C1479 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/D 0.03fF
C1480 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C1481 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_4/vin 0.20fF
C1482 divbuf_14/OUT2 divbuf_14/OUT3 1.37fF
C1483 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/a_630_n680# 0.01fF
C1484 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1485 pll_full_1/ro_complete_0/a5 pll_full_1/divider_0/clk 0.15fF
C1486 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z3 0.06fF
C1487 divbuf_19/OUT ro_complete_0/cbank_2/v 0.05fF
C1488 pll_full_1/divider_0/prescaler_0/tspc_2/D pll_full_1/divider_0/clk 0.26fF
C1489 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/OUT4 20.26fF
C1490 divbuf_3/OUT3 divbuf_3/OUT 0.26fF
C1491 divbuf_3/OUT4 divbuf_3/OUT5 20.26fF
C1492 pll_full_1/divbuf_1/OUT3 pll_full_1/divbuf_1/OUT4 5.16fF
C1493 pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1494 divider_0/nor_0/A divider_0/tspc_2/Z4 0.21fF
C1495 divider_0/tspc_2/Z2 divider_0/tspc_2/Z3 0.16fF
C1496 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/nor_0/A 0.55fF
C1497 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z4 0.21fF
C1498 divbuf_7/OUT2 divbuf_7/OUT5 0.02fF
C1499 divbuf_7/OUT3 divbuf_7/OUT4 5.16fF
C1500 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Qbar1 0.38fF
C1501 pll_full_0/divider_0/and_0/A pll_full_0/divider_0/and_0/B 0.18fF
C1502 cp_0/a_1710_0# cp_0/out 0.84fF
C1503 pd_1/tspc_r_0/Z4 pd_1/tspc_r_1/Z4 0.02fF
C1504 divbuf_13/a_492_n240# divbuf_13/OUT2 0.42fF
C1505 pll_full_1/ro_complete_0/a1 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1506 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C1507 divbuf_15/IN divbuf_15/OUT5 0.00fF
C1508 divider_0/tspc_2/Q divider_0/nor_0/A 0.55fF
C1509 divider_0/nor_0/B divider_0/tspc_1/Z4 0.21fF
C1510 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/v 1.30fF
C1511 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C1512 divbuf_23/OUT divbuf_23/OUT2 0.06fF
C1513 divbuf_4/OUT3 divbuf_4/OUT 0.26fF
C1514 divbuf_4/OUT4 divbuf_4/OUT5 20.26fF
C1515 divider_0/and_0/A divider_0/and_0/B 0.18fF
C1516 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/R 0.33fF
C1517 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z2 0.36fF
C1518 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C1519 divider_2/nor_0/B divider_2/tspc_1/a_630_n680# 0.35fF
C1520 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_0/D 0.32fF
C1521 divider_2/prescaler_0/Out divider_2/tspc_2/Z2 0.11fF
C1522 divider_2/tspc_1/Z1 divider_2/tspc_1/Z2 1.07fF
C1523 divider_2/nor_0/A divider_2/and_0/A 0.01fF
C1524 divbuf_9/IN divbuf_9/OUT5 0.00fF
C1525 divbuf_20/OUT ro_complete_0/cbank_1/v 0.05fF
C1526 ro_complete_0/cbank_0/switch_4/vin divbuf_18/OUT 0.13fF
C1527 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.05fF
C1528 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/clk 0.64fF
C1529 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT2 0.06fF
C1530 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT3 0.01fF
C1531 divider_1/tspc_2/Q divider_1/nor_0/B 0.22fF
C1532 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Z4 0.65fF
C1533 divider_0/tspc_0/Z4 divider_0/tspc_0/Z2 0.36fF
C1534 divider_0/prescaler_0/tspc_2/D divider_0/prescaler_0/nand_0/z1 0.24fF
C1535 divbuf_1/OUT4 divbuf_1/OUT 1.11fF
C1536 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C1537 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C1538 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1539 pll_full_0/ro_complete_0/a5 pll_full_0/divider_0/clk 0.15fF
C1540 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z2 0.19fF
C1541 divbuf_22/OUT3 divbuf_22/OUT5 0.01fF
C1542 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/clk 0.26fF
C1543 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/Z3 0.65fF
C1544 divider_1/tspc_2/Z1 divider_1/tspc_2/Z3 0.06fF
C1545 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z4 0.14fF
C1546 pd_0/tspc_r_1/Z4 pd_0/tspc_r_1/z5 0.04fF
C1547 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z2 0.25fF
C1548 divider_2/prescaler_0/m1_2700_2190# divider_2/nor_0/A 0.01fF
C1549 pll_full_1/pd_0/DIV pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.03fF
C1550 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/a0 0.13fF
C1551 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z3 0.45fF
C1552 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1553 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1554 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/divider_0/clk 1.46fF
C1555 ro_complete_1/a2 ro_complete_1/cbank_1/v 0.05fF
C1556 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/a1 0.14fF
C1557 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/v 1.43fF
C1558 divbuf_15/OUT divbuf_15/OUT2 0.06fF
C1559 divider_0/tspc_2/Q divider_0/tspc_1/a_630_n680# 0.01fF
C1560 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1561 divider_0/prescaler_0/tspc_2/D divider_0/clk 0.26fF
C1562 pll_full_0/ro_complete_0/a1 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1563 divbuf_17/OUT divbuf_17/a_492_n240# 0.00fF
C1564 divbuf_16/OUT5 divbuf_16/IN 0.00fF
C1565 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/D 0.09fF
C1566 divbuf_21/a_492_n240# divbuf_21/OUT5 0.01fF
C1567 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/DOWN 0.03fF
C1568 divbuf_24/OUT2 divbuf_24/OUT5 0.02fF
C1569 divbuf_24/OUT3 divbuf_24/OUT4 5.16fF
C1570 pd_1/tspc_r_1/Qbar pd_1/tspc_r_1/Qbar1 0.01fF
C1571 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z4 0.02fF
C1572 divider_2/tspc_1/Z4 divider_2/nor_0/A 0.02fF
C1573 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C1574 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C1575 pll_full_0/pd_0/UP pll_full_0/pd_0/tspc_r_1/Qbar 0.21fF
C1576 divider_1/tspc_0/Z3 divider_1/Out 0.05fF
C1577 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z3 0.06fF
C1578 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1579 pll_full_1/ro_complete_0/cbank_0/v pll_full_1/divider_0/clk 1.27fF
C1580 divbuf_2/OUT4 divbuf_2/OUT5 20.26fF
C1581 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/switch_5/vin 0.20fF
C1582 pll_full_1/divider_0/tspc_2/Z2 pll_full_1/divider_0/tspc_2/Z4 0.36fF
C1583 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/a_492_n240# 0.01fF
C1584 divbuf_17/OUT3 divbuf_17/OUT2 1.37fF
C1585 divider_1/mc2 divider_1/nor_0/B 0.06fF
C1586 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z4 0.08fF
C1587 divbuf_10/OUT3 divbuf_10/OUT 0.26fF
C1588 divbuf_10/OUT4 divbuf_10/OUT5 20.26fF
C1589 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1590 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C1591 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/clk 0.64fF
C1592 pd_0/tspc_r_0/Z2 pd_0/tspc_r_0/Z4 0.14fF
C1593 divider_2/mc2 divider_2/prescaler_0/tspc_2/a_630_n680# 0.33fF
C1594 pll_full_0/pd_0/tspc_r_0/Qbar pll_full_0/pd_0/tspc_r_0/Qbar1 0.01fF
C1595 divider_2/nor_0/A divider_2/tspc_2/Z3 0.38fF
C1596 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z4 0.12fF
C1597 divider_2/tspc_2/Z1 divider_2/tspc_2/Z2 1.07fF
C1598 pll_full_1/ro_complete_0/cbank_2/switch_4/vin pll_full_1/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C1599 ro_complete_1/a2 ro_complete_1/cbank_0/switch_2/vin 0.14fF
C1600 divbuf_21/OUT ro_complete_0/cbank_2/switch_1/vin 0.09fF
C1601 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/v 1.30fF
C1602 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/a_630_n680# 0.01fF
C1603 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_0/Z1 0.06fF
C1604 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1605 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C1606 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/D 0.05fF
C1607 divider_0/prescaler_0/tspc_0/Z3 divider_0/clk 0.64fF
C1608 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/a0 0.13fF
C1609 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/Z4 0.65fF
C1610 divbuf_5/a_492_n240# divbuf_5/OUT 0.00fF
C1611 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z3 0.45fF
C1612 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1613 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1614 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/divider_0/clk 1.46fF
C1615 divbuf_8/OUT2 divbuf_8/OUT 0.06fF
C1616 divbuf_8/OUT3 divbuf_8/OUT5 0.01fF
C1617 pd_0/R pd_0/and_pd_0/Out1 0.33fF
C1618 pd_0/REF pd_0/tspc_r_1/Z4 0.02fF
C1619 pd_0/UP pd_0/tspc_r_1/Qbar 0.21fF
C1620 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C1621 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1622 divider_2/tspc_1/Z1 divider_2/tspc_1/Z4 0.00fF
C1623 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z2 0.01fF
C1624 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT3 0.26fF
C1625 divider_2/and_0/out1 divider_2/and_0/Z1 0.36fF
C1626 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/Out 0.21fF
C1627 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1628 divider_0/tspc_2/Q divider_0/tspc_1/Z3 0.45fF
C1629 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1630 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1631 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/clk 0.45fF
C1632 divbuf_2/a_492_n240# divbuf_2/OUT 0.00fF
C1633 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Q 0.05fF
C1634 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z4 0.00fF
C1635 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1636 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/divider_0/clk 1.27fF
C1637 divbuf_11/a_492_n240# divbuf_11/OUT5 0.01fF
C1638 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z4 0.36fF
C1639 cp_0/a_1710_0# cp_0/a_1710_n2840# 0.83fF
C1640 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1641 divider_2/tspc_0/a_630_n680# divider_2/tspc_0/Z3 0.05fF
C1642 divider_2/and_0/OUT divider_2/prescaler_0/nand_0/z1 0.01fF
C1643 divbuf_14/OUT2 divbuf_14/OUT5 0.02fF
C1644 divbuf_14/OUT3 divbuf_14/OUT4 5.16fF
C1645 divbuf_1/OUT2 divbuf_1/OUT3 1.37fF
C1646 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z2 0.21fF
C1647 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/nor_0/B 0.22fF
C1648 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/nor_1/B 0.38fF
C1649 divbuf_1/a_492_n240# divbuf_1/OUT5 0.01fF
C1650 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C1651 ro_complete_0/cbank_1/switch_5/vin ro_complete_0/cbank_1/v 1.30fF
C1652 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1653 divbuf_22/OUT divbuf_22/OUT2 0.06fF
C1654 divbuf_3/OUT5 divbuf_3/OUT 43.38fF
C1655 divider_1/mc2 divider_1/nor_1/B 0.15fF
C1656 divider_0/tspc_2/Z2 divider_0/tspc_2/Z4 0.36fF
C1657 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C1658 divider_2/nor_0/B divider_2/mc2 0.06fF
C1659 divider_1/tspc_1/Z2 divider_1/nor_0/A 0.15fF
C1660 divider_1/prescaler_0/Out divider_1/tspc_2/Z3 0.45fF
C1661 pll_full_1/pd_0/DIV pll_full_1/pd_0/R 0.51fF
C1662 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C1663 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/Z1 0.06fF
C1664 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1665 pd_0/tspc_r_0/Qbar1 pd_0/DOWN 0.11fF
C1666 pd_0/DIV pd_0/tspc_r_0/Z1 0.17fF
C1667 divider_2/Out divider_2/tspc_0/a_630_n680# 0.04fF
C1668 divbuf_7/OUT3 divbuf_7/OUT 0.26fF
C1669 divbuf_7/OUT4 divbuf_7/OUT5 20.26fF
C1670 cp_0/a_1710_0# cp_0/down 0.32fF
C1671 pd_1/tspc_r_0/z5 pd_1/tspc_r_1/z5 0.02fF
C1672 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Z1 0.02fF
C1673 pd_1/REF pd_1/tspc_r_1/Qbar1 0.12fF
C1674 divider_2/and_0/OUT divider_2/clk 0.04fF
C1675 divbuf_20/OUT divbuf_22/OUT 3.09fF
C1676 divbuf_21/OUT ro_complete_0/cbank_1/switch_1/vin 0.09fF
C1677 pll_full_0/pd_0/UP pll_full_0/pd_0/and_pd_0/Z1 0.06fF
C1678 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.13fF
C1679 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/and_0/OUT 0.14fF
C1680 divbuf_0/a_492_n240# divbuf_0/OUT5 0.01fF
C1681 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/v 1.30fF
C1682 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C1683 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1684 divbuf_15/IN divbuf_15/a_492_n240# 0.13fF
C1685 divider_0/mc2 divider_0/and_0/A 0.16fF
C1686 divider_0/prescaler_0/Out divider_0/tspc_2/a_630_n680# 0.01fF
C1687 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1688 divbuf_23/OUT divbuf_23/OUT4 1.11fF
C1689 divbuf_4/OUT5 divbuf_4/OUT 43.38fF
C1690 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/DOWN 0.07fF
C1691 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/Out 0.21fF
C1692 divider_1/tspc_0/Z1 divider_1/tspc_0/Z2 1.07fF
C1693 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z4 0.01fF
C1694 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/nand_1/z1 0.22fF
C1695 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/tspc_0/D 0.04fF
C1696 divbuf_6/a_492_n240# divbuf_6/OUT 0.00fF
C1697 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/R 0.01fF
C1698 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1699 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/clk 0.45fF
C1700 pd_0/R pd_0/tspc_r_1/Z2 0.21fF
C1701 divider_2/tspc_1/Z2 divider_2/tspc_1/Z3 0.16fF
C1702 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_0/D 0.09fF
C1703 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C1704 divbuf_9/OUT2 divbuf_9/OUT 0.06fF
C1705 divbuf_9/OUT3 divbuf_9/OUT5 0.01fF
C1706 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C1707 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/pd_0/REF 0.17fF
C1708 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT4 1.11fF
C1709 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.11fF
C1710 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/clk 0.12fF
C1711 divbuf_21/OUT divbuf_21/OUT3 0.26fF
C1712 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1713 divbuf_16/OUT2 divbuf_16/OUT5 0.02fF
C1714 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/Q 0.04fF
C1715 divider_0/prescaler_0/tspc_1/Z3 divider_0/clk 0.45fF
C1716 divbuf_20/a_492_n240# divbuf_20/IN 0.13fF
C1717 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/nor_0/B 0.22fF
C1718 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/nor_1/B 0.38fF
C1719 divider_1/mc2 divider_1/and_0/out1 0.06fF
C1720 divider_2/nor_0/B divider_2/tspc_2/a_630_n680# 0.01fF
C1721 divider_1/tspc_2/Z1 divider_1/tspc_2/Z4 0.00fF
C1722 pd_1/DOWN pd_1/tspc_r_1/Qbar 0.02fF
C1723 pd_0/UP pd_0/and_pd_0/Z1 0.06fF
C1724 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/D 0.15fF
C1725 divbuf_12/a_492_n240# divbuf_12/OUT5 0.01fF
C1726 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C1727 divbuf_18/OUT divbuf_18/OUT4 1.11fF
C1728 pll_full_1/pd_0/tspc_r_0/Z1 pll_full_1/pd_0/tspc_r_0/Z3 0.09fF
C1729 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_1/Qbar 0.02fF
C1730 divider_0/tspc_2/Q divider_0/nor_0/B 0.22fF
C1731 divider_0/nor_1/Z1 divider_0/nor_1/B 0.06fF
C1732 divbuf_23/OUT ro_complete_0/cbank_2/v 0.08fF
C1733 divbuf_18/OUT ro_complete_0/cbank_1/switch_5/vin 0.09fF
C1734 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_0/Z3 0.11fF
C1735 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/clk 0.45fF
C1736 divbuf_3/a_492_n240# divbuf_3/OUT2 0.42fF
C1737 pll_full_1/cp_0/upbar pll_full_1/cp_0/down 0.02fF
C1738 divider_1/tspc_2/Q divider_1/tspc_2/a_630_n680# 0.04fF
C1739 divbuf_15/OUT5 divbuf_15/OUT3 0.01fF
C1740 divbuf_21/OUT2 divbuf_21/OUT3 1.37fF
C1741 pll_full_1/pd_0/DIV pll_full_1/pd_0/tspc_r_0/Z2 0.19fF
C1742 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C1743 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/and_0/OUT 0.14fF
C1744 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z2 0.01fF
C1745 pd_1/tspc_r_1/Z2 pd_1/tspc_r_1/Z4 0.14fF
C1746 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/z5 0.04fF
C1747 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/z5 0.11fF
C1748 divider_2/tspc_1/Q divider_2/tspc_0/Z3 0.45fF
C1749 divbuf_24/OUT3 divbuf_24/OUT 0.26fF
C1750 divbuf_24/OUT4 divbuf_24/OUT5 20.26fF
C1751 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_2/v 0.08fF
C1752 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C1753 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/cbank_1/switch_1/vin 0.19fF
C1754 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1755 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1756 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/z5 0.11fF
C1757 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_1/Q 0.13fF
C1758 divider_0/prescaler_0/m1_2700_2190# divider_0/and_0/OUT 0.14fF
C1759 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/v 1.30fF
C1760 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C1761 divbuf_4/a_492_n240# divbuf_4/OUT5 0.01fF
C1762 divider_1/nor_0/Z1 divider_1/and_0/B 0.18fF
C1763 divbuf_10/OUT5 divbuf_10/OUT 43.38fF
C1764 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C1765 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/clk 0.12fF
C1766 divider_2/nor_0/B divider_2/nor_1/B 0.47fF
C1767 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z3 0.06fF
C1768 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/D 0.11fF
C1769 pd_1/UP pd_1/and_pd_0/Out1 0.33fF
C1770 divider_2/nor_0/A divider_2/tspc_2/Z4 0.21fF
C1771 divider_2/tspc_2/Z2 divider_2/tspc_2/Z3 0.16fF
C1772 pll_full_1/ro_complete_0/cbank_2/switch_4/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C1773 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/nor_0/A 0.15fF
C1774 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1775 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1776 divider_0/prescaler_0/tspc_2/Z4 divider_0/prescaler_0/tspc_2/D 0.11fF
C1777 divider_0/prescaler_0/tspc_0/Z4 divider_0/clk 0.12fF
C1778 divbuf_2/OUT3 divbuf_2/OUT 0.26fF
C1779 ro_complete_1/a4 ro_complete_1/cbank_2/v 0.05fF
C1780 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/a0 0.09fF
C1781 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C1782 pll_full_1/divider_0/and_0/B pll_full_1/divider_0/and_0/Z1 0.07fF
C1783 divbuf_5/IN divbuf_5/OUT5 0.00fF
C1784 divbuf_22/a_492_n240# divbuf_22/IN 0.13fF
C1785 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/clk 0.45fF
C1786 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/z5 0.11fF
C1787 divider_2/tspc_1/Z3 divider_2/tspc_1/Z4 0.65fF
C1788 divbuf_8/OUT4 divbuf_8/OUT 1.11fF
C1789 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT4 1.11fF
C1790 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/z5 0.03fF
C1791 divider_2/and_0/A divider_2/and_0/B 0.18fF
C1792 divbuf_25/a_492_n240# divbuf_25/OUT5 0.01fF
C1793 divbuf_17/OUT5 divbuf_17/OUT3 0.01fF
C1794 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/cbank_0/v 1.30fF
C1795 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 pll_full_1/divider_0/clk 0.12fF
C1796 divider_0/prescaler_0/tspc_2/Z3 divider_0/clk 0.45fF
C1797 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/v 0.08fF
C1798 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C1799 io_clamp_low[2] io_clamp_high[2] 0.53fF
C1800 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1801 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z4 0.12fF
C1802 divider_1/tspc_1/Z1 divider_1/tspc_1/Z4 0.00fF
C1803 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Z4 0.65fF
C1804 divbuf_11/OUT2 divbuf_11/OUT3 1.37fF
C1805 divider_2/nor_0/B divider_2/tspc_0/Z2 0.20fF
C1806 pd_1/tspc_r_1/Qbar pd_1/R 0.03fF
C1807 io_clamp_high[1] io_analog[5] 0.53fF
C1808 divider_2/prescaler_0/tspc_2/D divider_2/prescaler_0/nand_0/z1 0.24fF
C1809 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Z1 0.07fF
C1810 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z3 0.65fF
C1811 divbuf_14/OUT3 divbuf_14/OUT 0.26fF
C1812 divbuf_14/OUT4 divbuf_14/OUT5 20.26fF
C1813 divbuf_17/OUT5 divbuf_17/OUT4 20.26fF
C1814 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/a_740_n680# 0.19fF
C1815 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1816 ro_complete_0/cbank_0/v ro_complete_0/cbank_2/v 0.04fF
C1817 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/nor_0/A 0.35fF
C1818 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/clk 0.60fF
C1819 pll_full_0/divbuf_0/OUT2 pll_full_0/divbuf_0/OUT3 1.37fF
C1820 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1821 divbuf_16/a_492_n240# divbuf_16/IN 0.13fF
C1822 divbuf_22/OUT divbuf_22/OUT4 1.11fF
C1823 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1824 divbuf_10/a_492_n240# divbuf_10/OUT2 0.42fF
C1825 pll_full_1/pd_0/DOWN pll_full_1/pd_0/and_pd_0/Out1 0.12fF
C1826 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/nor_0/A 0.15fF
C1827 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1828 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1829 divider_1/prescaler_0/m1_2700_2190# divider_1/nor_0/A 0.01fF
C1830 divider_1/prescaler_0/Out divider_1/tspc_2/Z4 0.12fF
C1831 divbuf_7/OUT5 divbuf_7/OUT 43.38fF
C1832 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z2 0.25fF
C1833 pll_full_1/pd_0/tspc_r_1/Z4 pll_full_1/pd_0/tspc_r_1/z5 0.04fF
C1834 pll_full_0/divider_0/and_0/B pll_full_0/divider_0/and_0/Z1 0.07fF
C1835 pd_1/tspc_r_1/Z3 pd_1/UP 0.03fF
C1836 divider_2/prescaler_0/tspc_2/D divider_2/clk 0.26fF
C1837 divbuf_13/a_492_n240# divbuf_13/OUT 0.00fF
C1838 pll_full_1/ro_complete_0/cbank_0/v pll_full_1/ro_complete_0/cbank_2/v 0.04fF
C1839 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1840 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1841 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_2/D 0.16fF
C1842 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.03fF
C1843 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z3 0.05fF
C1844 divider_0/prescaler_0/Out divider_0/nor_0/A 0.15fF
C1845 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1846 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Q 0.21fF
C1847 divbuf_20/OUT divbuf_20/a_492_n240# 0.00fF
C1848 divbuf_19/OUT4 divbuf_19/OUT5 20.26fF
C1849 divider_0/and_0/B divider_0/and_0/Z1 0.07fF
C1850 divbuf_6/IN divbuf_6/OUT5 0.00fF
C1851 pll_full_1/pd_0/UP pll_full_1/pd_0/R 0.46fF
C1852 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/clk 0.12fF
C1853 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/nand_1/z1 0.01fF
C1854 divbuf_19/OUT divbuf_19/OUT5 43.38fF
C1855 divbuf_8/a_492_n240# divbuf_8/IN 0.13fF
C1856 pd_1/DIV pd_1/tspc_r_0/Z3 0.65fF
C1857 pd_0/REF pd_0/tspc_r_1/Z3 0.65fF
C1858 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1859 divider_2/nor_1/B divider_2/tspc_1/a_630_n680# 0.00fF
C1860 divbuf_9/OUT4 divbuf_9/OUT 1.11fF
C1861 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_0/a_630_n680# 0.05fF
C1862 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z3 0.33fF
C1863 divbuf_21/OUT divbuf_21/OUT5 43.38fF
C1864 divbuf_0/IN divbuf_0/OUT5 0.00fF
C1865 ro_complete_1/a0 ro_complete_1/cbank_2/switch_4/vin 0.13fF
C1866 ro_complete_1/cbank_0/v ro_complete_1/cbank_1/v 1.27fF
C1867 divider_1/nor_1/Z1 divider_1/nor_0/B 0.18fF
C1868 divider_1/prescaler_0/tspc_2/Z2 divider_1/and_0/OUT 0.05fF
C1869 divider_0/prescaler_0/tspc_1/Z4 divider_0/clk 0.12fF
C1870 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_0/Z2 0.14fF
C1871 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Z4 0.02fF
C1872 pll_full_1/pd_0/UP pll_full_1/pd_0/tspc_r_1/Qbar1 0.11fF
C1873 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/nor_0/A 0.35fF
C1874 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/clk 0.60fF
C1875 divider_2/nor_0/B divider_2/nor_0/A 1.21fF
C1876 divider_1/tspc_2/Z3 divider_1/tspc_2/Z4 0.65fF
C1877 divbuf_12/OUT2 divbuf_12/OUT3 1.37fF
C1878 divider_2/mc2 divider_2/and_0/out1 0.06fF
C1879 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/D 0.05fF
C1880 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_492_n240# 0.00fF
C1881 divbuf_18/OUT ro_complete_0/cbank_1/v 0.05fF
C1882 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_0/Z1 0.03fF
C1883 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 pll_full_1/divider_0/clk 0.12fF
C1884 divider_1/tspc_2/Q divider_1/nor_0/A 0.55fF
C1885 divider_0/tspc_2/a_630_n680# divider_0/nor_0/A 0.35fF
C1886 divider_0/prescaler_0/tspc_1/Q divider_0/clk 0.60fF
C1887 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/ro_complete_0/cbank_2/v 0.04fF
C1888 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z4 0.12fF
C1889 divbuf_21/OUT2 divbuf_21/OUT5 0.02fF
C1890 divbuf_21/OUT3 divbuf_21/OUT4 5.16fF
C1891 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1892 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C1893 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C1894 divbuf_7/a_492_n240# divbuf_7/OUT2 0.42fF
C1895 divbuf_24/OUT5 divbuf_24/OUT 43.38fF
C1896 cp_0/a_1710_n2840# cp_0/upbar 0.29fF
C1897 pd_1/R pd_1/REF 0.61fF
C1898 pll_full_0/pd_0/UP pll_full_0/pd_0/tspc_r_1/z5 0.03fF
C1899 divbuf_19/OUT divbuf_19/OUT2 0.06fF
C1900 ro_complete_1/a3 ro_complete_1/cbank_1/switch_2/vin 0.09fF
C1901 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/cbank_0/v 1.30fF
C1902 ro_complete_0/cbank_2/switch_0/vin ro_complete_0/cbank_2/v 1.45fF
C1903 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1904 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_1/Q 0.21fF
C1905 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_2/D 0.16fF
C1906 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/D 0.03fF
C1907 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/a_630_n680# 0.05fF
C1908 divider_2/nor_0/B divider_2/tspc_1/Z1 0.03fF
C1909 divbuf_23/IN divbuf_23/OUT5 0.00fF
C1910 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z4 0.00fF
C1911 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/clk 0.14fF
C1912 divbuf_9/a_492_n240# divbuf_9/IN 0.13fF
C1913 cp_0/upbar cp_0/down 0.02fF
C1914 pll_full_1/ro_complete_0/cbank_2/switch_0/vin pll_full_1/ro_complete_0/cbank_2/v 1.45fF
C1915 divider_2/tspc_2/Z2 divider_2/tspc_2/Z4 0.36fF
C1916 divbuf_21/OUT ro_complete_0/cbank_1/switch_0/vin 0.12fF
C1917 divbuf_20/OUT ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1918 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/v 1.30fF
C1919 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/Z2 0.11fF
C1920 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1921 pll_full_1/ro_complete_0/cbank_2/v pll_full_1/divider_0/clk 1.36fF
C1922 divbuf_2/OUT5 divbuf_2/OUT 43.38fF
C1923 ro_complete_1/a3 ro_complete_1/cbank_1/v 0.05fF
C1924 divider_1/nor_1/Z1 divider_1/nor_1/B 0.06fF
C1925 divbuf_5/OUT2 divbuf_5/OUT 0.06fF
C1926 divbuf_5/OUT3 divbuf_5/OUT5 0.01fF
C1927 divider_1/mc2 divider_1/nor_0/A 0.04fF
C1928 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/R 0.21fF
C1929 divider_1/and_0/OUT divider_1/and_0/B 0.01fF
C1930 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/tspc_r_0/Qbar 0.01fF
C1931 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_0/Z1 0.03fF
C1932 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/clk 0.12fF
C1933 pd_0/UP pd_0/tspc_r_1/z5 0.03fF
C1934 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1935 pll_full_1/ro_complete_0/cbank_0/switch_2/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1936 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z3 0.06fF
C1937 divbuf_25/OUT2 divbuf_25/OUT3 1.37fF
C1938 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_1/Q 0.45fF
C1939 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C1940 ro_complete_1/a2 ro_complete_1/cbank_2/switch_2/vin 0.14fF
C1941 divbuf_22/OUT ro_complete_0/cbank_1/v 0.05fF
C1942 divbuf_16/OUT2 divbuf_16/a_492_n240# 0.42fF
C1943 divider_0/mc2 divider_0/prescaler_0/tspc_2/a_630_n680# 0.33fF
C1944 divider_0/nor_1/Z1 divider_0/nor_0/B 0.18fF
C1945 ro_complete_1/cbank_2/switch_0/vin ro_complete_1/cbank_2/v 1.45fF
C1946 divider_0/nor_1/B divider_0/tspc_0/Z1 0.03fF
C1947 divider_0/prescaler_0/tspc_2/Z4 divider_0/clk 0.12fF
C1948 divider_1/tspc_1/Z3 divider_1/tspc_1/Z4 0.65fF
C1949 divbuf_19/OUT5 divbuf_19/a_492_n240# 0.01fF
C1950 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z1 0.08fF
C1951 divbuf_11/OUT2 divbuf_11/OUT5 0.02fF
C1952 divbuf_11/OUT3 divbuf_11/OUT4 5.16fF
C1953 divbuf_24/a_492_n240# divbuf_24/OUT2 0.42fF
C1954 io_clamp_low[0] io_analog[4] 0.53fF
C1955 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/Q 0.04fF
C1956 divider_2/prescaler_0/tspc_1/Z3 divider_2/clk 0.45fF
C1957 divbuf_14/OUT5 divbuf_14/OUT 43.38fF
C1958 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C1959 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/and_0/A 0.80fF
C1960 pll_full_1/ro_complete_0/cbank_1/switch_2/vin pll_full_1/divider_0/clk 1.46fF
C1961 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Qbar1 0.38fF
C1962 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/a3 0.09fF
C1963 divbuf_15/OUT divbuf_15/OUT5 43.38fF
C1964 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/Z1 0.04fF
C1965 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z2 0.01fF
C1966 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/clk 0.05fF
C1967 pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_0/ro_complete_0/cbank_2/v 1.45fF
C1968 divider_2/nor_0/B divider_2/tspc_0/Z4 0.02fF
C1969 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_0/Qbar1 0.11fF
C1970 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z2 0.11fF
C1971 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1972 pll_full_0/ro_complete_0/cbank_2/v pll_full_0/divider_0/clk 1.36fF
C1973 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/Qbar 0.01fF
C1974 pd_0/tspc_r_0/Z3 pd_0/R 0.27fF
C1975 divider_2/mc2 divider_2/nor_1/B 0.15fF
C1976 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z4 0.20fF
C1977 pd_1/REF pd_1/tspc_r_1/z5 0.04fF
C1978 divbuf_13/IN divbuf_13/OUT5 0.00fF
C1979 divbuf_20/OUT divbuf_19/OUT 3.23fF
C1980 filter_0/v divbuf_0/a_492_n240# 0.00fF
C1981 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/a4 0.09fF
C1982 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/nor_1/B 0.00fF
C1983 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/nand_0/z1 0.07fF
C1984 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.05fF
C1985 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT 43.38fF
C1986 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C1987 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z4 0.12fF
C1988 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z2 1.07fF
C1989 divider_0/prescaler_0/Out divider_0/tspc_2/Z2 0.11fF
C1990 divider_0/tspc_0/Z3 divider_0/tspc_0/Z2 0.16fF
C1991 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1992 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/clk 0.14fF
C1993 divider_0/nor_1/Z1 divider_0/and_0/B 0.78fF
C1994 divbuf_2/IN divbuf_2/a_492_n240# 0.13fF
C1995 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/v 1.30fF
C1996 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1997 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1998 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/B 0.18fF
C1999 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_1/Q 0.45fF
C2000 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C2001 divbuf_6/OUT2 divbuf_6/OUT 0.06fF
C2002 divbuf_6/OUT3 divbuf_6/OUT5 0.01fF
C2003 divider_1/prescaler_0/tspc_0/D divider_1/prescaler_0/nand_1/z1 0.21fF
C2004 divider_1/nor_0/B divider_1/and_0/A 0.26fF
C2005 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Qbar1 0.38fF
C2006 divider_2/tspc_1/Z2 divider_2/tspc_2/Q 0.14fF
C2007 divider_2/prescaler_0/m1_2700_2190# divider_2/and_0/OUT 0.14fF
C2008 pll_full_1/ro_complete_0/cbank_2/switch_5/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C2009 divbuf_19/a_492_n240# divbuf_19/OUT2 0.42fF
C2010 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z4 0.08fF
C2011 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z3 0.05fF
C2012 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_2/a_630_n680# 0.01fF
C2013 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.05fF
C2014 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/clk 0.01fF
C2015 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/a_492_n240# 0.00fF
C2016 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/D 0.09fF
C2017 divbuf_20/a_492_n240# divbuf_20/OUT5 0.01fF
C2018 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C2019 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/A 0.80fF
C2020 pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_0/divider_0/clk 1.46fF
C2021 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z3 0.33fF
C2022 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z4 0.01fF
C2023 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/Z1 0.04fF
C2024 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z2 0.01fF
C2025 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/clk 0.05fF
C2026 pd_1/tspc_r_1/Z1 pd_1/tspc_r_1/Z2 0.71fF
C2027 pd_1/DOWN pd_1/tspc_r_0/Qbar1 0.11fF
C2028 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Z1 0.02fF
C2029 divbuf_18/OUT5 divbuf_18/OUT4 20.26fF
C2030 divider_2/prescaler_0/tspc_2/Z4 divider_2/prescaler_0/tspc_2/D 0.11fF
C2031 divbuf_12/OUT2 divbuf_12/OUT5 0.02fF
C2032 divbuf_12/OUT3 divbuf_12/OUT4 5.16fF
C2033 pll_full_1/divbuf_0/a_492_n240# pll_full_1/divbuf_0/OUT2 0.42fF
C2034 divbuf_14/a_492_n240# divbuf_14/OUT2 0.42fF
C2035 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z3 0.06fF
C2036 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/Z1 0.09fF
C2037 divider_0/Out divider_0/nor_1/B 0.22fF
C2038 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z3 0.33fF
Xpd_0 vdda1 vssa1 pd_0/REF pd_0/DIV pd_0/UP pd_0/DOWN pd_0/R pd
Xpd_1 vdda1 vssa1 pd_1/REF pd_1/DIV pd_1/UP pd_1/DOWN pd_1/R pd
Xcp_0 cp_0/vbias vdda1 gnd cp_0/out cp_0/down cp_0/upbar cp
Xfilter_0 vssa1 filter_0/v filter
Xro_complete_0 divbuf_18/OUT divbuf_19/OUT divbuf_23/OUT divbuf_21/OUT divbuf_22/OUT
+ divbuf_20/OUT ro_complete
Xro_complete_1 ro_complete_1/a0 ro_complete_1/a1 ro_complete_1/a5 ro_complete_1/a4
+ ro_complete_1/a3 ro_complete_1/a2 ro_complete
Xdivbuf_0 vdda1 divbuf_0/IN filter_0/v divbuf_0/OUT2 divbuf_0/OUT3 divbuf_0/OUT4 divbuf_0/OUT5
+ vssa1 divbuf
Xdivbuf_1 vdda1 divbuf_1/IN divbuf_1/OUT divbuf_1/OUT2 divbuf_1/OUT3 divbuf_1/OUT4
+ divbuf_1/OUT5 vssa1 divbuf
Xdivbuf_2 vdda1 divbuf_2/IN divbuf_2/OUT divbuf_2/OUT2 divbuf_2/OUT3 divbuf_2/OUT4
+ divbuf_2/OUT5 vssa1 divbuf
Xdivbuf_3 vdda1 divbuf_3/IN divbuf_3/OUT divbuf_3/OUT2 divbuf_3/OUT3 divbuf_3/OUT4
+ divbuf_3/OUT5 vssa1 divbuf
Xdivbuf_4 vdda1 divbuf_4/IN divbuf_4/OUT divbuf_4/OUT2 divbuf_4/OUT3 divbuf_4/OUT4
+ divbuf_4/OUT5 vssa1 divbuf
Xdivbuf_5 vdda1 divbuf_5/IN divbuf_5/OUT divbuf_5/OUT2 divbuf_5/OUT3 divbuf_5/OUT4
+ divbuf_5/OUT5 vssa1 divbuf
Xdivbuf_20 vdda1 divbuf_20/IN divbuf_20/OUT divbuf_20/OUT2 divbuf_20/OUT3 divbuf_20/OUT4
+ divbuf_20/OUT5 gnd divbuf
Xdivbuf_21 vdda1 divbuf_21/IN divbuf_21/OUT divbuf_21/OUT2 divbuf_21/OUT3 divbuf_21/OUT4
+ divbuf_21/OUT5 gnd divbuf
Xdivbuf_10 vdda1 divbuf_10/IN divbuf_10/OUT divbuf_10/OUT2 divbuf_10/OUT3 divbuf_10/OUT4
+ divbuf_10/OUT5 gnd divbuf
Xdivbuf_6 vdda1 divbuf_6/IN divbuf_6/OUT divbuf_6/OUT2 divbuf_6/OUT3 divbuf_6/OUT4
+ divbuf_6/OUT5 vssa1 divbuf
Xdivbuf_22 vdda1 divbuf_22/IN divbuf_22/OUT divbuf_22/OUT2 divbuf_22/OUT3 divbuf_22/OUT4
+ divbuf_22/OUT5 gnd divbuf
Xdivbuf_11 vdda1 divbuf_11/IN divbuf_11/OUT divbuf_11/OUT2 divbuf_11/OUT3 divbuf_11/OUT4
+ divbuf_11/OUT5 gnd divbuf
Xdivbuf_7 vdda1 divbuf_7/IN divbuf_7/OUT divbuf_7/OUT2 divbuf_7/OUT3 divbuf_7/OUT4
+ divbuf_7/OUT5 vssa1 divbuf
Xdivbuf_23 vdda1 divbuf_23/IN divbuf_23/OUT divbuf_23/OUT2 divbuf_23/OUT3 divbuf_23/OUT4
+ divbuf_23/OUT5 gnd divbuf
Xdivbuf_8 vdda1 divbuf_8/IN divbuf_8/OUT divbuf_8/OUT2 divbuf_8/OUT3 divbuf_8/OUT4
+ divbuf_8/OUT5 vssa1 divbuf
Xdivbuf_12 vdda1 divbuf_12/IN divbuf_12/OUT divbuf_12/OUT2 divbuf_12/OUT3 divbuf_12/OUT4
+ divbuf_12/OUT5 gnd divbuf
Xdivbuf_24 vdda1 divbuf_24/IN divbuf_24/OUT divbuf_24/OUT2 divbuf_24/OUT3 divbuf_24/OUT4
+ divbuf_24/OUT5 gnd divbuf
Xdivbuf_13 vdda1 divbuf_13/IN divbuf_13/OUT divbuf_13/OUT2 divbuf_13/OUT3 divbuf_13/OUT4
+ divbuf_13/OUT5 gnd divbuf
Xdivbuf_9 vdda1 divbuf_9/IN divbuf_9/OUT divbuf_9/OUT2 divbuf_9/OUT3 divbuf_9/OUT4
+ divbuf_9/OUT5 vssa1 divbuf
Xdivbuf_25 vdda1 divbuf_25/IN divbuf_25/OUT divbuf_25/OUT2 divbuf_25/OUT3 divbuf_25/OUT4
+ divbuf_25/OUT5 gnd divbuf
Xdivbuf_14 vdda1 divbuf_14/IN divbuf_14/OUT divbuf_14/OUT2 divbuf_14/OUT3 divbuf_14/OUT4
+ divbuf_14/OUT5 gnd divbuf
Xdivider_0 gnd vdd divider_0/Out divider_0/clk divider_0/mc2 divider
Xdivbuf_15 vdda1 divbuf_15/IN divbuf_15/OUT divbuf_15/OUT2 divbuf_15/OUT3 divbuf_15/OUT4
+ divbuf_15/OUT5 gnd divbuf
Xdivider_1 vssa1 vdda1 divider_1/Out divider_1/clk divider_1/mc2 divider
Xdivbuf_16 vdda1 divbuf_16/IN divbuf_16/OUT divbuf_16/OUT2 divbuf_16/OUT3 divbuf_16/OUT4
+ divbuf_16/OUT5 gnd divbuf
Xdivider_2 vssa1 vdda1 divider_2/Out divider_2/clk divider_2/mc2 divider
Xdivbuf_17 vdda1 divbuf_17/IN divbuf_17/OUT divbuf_17/OUT2 divbuf_17/OUT3 divbuf_17/OUT4
+ divbuf_17/OUT5 gnd divbuf
Xdivbuf_18 vdda1 divbuf_18/IN divbuf_18/OUT divbuf_18/OUT2 divbuf_18/OUT3 divbuf_18/OUT4
+ divbuf_18/OUT5 gnd divbuf
Xdivbuf_19 vdda1 divbuf_19/IN divbuf_19/OUT divbuf_19/OUT2 divbuf_19/OUT3 divbuf_19/OUT4
+ divbuf_19/OUT5 gnd divbuf
Xpll_full_0 vdda1 pll_full
Xpll_full_1 vdda1 pll_full
C2039 io_analog[4] vssa1 43.96fF
C2040 io_analog[5] vssa1 44.13fF
C2041 io_analog[6] vssa1 43.46fF
C2042 io_in_3v3[0] vssa1 0.61fF
C2043 io_oeb[26] vssa1 0.61fF
C2044 io_in[0] vssa1 0.61fF
C2045 io_out[26] vssa1 0.61fF
C2046 io_out[0] vssa1 0.61fF
C2047 io_in[26] vssa1 0.61fF
C2048 io_oeb[0] vssa1 0.61fF
C2049 io_in_3v3[26] vssa1 0.61fF
C2050 io_in_3v3[1] vssa1 0.61fF
C2051 io_oeb[25] vssa1 0.61fF
C2052 io_in[1] vssa1 0.61fF
C2053 io_out[25] vssa1 0.61fF
C2054 io_out[1] vssa1 0.61fF
C2055 io_in[25] vssa1 0.61fF
C2056 io_oeb[1] vssa1 0.61fF
C2057 io_in_3v3[25] vssa1 0.61fF
C2058 io_in_3v3[2] vssa1 0.61fF
C2059 io_oeb[24] vssa1 0.61fF
C2060 io_in[2] vssa1 0.61fF
C2061 io_out[24] vssa1 0.61fF
C2062 io_out[2] vssa1 0.61fF
C2063 io_in[24] vssa1 0.61fF
C2064 io_oeb[2] vssa1 0.61fF
C2065 io_in_3v3[24] vssa1 0.61fF
C2066 io_in_3v3[3] vssa1 0.61fF
C2067 gpio_noesd[17] vssa1 2.32fF
C2068 io_in[3] vssa1 0.61fF
C2069 gpio_analog[17] vssa1 2.30fF
C2070 io_out[3] vssa1 0.61fF
C2071 io_oeb[3] vssa1 0.61fF
C2072 io_in_3v3[4] vssa1 0.61fF
C2073 io_in[4] vssa1 0.61fF
C2074 io_out[4] vssa1 0.61fF
C2075 io_oeb[4] vssa1 0.61fF
C2076 io_oeb[23] vssa1 0.61fF
C2077 io_out[23] vssa1 0.61fF
C2078 io_in[23] vssa1 0.61fF
C2079 io_in_3v3[23] vssa1 0.61fF
C2080 gpio_noesd[16] vssa1 2.30fF
C2081 gpio_analog[16] vssa1 2.30fF
C2082 io_in_3v3[5] vssa1 0.61fF
C2083 io_in[5] vssa1 0.61fF
C2084 io_out[5] vssa1 0.61fF
C2085 io_oeb[5] vssa1 0.61fF
C2086 io_oeb[22] vssa1 0.61fF
C2087 io_out[22] vssa1 0.61fF
C2088 io_in[22] vssa1 0.61fF
C2089 io_in_3v3[22] vssa1 0.61fF
C2090 gpio_noesd[15] vssa1 2.31fF
C2091 gpio_analog[15] vssa1 2.30fF
C2092 io_in_3v3[6] vssa1 0.61fF
C2093 io_in[6] vssa1 0.61fF
C2094 io_out[6] vssa1 0.61fF
C2095 io_oeb[6] vssa1 0.61fF
C2096 io_oeb[21] vssa1 0.61fF
C2097 io_out[21] vssa1 0.61fF
C2098 io_in[21] vssa1 0.61fF
C2099 io_in_3v3[21] vssa1 0.61fF
C2100 gpio_noesd[14] vssa1 2.30fF
C2101 gpio_analog[14] vssa1 2.29fF
C2102 vssd2 vssa1 38.54fF
C2103 vssd1 vssa1 13.04fF
C2104 vdda2 vssa1 38.30fF
C2105 io_oeb[20] vssa1 0.61fF
C2106 io_out[20] vssa1 0.61fF
C2107 io_in[20] vssa1 0.61fF
C2108 io_in_3v3[20] vssa1 0.61fF
C2109 gpio_noesd[13] vssa1 2.31fF
C2110 gpio_analog[13] vssa1 2.30fF
C2111 gpio_analog[0] vssa1 0.61fF
C2112 gpio_noesd[0] vssa1 0.61fF
C2113 io_in_3v3[7] vssa1 0.61fF
C2114 io_in[7] vssa1 0.61fF
C2115 io_out[7] vssa1 0.61fF
C2116 io_oeb[7] vssa1 0.61fF
C2117 io_oeb[19] vssa1 0.61fF
C2118 io_out[19] vssa1 0.61fF
C2119 io_in[19] vssa1 0.61fF
C2120 io_in_3v3[19] vssa1 0.61fF
C2121 gpio_noesd[12] vssa1 2.32fF
C2122 gpio_analog[12] vssa1 2.30fF
C2123 gpio_analog[1] vssa1 0.61fF
C2124 gpio_noesd[1] vssa1 0.61fF
C2125 io_in_3v3[8] vssa1 0.61fF
C2126 io_in[8] vssa1 0.61fF
C2127 io_out[8] vssa1 0.61fF
C2128 io_oeb[8] vssa1 0.61fF
C2129 io_oeb[18] vssa1 0.61fF
C2130 io_out[18] vssa1 0.61fF
C2131 io_in[18] vssa1 0.61fF
C2132 io_in_3v3[18] vssa1 0.61fF
C2133 gpio_noesd[11] vssa1 2.30fF
C2134 gpio_analog[11] vssa1 2.29fF
C2135 gpio_analog[2] vssa1 0.61fF
C2136 gpio_noesd[2] vssa1 0.61fF
C2137 io_in_3v3[9] vssa1 0.61fF
C2138 io_in[9] vssa1 0.61fF
C2139 io_out[9] vssa1 0.61fF
C2140 io_oeb[9] vssa1 0.61fF
C2141 io_oeb[17] vssa1 0.61fF
C2142 io_out[17] vssa1 0.61fF
C2143 io_in[17] vssa1 0.61fF
C2144 io_in_3v3[17] vssa1 0.61fF
C2145 gpio_noesd[10] vssa1 2.31fF
C2146 gpio_analog[10] vssa1 2.29fF
C2147 gpio_analog[3] vssa1 0.61fF
C2148 gpio_noesd[3] vssa1 0.61fF
C2149 io_in_3v3[10] vssa1 0.61fF
C2150 io_in[10] vssa1 0.61fF
C2151 io_out[10] vssa1 0.61fF
C2152 io_oeb[10] vssa1 0.61fF
C2153 io_oeb[16] vssa1 0.61fF
C2154 io_out[16] vssa1 0.61fF
C2155 io_in[16] vssa1 0.61fF
C2156 io_in_3v3[16] vssa1 0.61fF
C2157 gpio_noesd[9] vssa1 2.28fF
C2158 gpio_analog[9] vssa1 2.28fF
C2159 gpio_analog[4] vssa1 0.61fF
C2160 gpio_noesd[4] vssa1 0.61fF
C2161 io_in_3v3[11] vssa1 0.61fF
C2162 io_in[11] vssa1 0.61fF
C2163 io_out[11] vssa1 0.61fF
C2164 io_oeb[11] vssa1 0.61fF
C2165 io_oeb[15] vssa1 0.61fF
C2166 io_out[15] vssa1 0.61fF
C2167 io_in[15] vssa1 0.61fF
C2168 io_in_3v3[15] vssa1 0.61fF
C2169 gpio_noesd[8] vssa1 2.28fF
C2170 gpio_analog[8] vssa1 2.26fF
C2171 gpio_analog[5] vssa1 0.61fF
C2172 gpio_noesd[5] vssa1 0.61fF
C2173 io_in_3v3[12] vssa1 0.61fF
C2174 io_in[12] vssa1 0.61fF
C2175 io_out[12] vssa1 0.61fF
C2176 io_oeb[12] vssa1 0.61fF
C2177 io_oeb[14] vssa1 0.61fF
C2178 io_out[14] vssa1 0.61fF
C2179 io_in[14] vssa1 0.61fF
C2180 io_in_3v3[14] vssa1 0.61fF
C2181 gpio_noesd[7] vssa1 2.30fF
C2182 gpio_analog[7] vssa1 2.28fF
C2183 vssa2 vssa1 38.35fF
C2184 gpio_analog[6] vssa1 5.71fF
C2185 gpio_noesd[6] vssa1 5.70fF
C2186 io_in_3v3[13] vssa1 0.61fF
C2187 io_in[13] vssa1 0.61fF
C2188 io_out[13] vssa1 0.61fF
C2189 io_oeb[13] vssa1 0.61fF
C2190 vccd1 vssa1 39.84fF
C2191 vccd2 vssa1 38.46fF
C2192 io_analog[0] vssa1 19.99fF
C2193 io_analog[10] vssa1 19.36fF
C2194 io_analog[1] vssa1 13.17fF
C2195 io_analog[2] vssa1 12.57fF
C2196 io_analog[3] vssa1 12.83fF
C2197 io_clamp_high[0] vssa1 3.58fF
C2198 io_clamp_low[0] vssa1 3.58fF
C2199 io_clamp_high[1] vssa1 3.58fF
C2200 io_clamp_low[1] vssa1 3.58fF
C2201 io_clamp_high[2] vssa1 3.58fF
C2202 io_clamp_low[2] vssa1 3.58fF
C2203 io_analog[7] vssa1 12.74fF
C2204 io_analog[8] vssa1 13.08fF
C2205 io_analog[9] vssa1 13.08fF
C2206 user_irq[2] vssa1 0.63fF
C2207 user_irq[1] vssa1 0.63fF
C2208 user_irq[0] vssa1 0.63fF
C2209 user_clock2 vssa1 0.63fF
C2210 la_oenb[127] vssa1 0.63fF
C2211 la_data_out[127] vssa1 0.63fF
C2212 la_data_in[127] vssa1 0.63fF
C2213 la_oenb[126] vssa1 0.63fF
C2214 la_data_out[126] vssa1 0.63fF
C2215 la_data_in[126] vssa1 0.63fF
C2216 la_oenb[125] vssa1 0.63fF
C2217 la_data_out[125] vssa1 0.63fF
C2218 la_data_in[125] vssa1 0.63fF
C2219 la_oenb[124] vssa1 0.63fF
C2220 la_data_out[124] vssa1 0.63fF
C2221 la_data_in[124] vssa1 0.63fF
C2222 la_oenb[123] vssa1 0.63fF
C2223 la_data_out[123] vssa1 0.63fF
C2224 la_data_in[123] vssa1 0.63fF
C2225 la_oenb[122] vssa1 0.63fF
C2226 la_data_out[122] vssa1 0.63fF
C2227 la_data_in[122] vssa1 0.63fF
C2228 la_oenb[121] vssa1 0.63fF
C2229 la_data_out[121] vssa1 0.63fF
C2230 la_data_in[121] vssa1 0.63fF
C2231 la_oenb[120] vssa1 0.63fF
C2232 la_data_out[120] vssa1 0.63fF
C2233 la_data_in[120] vssa1 0.63fF
C2234 la_oenb[119] vssa1 0.63fF
C2235 la_data_out[119] vssa1 0.63fF
C2236 la_data_in[119] vssa1 0.63fF
C2237 la_oenb[118] vssa1 0.63fF
C2238 la_data_out[118] vssa1 0.63fF
C2239 la_data_in[118] vssa1 0.63fF
C2240 la_oenb[117] vssa1 0.63fF
C2241 la_data_out[117] vssa1 0.63fF
C2242 la_data_in[117] vssa1 0.63fF
C2243 la_oenb[116] vssa1 0.63fF
C2244 la_data_out[116] vssa1 0.63fF
C2245 la_data_in[116] vssa1 0.63fF
C2246 la_oenb[115] vssa1 0.63fF
C2247 la_data_out[115] vssa1 0.63fF
C2248 la_data_in[115] vssa1 0.63fF
C2249 la_oenb[114] vssa1 0.63fF
C2250 la_data_out[114] vssa1 0.63fF
C2251 la_data_in[114] vssa1 0.63fF
C2252 la_oenb[113] vssa1 0.63fF
C2253 la_data_out[113] vssa1 0.63fF
C2254 la_data_in[113] vssa1 0.63fF
C2255 la_oenb[112] vssa1 0.63fF
C2256 la_data_out[112] vssa1 0.63fF
C2257 la_data_in[112] vssa1 0.63fF
C2258 la_oenb[111] vssa1 0.63fF
C2259 la_data_out[111] vssa1 0.63fF
C2260 la_data_in[111] vssa1 0.63fF
C2261 la_oenb[110] vssa1 0.63fF
C2262 la_data_out[110] vssa1 0.63fF
C2263 la_data_in[110] vssa1 0.63fF
C2264 la_oenb[109] vssa1 0.63fF
C2265 la_data_out[109] vssa1 0.63fF
C2266 la_data_in[109] vssa1 0.63fF
C2267 la_oenb[108] vssa1 0.63fF
C2268 la_data_out[108] vssa1 0.63fF
C2269 la_data_in[108] vssa1 0.63fF
C2270 la_oenb[107] vssa1 0.63fF
C2271 la_data_out[107] vssa1 0.63fF
C2272 la_data_in[107] vssa1 0.63fF
C2273 la_oenb[106] vssa1 0.63fF
C2274 la_data_out[106] vssa1 0.63fF
C2275 la_data_in[106] vssa1 0.63fF
C2276 la_oenb[105] vssa1 0.63fF
C2277 la_data_out[105] vssa1 0.63fF
C2278 la_data_in[105] vssa1 0.63fF
C2279 la_oenb[104] vssa1 0.63fF
C2280 la_data_out[104] vssa1 0.63fF
C2281 la_data_in[104] vssa1 0.63fF
C2282 la_oenb[103] vssa1 0.63fF
C2283 la_data_out[103] vssa1 0.63fF
C2284 la_data_in[103] vssa1 0.63fF
C2285 la_oenb[102] vssa1 0.63fF
C2286 la_data_out[102] vssa1 0.63fF
C2287 la_data_in[102] vssa1 0.63fF
C2288 la_oenb[101] vssa1 0.63fF
C2289 la_data_out[101] vssa1 0.63fF
C2290 la_data_in[101] vssa1 0.63fF
C2291 la_oenb[100] vssa1 0.63fF
C2292 la_data_out[100] vssa1 0.63fF
C2293 la_data_in[100] vssa1 0.63fF
C2294 la_oenb[99] vssa1 0.63fF
C2295 la_data_out[99] vssa1 0.63fF
C2296 la_data_in[99] vssa1 0.63fF
C2297 la_oenb[98] vssa1 0.63fF
C2298 la_data_out[98] vssa1 0.63fF
C2299 la_data_in[98] vssa1 0.63fF
C2300 la_oenb[97] vssa1 0.63fF
C2301 la_data_out[97] vssa1 0.63fF
C2302 la_data_in[97] vssa1 0.63fF
C2303 la_oenb[96] vssa1 0.63fF
C2304 la_data_out[96] vssa1 0.63fF
C2305 la_data_in[96] vssa1 0.63fF
C2306 la_oenb[95] vssa1 0.63fF
C2307 la_data_out[95] vssa1 0.63fF
C2308 la_data_in[95] vssa1 0.63fF
C2309 la_oenb[94] vssa1 0.63fF
C2310 la_data_out[94] vssa1 0.63fF
C2311 la_data_in[94] vssa1 0.63fF
C2312 la_oenb[93] vssa1 0.63fF
C2313 la_data_out[93] vssa1 0.63fF
C2314 la_data_in[93] vssa1 0.63fF
C2315 la_oenb[92] vssa1 0.63fF
C2316 la_data_out[92] vssa1 0.63fF
C2317 la_data_in[92] vssa1 0.63fF
C2318 la_oenb[91] vssa1 0.63fF
C2319 la_data_out[91] vssa1 0.63fF
C2320 la_data_in[91] vssa1 0.63fF
C2321 la_oenb[90] vssa1 0.63fF
C2322 la_data_out[90] vssa1 0.63fF
C2323 la_data_in[90] vssa1 0.63fF
C2324 la_oenb[89] vssa1 0.63fF
C2325 la_data_out[89] vssa1 0.63fF
C2326 la_data_in[89] vssa1 0.63fF
C2327 la_oenb[88] vssa1 0.63fF
C2328 la_data_out[88] vssa1 0.63fF
C2329 la_data_in[88] vssa1 0.63fF
C2330 la_oenb[87] vssa1 0.63fF
C2331 la_data_out[87] vssa1 0.63fF
C2332 la_data_in[87] vssa1 0.63fF
C2333 la_oenb[86] vssa1 0.63fF
C2334 la_data_out[86] vssa1 0.63fF
C2335 la_data_in[86] vssa1 0.63fF
C2336 la_oenb[85] vssa1 0.63fF
C2337 la_data_out[85] vssa1 0.63fF
C2338 la_data_in[85] vssa1 0.63fF
C2339 la_oenb[84] vssa1 0.63fF
C2340 la_data_out[84] vssa1 0.63fF
C2341 la_data_in[84] vssa1 0.63fF
C2342 la_oenb[83] vssa1 0.63fF
C2343 la_data_out[83] vssa1 0.63fF
C2344 la_data_in[83] vssa1 0.63fF
C2345 la_oenb[82] vssa1 0.63fF
C2346 la_data_out[82] vssa1 0.63fF
C2347 la_data_in[82] vssa1 0.63fF
C2348 la_oenb[81] vssa1 0.63fF
C2349 la_data_out[81] vssa1 0.63fF
C2350 la_data_in[81] vssa1 0.63fF
C2351 la_oenb[80] vssa1 0.63fF
C2352 la_data_out[80] vssa1 0.63fF
C2353 la_data_in[80] vssa1 0.63fF
C2354 la_oenb[79] vssa1 0.63fF
C2355 la_data_out[79] vssa1 0.63fF
C2356 la_data_in[79] vssa1 0.63fF
C2357 la_oenb[78] vssa1 0.63fF
C2358 la_data_out[78] vssa1 0.63fF
C2359 la_data_in[78] vssa1 0.63fF
C2360 la_oenb[77] vssa1 0.63fF
C2361 la_data_out[77] vssa1 0.63fF
C2362 la_data_in[77] vssa1 0.63fF
C2363 la_oenb[76] vssa1 0.63fF
C2364 la_data_out[76] vssa1 0.63fF
C2365 la_data_in[76] vssa1 0.63fF
C2366 la_oenb[75] vssa1 0.63fF
C2367 la_data_out[75] vssa1 0.63fF
C2368 la_data_in[75] vssa1 0.63fF
C2369 la_oenb[74] vssa1 0.63fF
C2370 la_data_out[74] vssa1 0.63fF
C2371 la_data_in[74] vssa1 0.63fF
C2372 la_oenb[73] vssa1 0.63fF
C2373 la_data_out[73] vssa1 0.63fF
C2374 la_data_in[73] vssa1 0.63fF
C2375 la_oenb[72] vssa1 0.63fF
C2376 la_data_out[72] vssa1 0.63fF
C2377 la_data_in[72] vssa1 0.63fF
C2378 la_oenb[71] vssa1 0.63fF
C2379 la_data_out[71] vssa1 0.63fF
C2380 la_data_in[71] vssa1 0.63fF
C2381 la_oenb[70] vssa1 0.63fF
C2382 la_data_out[70] vssa1 0.63fF
C2383 la_data_in[70] vssa1 0.63fF
C2384 la_oenb[69] vssa1 0.63fF
C2385 la_data_out[69] vssa1 0.63fF
C2386 la_data_in[69] vssa1 0.63fF
C2387 la_oenb[68] vssa1 0.63fF
C2388 la_data_out[68] vssa1 0.63fF
C2389 la_data_in[68] vssa1 0.63fF
C2390 la_oenb[67] vssa1 0.63fF
C2391 la_data_out[67] vssa1 0.63fF
C2392 la_data_in[67] vssa1 0.63fF
C2393 la_oenb[66] vssa1 0.63fF
C2394 la_data_out[66] vssa1 0.63fF
C2395 la_data_in[66] vssa1 0.63fF
C2396 la_oenb[65] vssa1 0.63fF
C2397 la_data_out[65] vssa1 0.63fF
C2398 la_data_in[65] vssa1 0.63fF
C2399 la_oenb[64] vssa1 0.63fF
C2400 la_data_out[64] vssa1 0.63fF
C2401 la_data_in[64] vssa1 0.63fF
C2402 la_oenb[63] vssa1 0.63fF
C2403 la_data_out[63] vssa1 0.63fF
C2404 la_data_in[63] vssa1 0.63fF
C2405 la_oenb[62] vssa1 0.63fF
C2406 la_data_out[62] vssa1 0.63fF
C2407 la_data_in[62] vssa1 0.63fF
C2408 la_oenb[61] vssa1 0.63fF
C2409 la_data_out[61] vssa1 0.63fF
C2410 la_data_in[61] vssa1 0.63fF
C2411 la_oenb[60] vssa1 0.63fF
C2412 la_data_out[60] vssa1 0.63fF
C2413 la_data_in[60] vssa1 0.63fF
C2414 la_oenb[59] vssa1 0.63fF
C2415 la_data_out[59] vssa1 0.63fF
C2416 la_data_in[59] vssa1 0.63fF
C2417 la_oenb[58] vssa1 0.63fF
C2418 la_data_out[58] vssa1 0.63fF
C2419 la_data_in[58] vssa1 0.63fF
C2420 la_oenb[57] vssa1 0.63fF
C2421 la_data_out[57] vssa1 0.63fF
C2422 la_data_in[57] vssa1 0.63fF
C2423 la_oenb[56] vssa1 0.63fF
C2424 la_data_out[56] vssa1 0.63fF
C2425 la_data_in[56] vssa1 0.63fF
C2426 la_oenb[55] vssa1 0.63fF
C2427 la_data_out[55] vssa1 0.63fF
C2428 la_data_in[55] vssa1 0.63fF
C2429 la_oenb[54] vssa1 0.63fF
C2430 la_data_out[54] vssa1 0.63fF
C2431 la_data_in[54] vssa1 0.63fF
C2432 la_oenb[53] vssa1 0.63fF
C2433 la_data_out[53] vssa1 0.63fF
C2434 la_data_in[53] vssa1 0.63fF
C2435 la_oenb[52] vssa1 0.63fF
C2436 la_data_out[52] vssa1 0.63fF
C2437 la_data_in[52] vssa1 0.63fF
C2438 la_oenb[51] vssa1 0.63fF
C2439 la_data_out[51] vssa1 0.63fF
C2440 la_data_in[51] vssa1 0.63fF
C2441 la_oenb[50] vssa1 0.63fF
C2442 la_data_out[50] vssa1 0.63fF
C2443 la_data_in[50] vssa1 0.63fF
C2444 la_oenb[49] vssa1 0.63fF
C2445 la_data_out[49] vssa1 0.63fF
C2446 la_data_in[49] vssa1 0.63fF
C2447 la_oenb[48] vssa1 0.63fF
C2448 la_data_out[48] vssa1 0.63fF
C2449 la_data_in[48] vssa1 0.63fF
C2450 la_oenb[47] vssa1 0.63fF
C2451 la_data_out[47] vssa1 0.63fF
C2452 la_data_in[47] vssa1 0.63fF
C2453 la_oenb[46] vssa1 0.63fF
C2454 la_data_out[46] vssa1 0.63fF
C2455 la_data_in[46] vssa1 0.63fF
C2456 la_oenb[45] vssa1 0.63fF
C2457 la_data_out[45] vssa1 0.63fF
C2458 la_data_in[45] vssa1 0.63fF
C2459 la_oenb[44] vssa1 0.63fF
C2460 la_data_out[44] vssa1 0.63fF
C2461 la_data_in[44] vssa1 0.63fF
C2462 la_oenb[43] vssa1 0.63fF
C2463 la_data_out[43] vssa1 0.63fF
C2464 la_data_in[43] vssa1 0.63fF
C2465 la_oenb[42] vssa1 0.63fF
C2466 la_data_out[42] vssa1 0.63fF
C2467 la_data_in[42] vssa1 0.63fF
C2468 la_oenb[41] vssa1 0.63fF
C2469 la_data_out[41] vssa1 0.63fF
C2470 la_data_in[41] vssa1 0.63fF
C2471 la_oenb[40] vssa1 0.63fF
C2472 la_data_out[40] vssa1 0.63fF
C2473 la_data_in[40] vssa1 0.63fF
C2474 la_oenb[39] vssa1 0.63fF
C2475 la_data_out[39] vssa1 0.63fF
C2476 la_data_in[39] vssa1 0.63fF
C2477 la_oenb[38] vssa1 0.63fF
C2478 la_data_out[38] vssa1 0.63fF
C2479 la_data_in[38] vssa1 0.63fF
C2480 la_oenb[37] vssa1 0.63fF
C2481 la_data_out[37] vssa1 0.63fF
C2482 la_data_in[37] vssa1 0.63fF
C2483 la_oenb[36] vssa1 0.63fF
C2484 la_data_out[36] vssa1 0.63fF
C2485 la_data_in[36] vssa1 0.63fF
C2486 la_oenb[35] vssa1 0.63fF
C2487 la_data_out[35] vssa1 0.63fF
C2488 la_data_in[35] vssa1 0.63fF
C2489 la_oenb[34] vssa1 0.63fF
C2490 la_data_out[34] vssa1 0.63fF
C2491 la_data_in[34] vssa1 0.63fF
C2492 la_oenb[33] vssa1 0.63fF
C2493 la_data_out[33] vssa1 0.63fF
C2494 la_data_in[33] vssa1 0.63fF
C2495 la_oenb[32] vssa1 0.63fF
C2496 la_data_out[32] vssa1 0.63fF
C2497 la_data_in[32] vssa1 0.63fF
C2498 la_oenb[31] vssa1 0.63fF
C2499 la_data_out[31] vssa1 0.63fF
C2500 la_data_in[31] vssa1 0.63fF
C2501 la_oenb[30] vssa1 0.63fF
C2502 la_data_out[30] vssa1 0.63fF
C2503 la_data_in[30] vssa1 0.63fF
C2504 la_oenb[29] vssa1 0.63fF
C2505 la_data_out[29] vssa1 0.63fF
C2506 la_data_in[29] vssa1 0.63fF
C2507 la_oenb[28] vssa1 0.63fF
C2508 la_data_out[28] vssa1 0.63fF
C2509 la_data_in[28] vssa1 0.63fF
C2510 la_oenb[27] vssa1 0.63fF
C2511 la_data_out[27] vssa1 0.63fF
C2512 la_data_in[27] vssa1 0.63fF
C2513 la_oenb[26] vssa1 0.63fF
C2514 la_data_out[26] vssa1 0.63fF
C2515 la_data_in[26] vssa1 0.63fF
C2516 la_oenb[25] vssa1 0.63fF
C2517 la_data_out[25] vssa1 0.63fF
C2518 la_data_in[25] vssa1 0.63fF
C2519 la_oenb[24] vssa1 0.63fF
C2520 la_data_out[24] vssa1 0.63fF
C2521 la_data_in[24] vssa1 0.63fF
C2522 la_oenb[23] vssa1 0.63fF
C2523 la_data_out[23] vssa1 0.63fF
C2524 la_data_in[23] vssa1 0.63fF
C2525 la_oenb[22] vssa1 0.63fF
C2526 la_data_out[22] vssa1 0.63fF
C2527 la_data_in[22] vssa1 0.63fF
C2528 la_oenb[21] vssa1 0.63fF
C2529 la_data_out[21] vssa1 0.63fF
C2530 la_data_in[21] vssa1 0.63fF
C2531 la_oenb[20] vssa1 0.63fF
C2532 la_data_out[20] vssa1 0.63fF
C2533 la_data_in[20] vssa1 0.63fF
C2534 la_oenb[19] vssa1 0.63fF
C2535 la_data_out[19] vssa1 0.63fF
C2536 la_data_in[19] vssa1 0.63fF
C2537 la_oenb[18] vssa1 0.63fF
C2538 la_data_out[18] vssa1 0.63fF
C2539 la_data_in[18] vssa1 0.63fF
C2540 la_oenb[17] vssa1 0.63fF
C2541 la_data_out[17] vssa1 0.63fF
C2542 la_data_in[17] vssa1 0.63fF
C2543 la_oenb[16] vssa1 0.63fF
C2544 la_data_out[16] vssa1 0.63fF
C2545 la_data_in[16] vssa1 0.63fF
C2546 la_oenb[15] vssa1 0.63fF
C2547 la_data_out[15] vssa1 0.63fF
C2548 la_data_in[15] vssa1 0.63fF
C2549 la_oenb[14] vssa1 0.63fF
C2550 la_data_out[14] vssa1 0.63fF
C2551 la_data_in[14] vssa1 0.63fF
C2552 la_oenb[13] vssa1 0.63fF
C2553 la_data_out[13] vssa1 0.63fF
C2554 la_data_in[13] vssa1 0.63fF
C2555 la_oenb[12] vssa1 0.63fF
C2556 la_data_out[12] vssa1 0.63fF
C2557 la_data_in[12] vssa1 0.63fF
C2558 la_oenb[11] vssa1 0.63fF
C2559 la_data_out[11] vssa1 0.63fF
C2560 la_data_in[11] vssa1 0.63fF
C2561 la_oenb[10] vssa1 0.63fF
C2562 la_data_out[10] vssa1 0.63fF
C2563 la_data_in[10] vssa1 0.63fF
C2564 la_oenb[9] vssa1 0.63fF
C2565 la_data_out[9] vssa1 0.63fF
C2566 la_data_in[9] vssa1 0.63fF
C2567 la_oenb[8] vssa1 0.63fF
C2568 la_data_out[8] vssa1 0.63fF
C2569 la_data_in[8] vssa1 0.63fF
C2570 la_oenb[7] vssa1 0.63fF
C2571 la_data_out[7] vssa1 0.63fF
C2572 la_data_in[7] vssa1 0.63fF
C2573 la_oenb[6] vssa1 0.63fF
C2574 la_data_out[6] vssa1 0.63fF
C2575 la_data_in[6] vssa1 0.63fF
C2576 la_oenb[5] vssa1 0.63fF
C2577 la_data_out[5] vssa1 0.63fF
C2578 la_data_in[5] vssa1 0.63fF
C2579 la_oenb[4] vssa1 0.63fF
C2580 la_data_out[4] vssa1 0.63fF
C2581 la_data_in[4] vssa1 0.63fF
C2582 la_oenb[3] vssa1 0.63fF
C2583 la_data_out[3] vssa1 0.63fF
C2584 la_data_in[3] vssa1 0.63fF
C2585 la_oenb[2] vssa1 0.63fF
C2586 la_data_out[2] vssa1 0.63fF
C2587 la_data_in[2] vssa1 0.63fF
C2588 la_oenb[1] vssa1 0.63fF
C2589 la_data_out[1] vssa1 0.63fF
C2590 la_data_in[1] vssa1 0.63fF
C2591 la_oenb[0] vssa1 0.63fF
C2592 la_data_out[0] vssa1 0.63fF
C2593 la_data_in[0] vssa1 0.63fF
C2594 wbs_dat_o[31] vssa1 0.63fF
C2595 wbs_dat_i[31] vssa1 0.63fF
C2596 wbs_adr_i[31] vssa1 0.63fF
C2597 wbs_dat_o[30] vssa1 0.63fF
C2598 wbs_dat_i[30] vssa1 0.63fF
C2599 wbs_adr_i[30] vssa1 0.63fF
C2600 wbs_dat_o[29] vssa1 0.63fF
C2601 wbs_dat_i[29] vssa1 0.63fF
C2602 wbs_adr_i[29] vssa1 0.63fF
C2603 wbs_dat_o[28] vssa1 0.63fF
C2604 wbs_dat_i[28] vssa1 0.63fF
C2605 wbs_adr_i[28] vssa1 0.63fF
C2606 wbs_dat_o[27] vssa1 0.63fF
C2607 wbs_dat_i[27] vssa1 0.63fF
C2608 wbs_adr_i[27] vssa1 0.63fF
C2609 wbs_dat_o[26] vssa1 0.63fF
C2610 wbs_dat_i[26] vssa1 0.63fF
C2611 wbs_adr_i[26] vssa1 0.63fF
C2612 wbs_dat_o[25] vssa1 0.63fF
C2613 wbs_dat_i[25] vssa1 0.63fF
C2614 wbs_adr_i[25] vssa1 0.63fF
C2615 wbs_dat_o[24] vssa1 0.63fF
C2616 wbs_dat_i[24] vssa1 0.63fF
C2617 wbs_adr_i[24] vssa1 0.63fF
C2618 wbs_dat_o[23] vssa1 0.63fF
C2619 wbs_dat_i[23] vssa1 0.63fF
C2620 wbs_adr_i[23] vssa1 0.63fF
C2621 wbs_dat_o[22] vssa1 0.63fF
C2622 wbs_dat_i[22] vssa1 0.63fF
C2623 wbs_adr_i[22] vssa1 0.63fF
C2624 wbs_dat_o[21] vssa1 0.63fF
C2625 wbs_dat_i[21] vssa1 0.63fF
C2626 wbs_adr_i[21] vssa1 0.63fF
C2627 wbs_dat_o[20] vssa1 0.63fF
C2628 wbs_dat_i[20] vssa1 0.63fF
C2629 wbs_adr_i[20] vssa1 0.63fF
C2630 wbs_dat_o[19] vssa1 0.63fF
C2631 wbs_dat_i[19] vssa1 0.63fF
C2632 wbs_adr_i[19] vssa1 0.63fF
C2633 wbs_dat_o[18] vssa1 0.63fF
C2634 wbs_dat_i[18] vssa1 0.63fF
C2635 wbs_adr_i[18] vssa1 0.63fF
C2636 wbs_dat_o[17] vssa1 0.63fF
C2637 wbs_dat_i[17] vssa1 0.63fF
C2638 wbs_adr_i[17] vssa1 0.63fF
C2639 wbs_dat_o[16] vssa1 0.63fF
C2640 wbs_dat_i[16] vssa1 0.63fF
C2641 wbs_adr_i[16] vssa1 0.63fF
C2642 wbs_dat_o[15] vssa1 0.63fF
C2643 wbs_dat_i[15] vssa1 0.63fF
C2644 wbs_adr_i[15] vssa1 0.63fF
C2645 wbs_dat_o[14] vssa1 0.63fF
C2646 wbs_dat_i[14] vssa1 0.63fF
C2647 wbs_adr_i[14] vssa1 0.63fF
C2648 wbs_dat_o[13] vssa1 0.63fF
C2649 wbs_dat_i[13] vssa1 0.63fF
C2650 wbs_adr_i[13] vssa1 0.63fF
C2651 wbs_dat_o[12] vssa1 0.63fF
C2652 wbs_dat_i[12] vssa1 0.63fF
C2653 wbs_adr_i[12] vssa1 0.63fF
C2654 wbs_dat_o[11] vssa1 0.63fF
C2655 wbs_dat_i[11] vssa1 0.63fF
C2656 wbs_adr_i[11] vssa1 0.63fF
C2657 wbs_dat_o[10] vssa1 0.63fF
C2658 wbs_dat_i[10] vssa1 0.63fF
C2659 wbs_adr_i[10] vssa1 0.63fF
C2660 wbs_dat_o[9] vssa1 0.63fF
C2661 wbs_dat_i[9] vssa1 0.63fF
C2662 wbs_adr_i[9] vssa1 0.63fF
C2663 wbs_dat_o[8] vssa1 0.63fF
C2664 wbs_dat_i[8] vssa1 0.63fF
C2665 wbs_adr_i[8] vssa1 0.63fF
C2666 wbs_dat_o[7] vssa1 0.63fF
C2667 wbs_dat_i[7] vssa1 0.63fF
C2668 wbs_adr_i[7] vssa1 0.63fF
C2669 wbs_dat_o[6] vssa1 0.63fF
C2670 wbs_dat_i[6] vssa1 0.63fF
C2671 wbs_adr_i[6] vssa1 0.63fF
C2672 wbs_dat_o[5] vssa1 0.63fF
C2673 wbs_dat_i[5] vssa1 0.63fF
C2674 wbs_adr_i[5] vssa1 0.63fF
C2675 wbs_dat_o[4] vssa1 0.63fF
C2676 wbs_dat_i[4] vssa1 0.63fF
C2677 wbs_adr_i[4] vssa1 0.63fF
C2678 wbs_sel_i[3] vssa1 0.63fF
C2679 wbs_dat_o[3] vssa1 0.63fF
C2680 wbs_dat_i[3] vssa1 0.63fF
C2681 wbs_adr_i[3] vssa1 0.63fF
C2682 wbs_sel_i[2] vssa1 0.63fF
C2683 wbs_dat_o[2] vssa1 0.63fF
C2684 wbs_dat_i[2] vssa1 0.63fF
C2685 wbs_adr_i[2] vssa1 0.63fF
C2686 wbs_sel_i[1] vssa1 0.63fF
C2687 wbs_dat_o[1] vssa1 0.63fF
C2688 wbs_dat_i[1] vssa1 0.63fF
C2689 wbs_adr_i[1] vssa1 0.63fF
C2690 wbs_sel_i[0] vssa1 0.63fF
C2691 wbs_dat_o[0] vssa1 0.63fF
C2692 wbs_dat_i[0] vssa1 0.63fF
C2693 wbs_adr_i[0] vssa1 0.63fF
C2694 wbs_we_i vssa1 0.63fF
C2695 wbs_stb_i vssa1 0.63fF
C2696 wbs_cyc_i vssa1 0.63fF
C2697 wbs_ack_o vssa1 0.63fF
C2698 wb_rst_i vssa1 0.63fF
C2699 wb_clk_i vssa1 0.63fF
C2700 m2_494098_659718# vssa1 0.80fF **FLOATING
C2701 pll_full_1/divider_0/and_0/Z1 vssa1 0.65fF
C2702 pll_full_1/divider_0/and_0/B vssa1 2.45fF
C2703 pll_full_1/divider_0/and_0/A vssa1 2.35fF
C2704 pll_full_1/divider_0/and_0/out1 vssa1 2.99fF
C2705 pll_full_1/divider_0/tspc_2/Z4 vssa1 0.86fF
C2706 pll_full_1/divider_0/tspc_2/Z3 vssa1 2.26fF
C2707 pll_full_1/divider_0/tspc_2/Z2 vssa1 1.46fF
C2708 pll_full_1/divider_0/tspc_2/Z1 vssa1 0.99fF
C2709 pll_full_1/divider_0/nor_0/A vssa1 7.08fF
C2710 pll_full_1/divider_0/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C2711 pll_full_1/divider_0/tspc_1/Z4 vssa1 0.86fF
C2712 pll_full_1/divider_0/tspc_1/Z3 vssa1 2.26fF
C2713 pll_full_1/divider_0/tspc_1/Z2 vssa1 1.46fF
C2714 pll_full_1/divider_0/tspc_1/Z1 vssa1 0.99fF
C2715 pll_full_1/divider_0/nor_0/B vssa1 7.12fF
C2716 pll_full_1/divider_0/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C2717 pll_full_1/divider_0/tspc_2/Q vssa1 3.14fF
C2718 pll_full_1/divider_0/tspc_0/Z4 vssa1 0.86fF
C2719 pll_full_1/divbuf_0/IN vssa1 9.89fF
C2720 pll_full_1/divider_0/tspc_0/Z3 vssa1 2.26fF
C2721 pll_full_1/divider_0/tspc_0/Z2 vssa1 1.46fF
C2722 pll_full_1/divider_0/tspc_0/Z1 vssa1 0.99fF
C2723 pll_full_1/divider_0/nor_1/B vssa1 6.48fF
C2724 pll_full_1/divider_0/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C2725 pll_full_1/divider_0/tspc_1/Q vssa1 3.12fF
C2726 pll_full_1/divider_0/clk vssa1 33.42fF
C2727 pll_full_1/divider_0/prescaler_0/nand_1/z1 vssa1 0.36fF
C2728 pll_full_1/divider_0/prescaler_0/tspc_0/D vssa1 2.64fF
C2729 pll_full_1/divider_0/prescaler_0/tspc_2/Q vssa1 3.72fF
C2730 pll_full_1/divider_0/prescaler_0/tspc_1/Q vssa1 3.61fF
C2731 pll_full_1/divider_0/prescaler_0/nand_0/z1 vssa1 0.36fF
C2732 pll_full_1/divider_0/prescaler_0/tspc_2/D vssa1 3.12fF
C2733 pll_full_1/divider_0/and_0/OUT vssa1 5.67fF
C2734 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C2735 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C2736 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 vssa1 1.19fF
C2737 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C2738 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# vssa1 1.47fF **FLOATING
C2739 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C2740 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C2741 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C2742 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C2743 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C2744 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C2745 pll_full_1/divider_0/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C2746 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C2747 pll_full_1/divider_0/prescaler_0/Out vssa1 4.59fF
C2748 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C2749 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C2750 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C2751 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C2752 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C2753 pll_full_1/divider_0/nor_1/Z1 vssa1 1.34fF
C2754 pll_full_1/divider_0/nor_0/Z1 vssa1 1.34fF
C2755 pll_full_1/divbuf_1/OUT vssa1 363.82fF
C2756 pll_full_1/divbuf_1/OUT5 vssa1 350.37fF
C2757 pll_full_1/divbuf_1/OUT4 vssa1 133.72fF
C2758 pll_full_1/divbuf_1/OUT3 vssa1 34.03fF
C2759 pll_full_1/divbuf_1/OUT2 vssa1 8.71fF
C2760 pll_full_1/divbuf_1/a_492_n240# vssa1 2.46fF **FLOATING
C2761 pll_full_1/divbuf_0/OUT5 vssa1 350.37fF
C2762 pll_full_1/divbuf_0/OUT4 vssa1 133.72fF
C2763 pll_full_1/divbuf_0/OUT3 vssa1 34.03fF
C2764 pll_full_1/divbuf_0/OUT2 vssa1 8.71fF
C2765 pll_full_1/divbuf_0/a_492_n240# vssa1 2.46fF **FLOATING
C2766 pll_full_1/ro_complete_0/cbank_2/v vssa1 16.43fF
C2767 pll_full_1/ro_complete_0/cbank_2/switch_5/vin vssa1 0.78fF
C2768 pll_full_1/ro_complete_0/cbank_2/switch_4/vin vssa1 1.50fF
C2769 pll_full_1/ro_complete_0/cbank_2/switch_2/vin vssa1 1.30fF
C2770 pll_full_1/ro_complete_0/cbank_2/switch_3/vin vssa1 0.56fF
C2771 pll_full_1/ro_complete_0/cbank_2/switch_1/vin vssa1 1.14fF
C2772 pll_full_1/ro_complete_0/cbank_2/switch_0/vin vssa1 1.02fF
C2773 pll_full_1/ro_complete_0/cbank_1/switch_5/vin vssa1 0.78fF
C2774 pll_full_1/ro_complete_0/a0 vssa1 5.35fF
C2775 pll_full_1/ro_complete_0/cbank_1/switch_4/vin vssa1 1.50fF
C2776 pll_full_1/ro_complete_0/a1 vssa1 6.54fF
C2777 pll_full_1/ro_complete_0/cbank_1/switch_2/vin vssa1 1.30fF
C2778 pll_full_1/ro_complete_0/a3 vssa1 5.96fF
C2779 pll_full_1/ro_complete_0/cbank_1/switch_3/vin vssa1 0.56fF
C2780 pll_full_1/ro_complete_0/a2 vssa1 5.21fF
C2781 pll_full_1/ro_complete_0/cbank_1/switch_1/vin vssa1 1.14fF
C2782 pll_full_1/ro_complete_0/a4 vssa1 5.81fF
C2783 pll_full_1/ro_complete_0/cbank_1/switch_0/vin vssa1 1.02fF
C2784 pll_full_1/ro_complete_0/a5 vssa1 6.74fF
C2785 pll_full_1/ro_complete_0/cbank_0/v vssa1 15.12fF
C2786 pll_full_1/ro_complete_0/cbank_0/switch_5/vin vssa1 0.78fF
C2787 pll_full_1/ro_complete_0/cbank_0/switch_4/vin vssa1 1.50fF
C2788 pll_full_1/ro_complete_0/cbank_0/switch_2/vin vssa1 1.30fF
C2789 pll_full_1/ro_complete_0/cbank_0/switch_3/vin vssa1 0.56fF
C2790 pll_full_1/ro_complete_0/cbank_0/switch_1/vin vssa1 1.14fF
C2791 pll_full_1/ro_complete_0/cbank_0/switch_0/vin vssa1 1.02fF
C2792 pll_full_1/ro_complete_0/ro_var_extend_0/vcont vssa1 0.27fF
C2793 pll_full_1/filter_0/a_4216_n5230# vssa1 418.90fF **FLOATING
C2794 pll_full_1/filter_0/a_4216_n2998# vssa1 1.39fF **FLOATING
C2795 pll_full_1/cp_0/down vssa1 1.54fF
C2796 pll_full_1/cp_0/upbar vssa1 1.79fF
C2797 pll_full_1/cp_0/a_7110_n2840# vssa1 0.17fF **FLOATING
C2798 pll_full_1/cp_0/a_3060_n2840# vssa1 1.71fF **FLOATING
C2799 pll_full_1/cp_0/a_7110_0# vssa1 0.17fF **FLOATING
C2800 pll_full_1/cp_0/a_6370_0# vssa1 0.40fF **FLOATING
C2801 pll_full_1/cp_0/a_3060_0# vssa1 2.49fF **FLOATING
C2802 pll_full_1/cp_0/a_1710_0# vssa1 7.47fF **FLOATING
C2803 pll_full_1/pd_0/and_pd_0/Z1 vssa1 0.39fF
C2804 pll_full_1/pd_0/and_pd_0/Out1 vssa1 2.22fF
C2805 pll_full_1/pd_0/tspc_r_1/z5 vssa1 1.10fF
C2806 pll_full_1/pd_0/tspc_r_1/Z4 vssa1 1.07fF
C2807 pll_full_1/pd_0/tspc_r_1/Qbar vssa1 0.88fF
C2808 pll_full_1/pd_0/tspc_r_1/Z2 vssa1 1.22fF
C2809 pll_full_1/pd_0/tspc_r_1/Z1 vssa1 0.67fF
C2810 pll_full_1/pd_0/UP vssa1 6.41fF
C2811 pll_full_1/pd_0/tspc_r_1/Qbar1 vssa1 1.34fF
C2812 pll_full_1/pd_0/tspc_r_1/Z3 vssa1 2.12fF
C2813 pll_full_1/pd_0/REF vssa1 6.48fF
C2814 pll_full_1/pd_0/tspc_r_0/z5 vssa1 1.10fF
C2815 pll_full_1/pd_0/tspc_r_0/Z4 vssa1 1.07fF
C2816 pll_full_1/pd_0/R vssa1 3.05fF
C2817 pll_full_1/pd_0/tspc_r_0/Qbar vssa1 0.79fF
C2818 pll_full_1/pd_0/tspc_r_0/Z2 vssa1 1.22fF
C2819 pll_full_1/pd_0/tspc_r_0/Z1 vssa1 0.67fF
C2820 pll_full_1/pd_0/DOWN vssa1 7.34fF
C2821 pll_full_1/pd_0/tspc_r_0/Qbar1 vssa1 1.34fF
C2822 pll_full_1/pd_0/tspc_r_0/Z3 vssa1 2.12fF
C2823 pll_full_1/pd_0/DIV vssa1 372.69fF
C2824 pll_full_0/divider_0/and_0/Z1 vssa1 0.65fF
C2825 pll_full_0/divider_0/and_0/B vssa1 2.45fF
C2826 pll_full_0/divider_0/and_0/A vssa1 2.35fF
C2827 pll_full_0/divider_0/and_0/out1 vssa1 2.99fF
C2828 pll_full_0/divider_0/tspc_2/Z4 vssa1 0.86fF
C2829 pll_full_0/divider_0/tspc_2/Z3 vssa1 2.26fF
C2830 pll_full_0/divider_0/tspc_2/Z2 vssa1 1.46fF
C2831 pll_full_0/divider_0/tspc_2/Z1 vssa1 0.99fF
C2832 pll_full_0/divider_0/nor_0/A vssa1 7.08fF
C2833 pll_full_0/divider_0/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C2834 pll_full_0/divider_0/tspc_1/Z4 vssa1 0.86fF
C2835 pll_full_0/divider_0/tspc_1/Z3 vssa1 2.26fF
C2836 pll_full_0/divider_0/tspc_1/Z2 vssa1 1.46fF
C2837 pll_full_0/divider_0/tspc_1/Z1 vssa1 0.99fF
C2838 pll_full_0/divider_0/nor_0/B vssa1 7.12fF
C2839 pll_full_0/divider_0/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C2840 pll_full_0/divider_0/tspc_2/Q vssa1 3.14fF
C2841 pll_full_0/divider_0/tspc_0/Z4 vssa1 0.86fF
C2842 pll_full_0/divbuf_0/IN vssa1 9.89fF
C2843 pll_full_0/divider_0/tspc_0/Z3 vssa1 2.26fF
C2844 pll_full_0/divider_0/tspc_0/Z2 vssa1 1.46fF
C2845 pll_full_0/divider_0/tspc_0/Z1 vssa1 0.99fF
C2846 pll_full_0/divider_0/nor_1/B vssa1 6.48fF
C2847 pll_full_0/divider_0/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C2848 pll_full_0/divider_0/tspc_1/Q vssa1 3.12fF
C2849 pll_full_0/divider_0/clk vssa1 33.42fF
C2850 pll_full_0/divider_0/prescaler_0/nand_1/z1 vssa1 0.36fF
C2851 pll_full_0/divider_0/prescaler_0/tspc_0/D vssa1 2.64fF
C2852 pll_full_0/divider_0/prescaler_0/tspc_2/Q vssa1 3.72fF
C2853 pll_full_0/divider_0/prescaler_0/tspc_1/Q vssa1 3.61fF
C2854 pll_full_0/divider_0/prescaler_0/nand_0/z1 vssa1 0.36fF
C2855 pll_full_0/divider_0/prescaler_0/tspc_2/D vssa1 3.12fF
C2856 pll_full_0/divider_0/and_0/OUT vssa1 5.67fF
C2857 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C2858 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C2859 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 vssa1 1.19fF
C2860 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C2861 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# vssa1 1.47fF **FLOATING
C2862 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C2863 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C2864 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C2865 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C2866 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C2867 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C2868 pll_full_0/divider_0/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C2869 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C2870 pll_full_0/divider_0/prescaler_0/Out vssa1 4.59fF
C2871 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C2872 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C2873 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C2874 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C2875 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C2876 pll_full_0/divider_0/nor_1/Z1 vssa1 1.34fF
C2877 pll_full_0/divider_0/nor_0/Z1 vssa1 1.34fF
C2878 pll_full_0/divbuf_1/OUT vssa1 363.82fF
C2879 pll_full_0/divbuf_1/OUT5 vssa1 350.37fF
C2880 pll_full_0/divbuf_1/OUT4 vssa1 133.72fF
C2881 pll_full_0/divbuf_1/OUT3 vssa1 34.03fF
C2882 pll_full_0/divbuf_1/OUT2 vssa1 8.71fF
C2883 pll_full_0/divbuf_1/a_492_n240# vssa1 2.46fF **FLOATING
C2884 pll_full_0/divbuf_0/OUT5 vssa1 350.37fF
C2885 pll_full_0/divbuf_0/OUT4 vssa1 133.72fF
C2886 pll_full_0/divbuf_0/OUT3 vssa1 34.03fF
C2887 pll_full_0/divbuf_0/OUT2 vssa1 8.71fF
C2888 pll_full_0/divbuf_0/a_492_n240# vssa1 2.46fF **FLOATING
C2889 pll_full_0/ro_complete_0/cbank_2/v vssa1 16.43fF
C2890 pll_full_0/ro_complete_0/cbank_2/switch_5/vin vssa1 0.78fF
C2891 pll_full_0/ro_complete_0/cbank_2/switch_4/vin vssa1 1.50fF
C2892 pll_full_0/ro_complete_0/cbank_2/switch_2/vin vssa1 1.30fF
C2893 pll_full_0/ro_complete_0/cbank_2/switch_3/vin vssa1 0.56fF
C2894 pll_full_0/ro_complete_0/cbank_2/switch_1/vin vssa1 1.14fF
C2895 pll_full_0/ro_complete_0/cbank_2/switch_0/vin vssa1 1.02fF
C2896 pll_full_0/ro_complete_0/cbank_1/switch_5/vin vssa1 0.78fF
C2897 pll_full_0/ro_complete_0/a0 vssa1 5.35fF
C2898 pll_full_0/ro_complete_0/cbank_1/switch_4/vin vssa1 1.50fF
C2899 pll_full_0/ro_complete_0/a1 vssa1 6.54fF
C2900 pll_full_0/ro_complete_0/cbank_1/switch_2/vin vssa1 1.30fF
C2901 pll_full_0/ro_complete_0/a3 vssa1 5.96fF
C2902 pll_full_0/ro_complete_0/cbank_1/switch_3/vin vssa1 0.56fF
C2903 pll_full_0/ro_complete_0/a2 vssa1 5.21fF
C2904 pll_full_0/ro_complete_0/cbank_1/switch_1/vin vssa1 1.14fF
C2905 pll_full_0/ro_complete_0/a4 vssa1 5.81fF
C2906 pll_full_0/ro_complete_0/cbank_1/switch_0/vin vssa1 1.02fF
C2907 pll_full_0/ro_complete_0/a5 vssa1 6.74fF
C2908 pll_full_0/ro_complete_0/cbank_0/v vssa1 15.12fF
C2909 pll_full_0/ro_complete_0/cbank_0/switch_5/vin vssa1 0.78fF
C2910 pll_full_0/ro_complete_0/cbank_0/switch_4/vin vssa1 1.50fF
C2911 pll_full_0/ro_complete_0/cbank_0/switch_2/vin vssa1 1.30fF
C2912 pll_full_0/ro_complete_0/cbank_0/switch_3/vin vssa1 0.56fF
C2913 pll_full_0/ro_complete_0/cbank_0/switch_1/vin vssa1 1.14fF
C2914 pll_full_0/ro_complete_0/cbank_0/switch_0/vin vssa1 1.02fF
C2915 pll_full_0/ro_complete_0/ro_var_extend_0/vcont vssa1 0.27fF
C2916 pll_full_0/filter_0/a_4216_n5230# vssa1 418.90fF **FLOATING
C2917 pll_full_0/filter_0/a_4216_n2998# vssa1 1.39fF **FLOATING
C2918 pll_full_0/cp_0/down vssa1 1.54fF
C2919 pll_full_0/cp_0/upbar vssa1 1.79fF
C2920 pll_full_0/cp_0/a_7110_n2840# vssa1 0.17fF **FLOATING
C2921 pll_full_0/cp_0/a_3060_n2840# vssa1 1.71fF **FLOATING
C2922 pll_full_0/cp_0/a_7110_0# vssa1 0.17fF **FLOATING
C2923 pll_full_0/cp_0/a_6370_0# vssa1 0.40fF **FLOATING
C2924 pll_full_0/cp_0/a_3060_0# vssa1 2.49fF **FLOATING
C2925 pll_full_0/cp_0/a_1710_0# vssa1 7.47fF **FLOATING
C2926 pll_full_0/pd_0/and_pd_0/Z1 vssa1 0.39fF
C2927 pll_full_0/pd_0/and_pd_0/Out1 vssa1 2.22fF
C2928 pll_full_0/pd_0/tspc_r_1/z5 vssa1 1.10fF
C2929 pll_full_0/pd_0/tspc_r_1/Z4 vssa1 1.07fF
C2930 pll_full_0/pd_0/tspc_r_1/Qbar vssa1 0.88fF
C2931 pll_full_0/pd_0/tspc_r_1/Z2 vssa1 1.22fF
C2932 pll_full_0/pd_0/tspc_r_1/Z1 vssa1 0.67fF
C2933 pll_full_0/pd_0/UP vssa1 6.41fF
C2934 pll_full_0/pd_0/tspc_r_1/Qbar1 vssa1 1.34fF
C2935 pll_full_0/pd_0/tspc_r_1/Z3 vssa1 2.12fF
C2936 pll_full_0/pd_0/REF vssa1 6.48fF
C2937 pll_full_0/pd_0/tspc_r_0/z5 vssa1 1.10fF
C2938 pll_full_0/pd_0/tspc_r_0/Z4 vssa1 1.07fF
C2939 pll_full_0/pd_0/R vssa1 3.05fF
C2940 pll_full_0/pd_0/tspc_r_0/Qbar vssa1 0.79fF
C2941 pll_full_0/pd_0/tspc_r_0/Z2 vssa1 1.22fF
C2942 pll_full_0/pd_0/tspc_r_0/Z1 vssa1 0.67fF
C2943 pll_full_0/pd_0/DOWN vssa1 7.34fF
C2944 pll_full_0/pd_0/tspc_r_0/Qbar1 vssa1 1.34fF
C2945 pll_full_0/pd_0/tspc_r_0/Z3 vssa1 2.12fF
C2946 pll_full_0/pd_0/DIV vssa1 372.69fF
C2947 divbuf_19/OUT5 vssa1 350.37fF
C2948 divbuf_19/OUT4 vssa1 133.72fF
C2949 divbuf_19/OUT3 vssa1 34.03fF
C2950 divbuf_19/OUT2 vssa1 8.71fF
C2951 divbuf_19/IN vssa1 0.89fF
C2952 divbuf_19/a_492_n240# vssa1 2.46fF **FLOATING
C2953 divbuf_18/OUT5 vssa1 350.37fF
C2954 divbuf_18/OUT4 vssa1 133.72fF
C2955 divbuf_18/OUT3 vssa1 34.03fF
C2956 divbuf_18/OUT2 vssa1 8.71fF
C2957 divbuf_18/IN vssa1 0.89fF
C2958 divbuf_18/a_492_n240# vssa1 2.46fF **FLOATING
C2959 divbuf_17/OUT vssa1 363.82fF
C2960 divbuf_17/OUT5 vssa1 350.37fF
C2961 divbuf_17/OUT4 vssa1 133.72fF
C2962 divbuf_17/OUT3 vssa1 34.03fF
C2963 divbuf_17/OUT2 vssa1 8.71fF
C2964 divbuf_17/IN vssa1 0.89fF
C2965 divbuf_17/a_492_n240# vssa1 2.46fF **FLOATING
C2966 divider_2/and_0/Z1 vssa1 0.74fF
C2967 divider_2/and_0/B vssa1 2.25fF
C2968 divider_2/and_0/A vssa1 2.19fF
C2969 divider_2/and_0/out1 vssa1 2.93fF
C2970 divider_2/tspc_2/Z4 vssa1 0.86fF
C2971 divider_2/tspc_2/Z3 vssa1 2.26fF
C2972 divider_2/tspc_2/Z2 vssa1 1.46fF
C2973 divider_2/tspc_2/Z1 vssa1 0.99fF
C2974 divider_2/nor_0/A vssa1 7.04fF
C2975 divider_2/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C2976 divider_2/tspc_1/Z4 vssa1 0.86fF
C2977 divider_2/tspc_1/Z3 vssa1 2.26fF
C2978 divider_2/tspc_1/Z2 vssa1 1.46fF
C2979 divider_2/tspc_1/Z1 vssa1 0.99fF
C2980 divider_2/nor_0/B vssa1 7.05fF
C2981 divider_2/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C2982 divider_2/tspc_2/Q vssa1 3.14fF
C2983 divider_2/tspc_0/Z4 vssa1 0.86fF
C2984 divider_2/Out vssa1 1.60fF
C2985 divider_2/tspc_0/Z3 vssa1 2.26fF
C2986 divider_2/tspc_0/Z2 vssa1 1.46fF
C2987 divider_2/tspc_0/Z1 vssa1 0.99fF
C2988 divider_2/nor_1/B vssa1 6.44fF
C2989 divider_2/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C2990 divider_2/tspc_1/Q vssa1 3.12fF
C2991 divider_2/clk vssa1 5.63fF
C2992 divider_2/prescaler_0/nand_1/z1 vssa1 0.36fF
C2993 divider_2/prescaler_0/tspc_0/D vssa1 2.64fF
C2994 divider_2/prescaler_0/tspc_2/Q vssa1 3.74fF
C2995 divider_2/prescaler_0/tspc_1/Q vssa1 3.61fF
C2996 divider_2/prescaler_0/nand_0/z1 vssa1 0.36fF
C2997 divider_2/prescaler_0/tspc_2/D vssa1 3.12fF
C2998 divider_2/and_0/OUT vssa1 5.62fF
C2999 divider_2/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C3000 divider_2/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C3001 divider_2/prescaler_0/tspc_2/Z2 vssa1 1.46fF
C3002 divider_2/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C3003 divider_2/prescaler_0/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C3004 divider_2/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C3005 divider_2/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C3006 divider_2/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C3007 divider_2/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C3008 divider_2/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C3009 divider_2/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C3010 divider_2/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C3011 divider_2/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C3012 divider_2/prescaler_0/Out vssa1 4.59fF
C3013 divider_2/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C3014 divider_2/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C3015 divider_2/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C3016 divider_2/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C3017 divider_2/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C3018 divider_2/nor_1/Z1 vssa1 1.34fF
C3019 divider_2/mc2 vssa1 5.29fF
C3020 divider_2/nor_0/Z1 vssa1 1.34fF
C3021 divbuf_16/OUT vssa1 363.82fF
C3022 divbuf_16/OUT5 vssa1 350.37fF
C3023 divbuf_16/OUT4 vssa1 133.72fF
C3024 divbuf_16/OUT3 vssa1 34.03fF
C3025 divbuf_16/OUT2 vssa1 8.71fF
C3026 divbuf_16/IN vssa1 0.89fF
C3027 divbuf_16/a_492_n240# vssa1 2.46fF **FLOATING
C3028 divider_1/and_0/Z1 vssa1 0.74fF
C3029 divider_1/and_0/B vssa1 2.25fF
C3030 divider_1/and_0/A vssa1 2.19fF
C3031 divider_1/and_0/out1 vssa1 2.93fF
C3032 divider_1/tspc_2/Z4 vssa1 0.86fF
C3033 divider_1/tspc_2/Z3 vssa1 2.26fF
C3034 divider_1/tspc_2/Z2 vssa1 1.46fF
C3035 divider_1/tspc_2/Z1 vssa1 0.99fF
C3036 divider_1/nor_0/A vssa1 7.04fF
C3037 divider_1/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C3038 divider_1/tspc_1/Z4 vssa1 0.86fF
C3039 divider_1/tspc_1/Z3 vssa1 2.26fF
C3040 divider_1/tspc_1/Z2 vssa1 1.46fF
C3041 divider_1/tspc_1/Z1 vssa1 0.99fF
C3042 divider_1/nor_0/B vssa1 7.05fF
C3043 divider_1/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C3044 divider_1/tspc_2/Q vssa1 3.14fF
C3045 divider_1/tspc_0/Z4 vssa1 0.86fF
C3046 divider_1/Out vssa1 1.60fF
C3047 divider_1/tspc_0/Z3 vssa1 2.26fF
C3048 divider_1/tspc_0/Z2 vssa1 1.46fF
C3049 divider_1/tspc_0/Z1 vssa1 0.99fF
C3050 divider_1/nor_1/B vssa1 6.33fF
C3051 divider_1/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C3052 divider_1/tspc_1/Q vssa1 3.12fF
C3053 divider_1/clk vssa1 5.63fF
C3054 divider_1/prescaler_0/nand_1/z1 vssa1 0.36fF
C3055 divider_1/prescaler_0/tspc_0/D vssa1 2.64fF
C3056 divider_1/prescaler_0/tspc_2/Q vssa1 3.74fF
C3057 divider_1/prescaler_0/tspc_1/Q vssa1 3.61fF
C3058 divider_1/prescaler_0/nand_0/z1 vssa1 0.36fF
C3059 divider_1/prescaler_0/tspc_2/D vssa1 3.12fF
C3060 divider_1/and_0/OUT vssa1 5.62fF
C3061 divider_1/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C3062 divider_1/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C3063 divider_1/prescaler_0/tspc_2/Z2 vssa1 1.46fF
C3064 divider_1/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C3065 divider_1/prescaler_0/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C3066 divider_1/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C3067 divider_1/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C3068 divider_1/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C3069 divider_1/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C3070 divider_1/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C3071 divider_1/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C3072 divider_1/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C3073 divider_1/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C3074 divider_1/prescaler_0/Out vssa1 4.59fF
C3075 divider_1/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C3076 divider_1/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C3077 divider_1/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C3078 divider_1/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C3079 divider_1/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C3080 divider_1/nor_1/Z1 vssa1 1.34fF
C3081 divider_1/mc2 vssa1 5.29fF
C3082 divider_1/nor_0/Z1 vssa1 1.34fF
C3083 divbuf_15/OUT vssa1 363.82fF
C3084 divbuf_15/OUT5 vssa1 350.37fF
C3085 divbuf_15/OUT4 vssa1 133.72fF
C3086 divbuf_15/OUT3 vssa1 34.03fF
C3087 divbuf_15/OUT2 vssa1 8.71fF
C3088 divbuf_15/IN vssa1 0.89fF
C3089 divbuf_15/a_492_n240# vssa1 2.46fF **FLOATING
C3090 divider_0/and_0/Z1 vssa1 0.74fF
C3091 divider_0/and_0/B vssa1 2.25fF
C3092 divider_0/and_0/A vssa1 2.19fF
C3093 divider_0/and_0/out1 vssa1 2.93fF
C3094 divider_0/tspc_2/Z4 vssa1 0.86fF
C3095 divider_0/tspc_2/Z3 vssa1 2.26fF
C3096 divider_0/tspc_2/Z2 vssa1 1.46fF
C3097 divider_0/tspc_2/Z1 vssa1 0.99fF
C3098 divider_0/nor_0/A vssa1 7.04fF
C3099 divider_0/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C3100 divider_0/tspc_1/Z4 vssa1 0.86fF
C3101 divider_0/tspc_1/Z3 vssa1 2.26fF
C3102 divider_0/tspc_1/Z2 vssa1 1.46fF
C3103 divider_0/tspc_1/Z1 vssa1 0.99fF
C3104 divider_0/nor_0/B vssa1 7.05fF
C3105 divider_0/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C3106 divider_0/tspc_2/Q vssa1 3.14fF
C3107 divider_0/tspc_0/Z4 vssa1 0.86fF
C3108 divider_0/Out vssa1 1.60fF
C3109 divider_0/tspc_0/Z3 vssa1 2.26fF
C3110 divider_0/tspc_0/Z2 vssa1 1.46fF
C3111 divider_0/tspc_0/Z1 vssa1 0.99fF
C3112 divider_0/nor_1/B vssa1 6.33fF
C3113 divider_0/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C3114 divider_0/tspc_1/Q vssa1 3.12fF
C3115 divider_0/clk vssa1 5.63fF
C3116 divider_0/prescaler_0/nand_1/z1 vssa1 0.36fF
C3117 divider_0/prescaler_0/tspc_0/D vssa1 2.64fF
C3118 divider_0/prescaler_0/tspc_2/Q vssa1 3.64fF
C3119 divider_0/prescaler_0/tspc_1/Q vssa1 3.61fF
C3120 divider_0/prescaler_0/nand_0/z1 vssa1 0.36fF
C3121 divider_0/prescaler_0/tspc_2/D vssa1 3.12fF
C3122 divider_0/and_0/OUT vssa1 5.62fF
C3123 divider_0/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C3124 divider_0/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C3125 divider_0/prescaler_0/tspc_2/Z2 vssa1 1.46fF
C3126 divider_0/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C3127 divider_0/prescaler_0/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C3128 divider_0/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C3129 divider_0/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C3130 divider_0/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C3131 divider_0/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C3132 divider_0/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C3133 divider_0/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C3134 divider_0/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C3135 divider_0/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C3136 divider_0/prescaler_0/Out vssa1 4.59fF
C3137 divider_0/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C3138 divider_0/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C3139 divider_0/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C3140 divider_0/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C3141 divider_0/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C3142 divider_0/nor_1/Z1 vssa1 1.34fF
C3143 divider_0/mc2 vssa1 5.29fF
C3144 divider_0/nor_0/Z1 vssa1 1.34fF
C3145 divbuf_14/OUT vssa1 363.82fF
C3146 divbuf_14/OUT5 vssa1 350.37fF
C3147 divbuf_14/OUT4 vssa1 133.72fF
C3148 divbuf_14/OUT3 vssa1 34.03fF
C3149 divbuf_14/OUT2 vssa1 8.71fF
C3150 divbuf_14/IN vssa1 0.89fF
C3151 divbuf_14/a_492_n240# vssa1 2.46fF **FLOATING
C3152 divbuf_25/OUT vssa1 363.82fF
C3153 divbuf_25/OUT5 vssa1 350.37fF
C3154 divbuf_25/OUT4 vssa1 133.72fF
C3155 divbuf_25/OUT3 vssa1 34.03fF
C3156 divbuf_25/OUT2 vssa1 8.71fF
C3157 divbuf_25/IN vssa1 0.89fF
C3158 divbuf_25/a_492_n240# vssa1 2.46fF **FLOATING
C3159 divbuf_9/OUT vssa1 363.82fF
C3160 divbuf_9/OUT5 vssa1 350.37fF
C3161 divbuf_9/OUT4 vssa1 133.72fF
C3162 divbuf_9/OUT3 vssa1 34.03fF
C3163 divbuf_9/OUT2 vssa1 8.71fF
C3164 divbuf_9/IN vssa1 0.89fF
C3165 divbuf_9/a_492_n240# vssa1 2.46fF **FLOATING
C3166 divbuf_13/OUT vssa1 363.82fF
C3167 divbuf_13/OUT5 vssa1 350.37fF
C3168 divbuf_13/OUT4 vssa1 133.72fF
C3169 divbuf_13/OUT3 vssa1 34.03fF
C3170 divbuf_13/OUT2 vssa1 8.71fF
C3171 divbuf_13/IN vssa1 0.89fF
C3172 divbuf_13/a_492_n240# vssa1 2.46fF **FLOATING
C3173 divbuf_24/OUT vssa1 363.82fF
C3174 divbuf_24/OUT5 vssa1 350.37fF
C3175 divbuf_24/OUT4 vssa1 133.72fF
C3176 divbuf_24/OUT3 vssa1 34.03fF
C3177 divbuf_24/OUT2 vssa1 8.71fF
C3178 divbuf_24/IN vssa1 0.89fF
C3179 divbuf_24/a_492_n240# vssa1 2.46fF **FLOATING
C3180 divbuf_12/OUT vssa1 363.82fF
C3181 divbuf_12/OUT5 vssa1 350.37fF
C3182 divbuf_12/OUT4 vssa1 133.72fF
C3183 divbuf_12/OUT3 vssa1 34.03fF
C3184 divbuf_12/OUT2 vssa1 8.71fF
C3185 divbuf_12/IN vssa1 0.89fF
C3186 divbuf_12/a_492_n240# vssa1 2.46fF **FLOATING
C3187 divbuf_8/OUT vssa1 363.82fF
C3188 divbuf_8/OUT5 vssa1 350.37fF
C3189 divbuf_8/OUT4 vssa1 133.72fF
C3190 divbuf_8/OUT3 vssa1 34.03fF
C3191 divbuf_8/OUT2 vssa1 8.71fF
C3192 divbuf_8/IN vssa1 0.89fF
C3193 divbuf_8/a_492_n240# vssa1 2.46fF **FLOATING
C3194 divbuf_23/OUT5 vssa1 350.37fF
C3195 divbuf_23/OUT4 vssa1 133.72fF
C3196 divbuf_23/OUT3 vssa1 34.03fF
C3197 divbuf_23/OUT2 vssa1 8.71fF
C3198 divbuf_23/IN vssa1 0.89fF
C3199 divbuf_23/a_492_n240# vssa1 2.46fF **FLOATING
C3200 divbuf_7/OUT vssa1 363.82fF
C3201 divbuf_7/OUT5 vssa1 350.37fF
C3202 divbuf_7/OUT4 vssa1 133.72fF
C3203 divbuf_7/OUT3 vssa1 34.03fF
C3204 divbuf_7/OUT2 vssa1 8.71fF
C3205 divbuf_7/IN vssa1 0.89fF
C3206 divbuf_7/a_492_n240# vssa1 2.46fF **FLOATING
C3207 divbuf_11/OUT vssa1 363.82fF
C3208 divbuf_11/OUT5 vssa1 350.37fF
C3209 divbuf_11/OUT4 vssa1 133.72fF
C3210 divbuf_11/OUT3 vssa1 34.03fF
C3211 divbuf_11/OUT2 vssa1 8.71fF
C3212 divbuf_11/IN vssa1 0.89fF
C3213 divbuf_11/a_492_n240# vssa1 2.46fF **FLOATING
C3214 divbuf_22/OUT5 vssa1 350.37fF
C3215 divbuf_22/OUT4 vssa1 133.72fF
C3216 divbuf_22/OUT3 vssa1 34.03fF
C3217 divbuf_22/OUT2 vssa1 8.71fF
C3218 divbuf_22/IN vssa1 0.89fF
C3219 divbuf_22/a_492_n240# vssa1 2.46fF **FLOATING
C3220 divbuf_6/OUT vssa1 363.82fF
C3221 divbuf_6/OUT5 vssa1 350.37fF
C3222 divbuf_6/OUT4 vssa1 133.72fF
C3223 divbuf_6/OUT3 vssa1 34.03fF
C3224 divbuf_6/OUT2 vssa1 8.71fF
C3225 divbuf_6/IN vssa1 0.89fF
C3226 divbuf_6/a_492_n240# vssa1 2.46fF **FLOATING
C3227 divbuf_10/OUT vssa1 363.82fF
C3228 divbuf_10/OUT5 vssa1 350.37fF
C3229 divbuf_10/OUT4 vssa1 133.72fF
C3230 divbuf_10/OUT3 vssa1 34.03fF
C3231 divbuf_10/OUT2 vssa1 8.71fF
C3232 divbuf_10/IN vssa1 0.89fF
C3233 divbuf_10/a_492_n240# vssa1 2.46fF **FLOATING
C3234 divbuf_21/OUT5 vssa1 350.37fF
C3235 divbuf_21/OUT4 vssa1 133.72fF
C3236 divbuf_21/OUT3 vssa1 34.03fF
C3237 divbuf_21/OUT2 vssa1 8.71fF
C3238 divbuf_21/IN vssa1 0.89fF
C3239 divbuf_21/a_492_n240# vssa1 2.46fF **FLOATING
C3240 divbuf_20/OUT5 vssa1 350.37fF
C3241 divbuf_20/OUT4 vssa1 133.72fF
C3242 divbuf_20/OUT3 vssa1 34.03fF
C3243 divbuf_20/OUT2 vssa1 8.71fF
C3244 divbuf_20/IN vssa1 0.89fF
C3245 divbuf_20/a_492_n240# vssa1 2.46fF **FLOATING
C3246 divbuf_5/OUT vssa1 363.82fF
C3247 divbuf_5/OUT5 vssa1 350.37fF
C3248 divbuf_5/OUT4 vssa1 133.72fF
C3249 divbuf_5/OUT3 vssa1 34.03fF
C3250 divbuf_5/OUT2 vssa1 8.71fF
C3251 divbuf_5/IN vssa1 0.89fF
C3252 divbuf_5/a_492_n240# vssa1 2.46fF **FLOATING
C3253 divbuf_4/OUT vssa1 363.82fF
C3254 divbuf_4/OUT5 vssa1 350.37fF
C3255 divbuf_4/OUT4 vssa1 133.72fF
C3256 divbuf_4/OUT3 vssa1 34.03fF
C3257 divbuf_4/OUT2 vssa1 8.71fF
C3258 divbuf_4/IN vssa1 0.89fF
C3259 divbuf_4/a_492_n240# vssa1 2.46fF **FLOATING
C3260 divbuf_3/OUT vssa1 363.82fF
C3261 divbuf_3/OUT5 vssa1 350.37fF
C3262 divbuf_3/OUT4 vssa1 133.72fF
C3263 divbuf_3/OUT3 vssa1 34.03fF
C3264 divbuf_3/OUT2 vssa1 8.71fF
C3265 divbuf_3/IN vssa1 0.89fF
C3266 divbuf_3/a_492_n240# vssa1 2.46fF **FLOATING
C3267 divbuf_2/OUT vssa1 363.82fF
C3268 divbuf_2/OUT5 vssa1 350.37fF
C3269 divbuf_2/OUT4 vssa1 133.72fF
C3270 divbuf_2/OUT3 vssa1 34.03fF
C3271 divbuf_2/OUT2 vssa1 8.71fF
C3272 divbuf_2/IN vssa1 0.89fF
C3273 divbuf_2/a_492_n240# vssa1 2.46fF **FLOATING
C3274 divbuf_1/OUT vssa1 363.82fF
C3275 divbuf_1/OUT5 vssa1 350.37fF
C3276 divbuf_1/OUT4 vssa1 133.72fF
C3277 divbuf_1/OUT3 vssa1 34.03fF
C3278 divbuf_1/OUT2 vssa1 8.71fF
C3279 divbuf_1/IN vssa1 0.89fF
C3280 divbuf_1/a_492_n240# vssa1 2.46fF **FLOATING
C3281 divbuf_0/OUT5 vssa1 350.37fF
C3282 divbuf_0/OUT4 vssa1 133.72fF
C3283 divbuf_0/OUT3 vssa1 34.03fF
C3284 divbuf_0/OUT2 vssa1 8.71fF
C3285 divbuf_0/IN vssa1 0.89fF
C3286 divbuf_0/a_492_n240# vssa1 2.46fF **FLOATING
C3287 ro_complete_1/cbank_2/v vssa1 16.43fF
C3288 ro_complete_1/cbank_2/switch_5/vin vssa1 0.78fF
C3289 ro_complete_1/cbank_2/switch_4/vin vssa1 1.50fF
C3290 ro_complete_1/cbank_2/switch_2/vin vssa1 1.30fF
C3291 ro_complete_1/cbank_2/switch_3/vin vssa1 0.56fF
C3292 ro_complete_1/cbank_2/switch_1/vin vssa1 1.14fF
C3293 ro_complete_1/cbank_2/switch_0/vin vssa1 1.02fF
C3294 ro_complete_1/cbank_1/v vssa1 16.43fF
C3295 ro_complete_1/cbank_1/switch_5/vin vssa1 0.78fF
C3296 ro_complete_1/a0 vssa1 5.35fF
C3297 ro_complete_1/cbank_1/switch_4/vin vssa1 1.50fF
C3298 ro_complete_1/a1 vssa1 6.54fF
C3299 ro_complete_1/cbank_1/switch_2/vin vssa1 1.30fF
C3300 ro_complete_1/a3 vssa1 5.96fF
C3301 ro_complete_1/cbank_1/switch_3/vin vssa1 0.56fF
C3302 ro_complete_1/a2 vssa1 5.21fF
C3303 ro_complete_1/cbank_1/switch_1/vin vssa1 1.14fF
C3304 ro_complete_1/a4 vssa1 5.81fF
C3305 ro_complete_1/cbank_1/switch_0/vin vssa1 1.02fF
C3306 ro_complete_1/a5 vssa1 6.74fF
C3307 ro_complete_1/cbank_0/v vssa1 15.12fF
C3308 ro_complete_1/cbank_0/switch_5/vin vssa1 0.78fF
C3309 ro_complete_1/cbank_0/switch_4/vin vssa1 1.50fF
C3310 ro_complete_1/cbank_0/switch_2/vin vssa1 1.30fF
C3311 ro_complete_1/cbank_0/switch_3/vin vssa1 0.56fF
C3312 ro_complete_1/cbank_0/switch_1/vin vssa1 1.14fF
C3313 ro_complete_1/cbank_0/switch_0/vin vssa1 1.02fF
C3314 ro_complete_1/ro_var_extend_0/vcont vssa1 0.27fF
C3315 ro_complete_0/cbank_2/v vssa1 16.43fF
C3316 ro_complete_0/cbank_2/switch_5/vin vssa1 0.78fF
C3317 ro_complete_0/cbank_2/switch_4/vin vssa1 1.50fF
C3318 ro_complete_0/cbank_2/switch_2/vin vssa1 1.30fF
C3319 ro_complete_0/cbank_2/switch_3/vin vssa1 0.56fF
C3320 ro_complete_0/cbank_2/switch_1/vin vssa1 1.14fF
C3321 ro_complete_0/cbank_2/switch_0/vin vssa1 1.02fF
C3322 ro_complete_0/cbank_1/v vssa1 16.46fF
C3323 ro_complete_0/cbank_1/switch_5/vin vssa1 0.78fF
C3324 divbuf_18/OUT vssa1 405.76fF
C3325 ro_complete_0/cbank_1/switch_4/vin vssa1 1.50fF
C3326 divbuf_19/OUT vssa1 402.77fF
C3327 ro_complete_0/cbank_1/switch_2/vin vssa1 1.30fF
C3328 divbuf_22/OUT vssa1 394.74fF
C3329 ro_complete_0/cbank_1/switch_3/vin vssa1 0.56fF
C3330 divbuf_20/OUT vssa1 397.92fF
C3331 ro_complete_0/cbank_1/switch_1/vin vssa1 1.14fF
C3332 divbuf_21/OUT vssa1 391.26fF
C3333 ro_complete_0/cbank_1/switch_0/vin vssa1 1.02fF
C3334 divbuf_23/OUT vssa1 387.66fF
C3335 ro_complete_0/cbank_0/v vssa1 15.12fF
C3336 ro_complete_0/cbank_0/switch_5/vin vssa1 0.78fF
C3337 ro_complete_0/cbank_0/switch_4/vin vssa1 1.50fF
C3338 ro_complete_0/cbank_0/switch_2/vin vssa1 1.30fF
C3339 ro_complete_0/cbank_0/switch_3/vin vssa1 0.56fF
C3340 ro_complete_0/cbank_0/switch_1/vin vssa1 1.14fF
C3341 ro_complete_0/cbank_0/switch_0/vin vssa1 1.02fF
C3342 ro_complete_0/ro_var_extend_0/vcont vssa1 0.27fF
C3343 filter_0/v vssa1 477.90fF
C3344 filter_0/a_4216_n5230# vssa1 418.47fF **FLOATING
C3345 filter_0/a_4216_n2998# vssa1 1.03fF **FLOATING
C3346 cp_0/down vssa1 1.54fF
C3347 cp_0/vbias vssa1 2.41fF
C3348 cp_0/out vssa1 5.34fF
C3349 cp_0/upbar vssa1 1.50fF
C3350 cp_0/a_7110_n2840# vssa1 0.17fF **FLOATING
C3351 cp_0/a_3060_n2840# vssa1 1.71fF **FLOATING
C3352 cp_0/a_7110_0# vssa1 0.17fF **FLOATING
C3353 cp_0/a_6370_0# vssa1 0.40fF **FLOATING
C3354 cp_0/a_3060_0# vssa1 1.66fF **FLOATING
C3355 cp_0/a_1710_0# vssa1 5.89fF **FLOATING
C3356 cp_0/a_1710_n2840# vssa1 4.91fF **FLOATING
C3357 cp_0/a_10_n50# vssa1 2.96fF **FLOATING
C3358 pd_1/and_pd_0/Z1 vssa1 0.39fF
C3359 pd_1/and_pd_0/Out1 vssa1 2.22fF
C3360 pd_1/tspc_r_1/z5 vssa1 1.10fF
C3361 pd_1/tspc_r_1/Z4 vssa1 1.07fF
C3362 pd_1/tspc_r_1/Qbar vssa1 0.88fF
C3363 pd_1/tspc_r_1/Z2 vssa1 1.22fF
C3364 pd_1/tspc_r_1/Z1 vssa1 0.67fF
C3365 pd_1/UP vssa1 2.21fF
C3366 pd_1/tspc_r_1/Qbar1 vssa1 1.34fF
C3367 pd_1/tspc_r_1/Z3 vssa1 2.12fF
C3368 pd_1/REF vssa1 1.80fF
C3369 pd_1/tspc_r_0/z5 vssa1 1.10fF
C3370 pd_1/tspc_r_0/Z4 vssa1 1.07fF
C3371 pd_1/R vssa1 3.05fF
C3372 pd_1/tspc_r_0/Qbar vssa1 0.79fF
C3373 pd_1/tspc_r_0/Z2 vssa1 1.22fF
C3374 pd_1/tspc_r_0/Z1 vssa1 0.67fF
C3375 pd_1/DOWN vssa1 3.08fF
C3376 pd_1/tspc_r_0/Qbar1 vssa1 1.34fF
C3377 pd_1/tspc_r_0/Z3 vssa1 2.12fF
C3378 pd_1/DIV vssa1 1.82fF
C3379 pd_0/and_pd_0/Z1 vssa1 0.39fF
C3380 pd_0/and_pd_0/Out1 vssa1 2.22fF
C3381 pd_0/tspc_r_1/z5 vssa1 1.10fF
C3382 pd_0/tspc_r_1/Z4 vssa1 1.07fF
C3383 pd_0/tspc_r_1/Qbar vssa1 0.88fF
C3384 pd_0/tspc_r_1/Z2 vssa1 1.22fF
C3385 pd_0/tspc_r_1/Z1 vssa1 0.67fF
C3386 pd_0/UP vssa1 2.21fF
C3387 pd_0/tspc_r_1/Qbar1 vssa1 1.34fF
C3388 pd_0/tspc_r_1/Z3 vssa1 2.12fF
C3389 pd_0/REF vssa1 1.80fF
C3390 pd_0/tspc_r_0/z5 vssa1 1.10fF
C3391 pd_0/tspc_r_0/Z4 vssa1 1.07fF
C3392 pd_0/R vssa1 3.05fF
C3393 pd_0/tspc_r_0/Qbar vssa1 0.79fF
C3394 pd_0/tspc_r_0/Z2 vssa1 1.22fF
C3395 pd_0/tspc_r_0/Z1 vssa1 0.67fF
C3396 pd_0/DOWN vssa1 3.08fF
C3397 pd_0/tspc_r_0/Qbar1 vssa1 1.34fF
C3398 pd_0/tspc_r_0/Z3 vssa1 2.12fF
C3399 pd_0/DIV vssa1 1.82fF
.ends
