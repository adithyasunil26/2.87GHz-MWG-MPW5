* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[5] io_analog[6] io_analog[7]
+ io_analog[8] io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
C0 cp_buffered_0/tapered_buf_1/a_n10_230# cp_buffered_0/tapered_buf_1/a_160_230# 0.09fF
C1 cp_buffered_0/tapered_buf_1/a_4670_0# cp_buffered_0/tapered_buf_1/a_210_n610# 29.21fF
C2 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z4 0.00fF
C3 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/a1 0.14fF
C4 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/v 1.30fF
C5 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/a3 0.09fF
C6 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C7 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_1/vin ro_complete_buffered_0/ro_complete_0/a3 0.13fF
C8 ro_complete_buffered_0/tapered_buf_0/a_n10_230# ro_complete_buffered_0/tapered_buf_0/a_n10_n140# 0.01fF
C9 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_3/vin ro_complete_buffered_0/ro_complete_0/a1 0.14fF
C10 cp_buffered_0/tapered_buf_2/a_160_230# cp_buffered_0/tapered_buf_2/a_160_n140# 0.17fF
C11 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/and_0/OUT 0.06fF
C12 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.38fF
C13 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.11fF
C14 pll_full_1/ro_complete_0/cbank_1/switch_4/vin pll_full_1/vco 1.46fF
C15 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D div_pd_buffered_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C16 div_pd_buffered_0/tapered_buf_2/a_160_n140# div_pd_buffered_0/tapered_buf_2/a_160_230# 0.17fF
C17 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/div 0.65fF
C18 ro_complete_buffered_0/tapered_buf_2/a_210_n610# ro_complete_buffered_0/tapered_buf_2/a_4670_0# 29.21fF
C19 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/A 0.01fF
C20 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_0/Q 0.05fF
C21 pd_buffered_0/tapered_buf_3/a_210_n610# pd_buffered_0/tapered_buf_3/out 26.29fF
C22 pd_buffered_0/tapered_buf_2/a_n10_230# pd_buffered_0/tapered_buf_2/in 0.02fF
C23 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C24 divider_0/tspc_2/Z3 divider_0/tspc_2/Z4 0.65fF
C25 divider_1/nor_1/B divider_1/tspc_2/Z4 0.02fF
C26 cp_buffered_0/tapered_buf_2/in cp_buffered_0/tapered_buf_2/a_160_n140# 0.19fF
C27 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C28 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C29 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/vco 0.01fF
C30 divider_0/nor_0/Z1 divider_0/and_0/B 0.78fF
C31 cp_buffered_0/tapered_buf_0/a_n10_230# cp_buffered_0/tapered_buf_0/a_160_230# 0.09fF
C32 cp_buffered_0/tapered_buf_0/a_4670_0# cp_buffered_0/tapered_buf_0/a_210_n610# 29.21fF
C33 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/div 0.65fF
C34 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/tspc_0/Z2 0.11fF
C35 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/v 1.30fF
C36 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/cbank_0/v 1.30fF
C37 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C38 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_2/v 0.08fF
C39 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C40 div_pd_buffered_0/tapered_buf_3/a_4670_0# div_pd_buffered_0/tapered_buf_3/a_1650_0# 4.78fF
C41 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_4/vin ro_complete_buffered_0/ro_complete_0/a0 0.13fF
C42 ro_complete_buffered_0/ro_complete_0/a5 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C43 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/vco 0.01fF
C44 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D div_pd_buffered_0/divider_0/clk 0.26fF
C45 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z3 0.16fF
C46 cp_buffered_0/tapered_buf_2/a_1650_0# cp_buffered_0/tapered_buf_2/a_210_n610# 2.89fF
C47 pd_buffered_0/tapered_buf_3/a_160_n140# pd_buffered_0/tapered_buf_3/a_n10_n140# 0.05fF
C48 pd_buffered_0/tapered_buf_3/a_580_0# pd_buffered_0/tapered_buf_3/a_210_n610# 0.84fF
C49 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/div 0.12fF
C50 pd_buffered_0/pd_0/tspc_r_0/Z1 pd_buffered_0/pd_0/tspc_r_0/Z2 0.71fF
C51 pd_buffered_0/pd_0/tspc_r_0/Z3 pd_buffered_0/pd_0/tspc_r_0/Z4 0.20fF
C52 pd_buffered_0/pd_0/REF pd_buffered_0/pd_0/tspc_r_0/z5 0.04fF
C53 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C54 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z3 0.05fF
C55 divider_1/nor_0/B divider_1/tspc_2/Z1 0.03fF
C56 pll_full_0/ro_complete_0/cbank_2/v pll_full_0/vco 1.36fF
C57 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/pd_0/tspc_r_1/z5 0.03fF
C58 div_pd_buffered_0/pd_0/tspc_r_1/Z2 div_pd_buffered_0/pd_0/R 0.21fF
C59 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/UP 0.03fF
C60 ro_complete_buffered_0/tapered_buf_5/a_1650_0# ro_complete_buffered_0/tapered_buf_5/a_210_n610# 2.89fF
C61 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C62 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/div 0.12fF
C63 pll_full_1/ro_complete_0/cbank_2/switch_4/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C64 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z2 0.01fF
C65 ro_complete_buffered_0/ro_complete_0/a1 ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C66 divider_0/tspc_0/Z4 divider_0/tspc_0/Z3 0.65fF
C67 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/ref 0.65fF
C68 ro_complete_buffered_0/tapered_buf_5/a_580_0# ro_complete_buffered_0/tapered_buf_5/a_1650_0# 1.27fF
C69 cp_buffered_0/tapered_buf_2/a_n10_n140# cp_buffered_0/tapered_buf_2/a_160_n140# 0.05fF
C70 pd_buffered_0/tapered_buf_0/a_1650_0# pd_buffered_0/tapered_buf_0/a_4670_0# 4.78fF
C71 pd_buffered_0/tapered_buf_0/a_160_n140# pd_buffered_0/tapered_buf_0/a_160_230# 0.17fF
C72 pd_buffered_0/pd_0/tspc_r_0/Z4 pd_buffered_0/pd_0/tspc_r_1/Z4 0.02fF
C73 pd_buffered_0/pd_0/tspc_r_1/Qbar1 pd_buffered_0/pd_0/DOWN 0.11fF
C74 pd_buffered_0/pd_0/DIV pd_buffered_0/pd_0/tspc_r_1/Z1 0.17fF
C75 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/ref 0.02fF
C76 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/a_630_n680# 0.35fF
C77 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C78 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C79 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_0/B 0.06fF
C80 div_pd_buffered_0/tapered_buf_4/a_n10_n140# div_pd_buffered_0/tapered_buf_4/a_160_n140# 0.05fF
C81 cp_buffered_0/cp_0/a_1710_n2840# cp_buffered_0/cp_0/out 0.61fF
C82 pll_full_1/pd_0/tspc_r_0/Qbar pll_full_1/pd_0/UP 0.21fF
C83 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/tspc_0/Z4 0.12fF
C84 ro_complete_buffered_0/tapered_buf_6/a_1650_0# ro_complete_buffered_0/tapered_buf_6/a_210_n610# 2.89fF
C85 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C86 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/Z4 0.36fF
C87 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_1/Q 0.05fF
C88 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C89 divider_1/tspc_0/Q divider_1/tspc_0/a_630_n680# 0.04fF
C90 divider_0/and_0/OUT divider_0/and_0/B 0.01fF
C91 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C92 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C93 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C94 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C95 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C96 pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_0/vco 1.46fF
C97 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/D 0.03fF
C98 divider_0/nor_1/A divider_0/prescaler_0/tspc_1/Q 0.03fF
C99 pll_full_0/pd_0/tspc_r_0/Qbar pll_full_0/pd_0/DOWN 0.02fF
C100 div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 div_pd_buffered_0/pd_0/tspc_r_0/Qbar 0.01fF
C101 ro_complete_buffered_0/tapered_buf_7/a_1650_0# ro_complete_buffered_0/tapered_buf_7/a_210_n610# 2.89fF
C102 ro_complete_0/a3 ro_complete_0/cbank_2/switch_1/vin 0.13fF
C103 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C104 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C105 div_pd_buffered_0/divider_0/tspc_1/Q div_pd_buffered_0/divider_0/tspc_2/Z4 0.15fF
C106 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/tapered_buf_1/in 0.05fF
C107 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_4/vin ro_complete_buffered_0/ro_complete_0/a0 0.13fF
C108 divider_0/tspc_0/Z4 divider_0/tspc_0/Z2 0.36fF
C109 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_1/Q 0.13fF
C110 divider_0/prescaler_0/m1_2700_2190# divider_0/and_0/OUT 0.14fF
C111 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C112 divider_0/nor_1/B divider_0/and_0/A 0.26fF
C113 pll_full_1/pd_0/R pll_full_1/pd_0/tspc_r_1/Z3 0.27fF
C114 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/D 0.05fF
C115 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C116 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C117 div_pd_buffered_0/tapered_buf_3/a_210_n610# div_pd_buffered_0/divider_0/mc2 26.29fF
C118 divider_0/nor_1/A divider_0/tspc_0/Q 0.55fF
C119 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 0.38fF
C120 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C121 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C122 ro_complete_buffered_0/tapered_buf_4/a_160_n140# ro_complete_buffered_0/tapered_buf_4/in 0.19fF
C123 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/v 1.30fF
C124 pll_full_1/ro_complete_0/cbank_0/v pll_full_1/ro_complete_0/cbank_2/v 0.04fF
C125 div_pd_buffered_0/divider_0/tspc_2/Z2 div_pd_buffered_0/divider_0/tspc_2/Z4 0.36fF
C126 divider_0/nor_1/B divider_0/tspc_1/Z3 0.38fF
C127 divider_0/prescaler_0/tspc_1/Z4 divider_0/prescaler_0/tspc_1/a_630_n680# 0.12fF
C128 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_0/vin ro_complete_buffered_0/tapered_buf_1/in 1.43fF
C129 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_0/Q 0.01fF
C130 divider_0/prescaler_0/Out divider_0/tspc_0/Z3 0.45fF
C131 divider_0/prescaler_0/tspc_0/Z4 divider_0/clk 0.12fF
C132 pd_buffered_0/tapered_buf_2/a_160_230# pd_buffered_0/tapered_buf_2/a_580_0# 0.02fF
C133 pll_full_1/pd_0/R pll_full_1/pd_0/tspc_r_1/Qbar1 0.01fF
C134 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/R 0.30fF
C135 divider_1/tspc_1/Z1 divider_1/tspc_1/Z2 1.07fF
C136 pd_buffered_0/tapered_buf_0/a_160_n140# pd_buffered_0/tapered_buf_0/in 0.19fF
C137 pd_buffered_0/pd_0/tspc_r_0/Z3 pd_buffered_0/pd_0/R 0.29fF
C138 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z3 0.16fF
C139 pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C140 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z4 0.12fF
C141 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C142 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/vco 0.11fF
C143 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C144 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C145 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z4 0.20fF
C146 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C147 ro_complete_buffered_0/tapered_buf_4/a_n10_230# ro_complete_buffered_0/tapered_buf_4/a_n10_n140# 0.01fF
C148 pd_buffered_0/tapered_buf_2/a_160_n140# pd_buffered_0/tapered_buf_2/a_210_n610# 0.22fF
C149 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/nor_1/B 0.38fF
C150 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/tspc_0/Z1 0.00fF
C151 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C152 pll_full_1/ro_complete_0/a2 pll_full_1/vco 0.11fF
C153 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C154 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z4 0.12fF
C155 divider_0/nor_1/B divider_0/tspc_1/Z4 0.21fF
C156 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_4/vin ro_complete_buffered_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C157 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z3 0.05fF
C158 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_2/Z1 0.03fF
C159 divider_1/tspc_0/Q divider_1/nor_1/A 0.55fF
C160 divider_0/prescaler_0/tspc_0/D divider_0/prescaler_0/nand_1/z1 0.21fF
C161 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C162 cp_buffered_0/tapered_buf_1/a_n10_230# cp_buffered_0/tapered_buf_1/a_n10_n140# 0.01fF
C163 cp_buffered_0/cp_0/a_1710_0# cp_buffered_0/cp_0/down 0.32fF
C164 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divider_0/tspc_2/Z4 0.65fF
C165 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# 0.01fF
C166 pll_full_1/pd_0/tspc_r_1/Z4 pll_full_1/div 0.02fF
C167 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/a1 0.14fF
C168 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/tspc_2/Z4 0.02fF
C169 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C170 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 div_pd_buffered_0/divider_0/clk 0.45fF
C171 ro_complete_buffered_0/tapered_buf_0/a_160_n140# ro_complete_buffered_0/tapered_buf_0/in 0.19fF
C172 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C173 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C174 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.04fF
C175 pll_full_1/ro_complete_0/cbank_1/switch_0/vin pll_full_1/vco 1.58fF
C176 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/UP 0.33fF
C177 div_pd_buffered_0/tapered_buf_3/a_580_0# div_pd_buffered_0/tapered_buf_3/a_160_n140# 0.35fF
C178 divider_0/prescaler_0/Out divider_0/tspc_0/Z2 0.11fF
C179 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/v 1.30fF
C180 divider_1/prescaler_0/tspc_0/Z2 divider_1/and_0/OUT 0.06fF
C181 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.21fF
C182 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C183 divider_1/tspc_1/Q divider_1/tspc_2/Z1 0.01fF
C184 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C185 cp_buffered_0/tapered_buf_0/a_n10_230# cp_buffered_0/tapered_buf_0/a_n10_n140# 0.01fF
C186 div_pd_buffered_0/tapered_buf_1/a_580_0# div_pd_buffered_0/tapered_buf_1/a_1650_0# 1.27fF
C187 ro_complete_0/a5 ro_complete_0/cbank_2/switch_0/vin 0.09fF
C188 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C189 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/tspc_0/Z3 0.65fF
C190 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/tspc_2/D 0.03fF
C191 pd_buffered_0/tapered_buf_3/a_4670_0# pd_buffered_0/tapered_buf_3/a_210_n610# 29.21fF
C192 div_pd_buffered_0/tapered_buf_2/a_4670_0# div_pd_buffered_0/tapered_buf_2/a_210_n610# 29.21fF
C193 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z4 0.36fF
C194 div_pd_buffered_0/tapered_buf_3/a_210_n610# div_pd_buffered_0/tapered_buf_3/a_160_n140# 0.22fF
C195 divider_1/mc2 divider_1/and_0/A 0.16fF
C196 pd_buffered_0/pd_0/tspc_r_0/Qbar1 pd_buffered_0/pd_0/tspc_r_0/z5 0.20fF
C197 pll_full_1/pd_0/R pll_full_1/pd_0/UP 0.46fF
C198 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C199 pll_full_0/ro_complete_0/a1 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C200 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z4 0.12fF
C201 divider_1/tspc_2/Z1 divider_1/tspc_2/Z2 1.07fF
C202 divider_1/nor_0/B divider_1/tspc_2/Z3 0.38fF
C203 div_pd_buffered_0/pd_0/tspc_r_1/Z2 div_pd_buffered_0/pd_0/tspc_r_1/Z4 0.14fF
C204 pll_full_1/ro_complete_0/cbank_2/switch_0/vin pll_full_1/ro_complete_0/cbank_2/v 1.45fF
C205 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/and_0/A 0.16fF
C206 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/and_0/OUT 0.14fF
C207 divider_0/nor_1/Z1 divider_0/and_0/A 0.80fF
C208 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_5/vin ro_complete_buffered_0/tapered_buf_1/in 1.30fF
C209 pd_buffered_0/tapered_buf_3/a_160_n140# pd_buffered_0/pd_0/DOWN 0.19fF
C210 divider_1/tspc_0/Q divider_1/tspc_0/Z3 0.05fF
C211 divider_0/prescaler_0/tspc_1/Z2 divider_0/clk 0.11fF
C212 ro_complete_buffered_0/tapered_buf_5/a_160_n140# ro_complete_buffered_0/tapered_buf_5/a_160_230# 0.17fF
C213 divider_1/tspc_1/Z1 divider_1/tspc_1/Z4 0.00fF
C214 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z2 0.01fF
C215 pd_buffered_0/tapered_buf_0/a_160_n140# pd_buffered_0/tapered_buf_0/a_n10_n140# 0.05fF
C216 pd_buffered_0/tapered_buf_0/a_580_0# pd_buffered_0/tapered_buf_0/a_210_n610# 0.84fF
C217 pd_buffered_0/tapered_buf_1/a_160_230# pd_buffered_0/tapered_buf_1/a_160_n140# 0.17fF
C218 pd_buffered_0/pd_0/tspc_r_0/z5 pd_buffered_0/pd_0/tspc_r_1/z5 0.02fF
C219 pd_buffered_0/pd_0/tspc_r_1/Z3 pd_buffered_0/pd_0/tspc_r_1/Z2 0.25fF
C220 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C221 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C222 io_clamp_high[0] io_analog[4] 0.53fF
C223 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/tspc_r_0/Z2 0.71fF
C224 divider_1/and_0/out1 divider_1/and_0/Z1 0.36fF
C225 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/B 0.01fF
C226 ro_complete_buffered_0/tapered_buf_6/a_160_n140# ro_complete_buffered_0/tapered_buf_6/in 0.19fF
C227 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C228 pll_full_1/ro_complete_0/cbank_0/switch_2/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C229 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.01fF
C230 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.21fF
C231 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/a3 3.17fF
C232 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C233 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.03fF
C234 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/tspc_0/Z2 0.36fF
C235 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C236 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 div_pd_buffered_0/divider_0/clk 0.12fF
C237 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z2 0.19fF
C238 pll_full_1/div pll_full_1/vco 2.26fF
C239 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/a0 0.13fF
C240 divider_1/and_0/OUT divider_1/prescaler_0/nand_0/z1 0.01fF
C241 pd_buffered_0/pd_0/DOWN pd_buffered_0/pd_0/UP 1.06fF
C242 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C243 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C244 div_pd_buffered_0/pd_0/tspc_r_0/Z1 div_pd_buffered_0/pd_0/tspc_r_0/Z2 0.71fF
C245 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/tspc_r_0/Z4 0.20fF
C246 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/tspc_r_0/z5 0.04fF
C247 ro_complete_buffered_0/tapered_buf_7/a_160_n140# ro_complete_buffered_0/tapered_buf_7/in 0.19fF
C248 ro_complete_0/a2 ro_complete_0/cbank_1/v 0.05fF
C249 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/a0 0.13fF
C250 ro_complete_buffered_0/tapered_buf_1/a_n10_230# ro_complete_buffered_0/tapered_buf_1/in 0.02fF
C251 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C252 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/tspc_0/Q 0.55fF
C253 pll_full_1/ro_complete_0/cbank_1/switch_5/vin pll_full_1/vco 1.46fF
C254 div_pd_buffered_0/tapered_buf_0/a_580_0# div_pd_buffered_0/tapered_buf_0/a_210_n610# 0.84fF
C255 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 div_pd_buffered_0/divider_0/clk 0.45fF
C256 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/DOWN 0.12fF
C257 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/D 0.11fF
C258 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_1/Q 0.21fF
C259 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_2/D 0.16fF
C260 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/D 0.03fF
C261 pd_buffered_0/pd_0/REF pd_buffered_0/pd_0/tspc_r_0/Qbar1 0.12fF
C262 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_1/B 0.18fF
C263 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_0/Z4 0.12fF
C264 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.19fF
C265 divider_1/nor_1/A divider_1/tspc_0/a_630_n680# 0.35fF
C266 divider_0/and_0/out1 divider_0/and_0/A 0.01fF
C267 divider_0/tspc_0/Z3 divider_0/tspc_0/Q 0.05fF
C268 divider_1/and_0/OUT divider_1/clk 0.04fF
C269 filter_0/a_4216_n5230# filter_0/v 0.91fF
C270 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_0/Q 0.14fF
C271 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/vco 0.01fF
C272 divider_0/nor_1/A divider_0/and_0/A 0.01fF
C273 div_pd_buffered_0/tapered_buf_1/a_n10_n140# div_pd_buffered_0/tapered_buf_1/a_160_n140# 0.05fF
C274 div_pd_buffered_0/pd_0/tspc_r_0/Z4 div_pd_buffered_0/pd_0/tspc_r_1/Z4 0.02fF
C275 div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 div_pd_buffered_0/pd_0/DOWN 0.11fF
C276 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/tspc_r_1/Z1 0.17fF
C277 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/v 1.43fF
C278 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C279 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C280 ro_complete_buffered_0/ro_complete_0/a5 ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.08fF
C281 ro_complete_buffered_0/ro_complete_0/a0 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C282 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_2/Z1 0.01fF
C283 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_0/Q 0.22fF
C284 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C285 divider_1/tspc_1/Z2 divider_1/tspc_1/Z3 0.16fF
C286 pll_full_0/divider_0/and_0/OUT pll_full_0/div 0.01fF
C287 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C288 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C289 ro_complete_buffered_0/tapered_buf_1/a_n10_230# ro_complete_buffered_0/tapered_buf_1/a_160_230# 0.09fF
C290 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C291 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C292 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/and_0/A 0.80fF
C293 pll_full_1/ro_complete_0/cbank_2/switch_5/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C294 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/R 0.29fF
C295 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C296 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C297 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_4/vin ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C298 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z4 0.12fF
C299 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z2 1.07fF
C300 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_2/Z3 0.38fF
C301 div_pd_buffered_0/divider_0/and_0/B div_pd_buffered_0/divider_0/and_0/Z1 0.07fF
C302 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/Qbar1 0.38fF
C303 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C304 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C305 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C306 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/a_630_n680# 0.05fF
C307 filter_0/a_4216_n2998# filter_0/v 0.36fF
C308 pd_buffered_0/pd_0/DOWN pd_buffered_0/pd_0/and_pd_0/Out1 0.12fF
C309 pd_buffered_0/pd_0/tspc_r_0/Qbar pd_buffered_0/pd_0/UP 0.21fF
C310 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/B 0.78fF
C311 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/vco 1.46fF
C312 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/D 0.15fF
C313 divider_0/nor_1/A divider_0/tspc_1/Z4 0.02fF
C314 divider_0/mc2 divider_0/and_0/A 0.16fF
C315 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/tspc_0/a_630_n680# 0.01fF
C316 ro_complete_buffered_0/tapered_buf_2/a_160_230# ro_complete_buffered_0/tapered_buf_2/a_580_0# 0.02fF
C317 ro_complete_0/a4 ro_complete_0/cbank_2/switch_1/vin 0.09fF
C318 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/v 1.30fF
C319 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# 0.04fF
C320 divider_0/tspc_1/a_630_n680# divider_0/nor_1/B 0.35fF
C321 ro_complete_buffered_0/tapered_buf_0/a_160_n140# ro_complete_buffered_0/tapered_buf_0/a_160_230# 0.17fF
C322 ro_complete_buffered_0/tapered_buf_1/a_160_230# ro_complete_buffered_0/tapered_buf_1/a_580_0# 0.02fF
C323 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_1/Z4 0.12fF
C324 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C325 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/tspc_0/Z3 0.38fF
C326 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 div_pd_buffered_0/divider_0/clk 0.12fF
C327 divider_0/nor_1/B divider_0/tspc_2/Z4 0.02fF
C328 divider_0/tspc_0/Z4 divider_0/tspc_0/Z1 0.00fF
C329 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z2 1.07fF
C330 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/Z1 0.36fF
C331 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Z2 0.25fF
C332 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_0/Z2 0.14fF
C333 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C334 divider_1/tspc_0/Z3 divider_1/tspc_0/a_630_n680# 0.05fF
C335 divider_1/nor_1/Z1 divider_1/nor_1/B 0.06fF
C336 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/tspc_r_1/Qbar 0.01fF
C337 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/ref 0.12fF
C338 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C339 div_pd_buffered_0/tapered_buf_2/in div_pd_buffered_0/divider_0/mc2 0.02fF
C340 divider_1/tspc_1/Q divider_1/tspc_2/Z3 0.45fF
C341 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/R 0.29fF
C342 div_pd_buffered_0/tapered_buf_0/a_160_n140# div_pd_buffered_0/tapered_buf_0/a_580_0# 0.35fF
C343 div_pd_buffered_0/tapered_buf_1/out div_pd_buffered_0/tapered_buf_1/a_210_n610# 26.29fF
C344 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/and_0/OUT 0.06fF
C345 div_pd_buffered_0/divider_0/nor_1/Z1 div_pd_buffered_0/divider_0/nor_1/B 0.06fF
C346 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C347 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C348 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/nand_0/z1 0.01fF
C349 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/vco 0.11fF
C350 div_pd_buffered_0/divider_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/nor_0/B 0.35fF
C351 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q div_pd_buffered_0/divider_0/clk 0.60fF
C352 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/a_630_n680# 0.19fF
C353 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/Z1 0.06fF
C354 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C355 pd_buffered_0/pd_0/REF pd_buffered_0/pd_0/DIV 0.51fF
C356 divider_1/prescaler_0/tspc_1/Z2 divider_1/and_0/OUT 0.06fF
C357 divider_1/tspc_2/Z2 divider_1/tspc_2/Z3 0.16fF
C358 divider_1/nor_0/B divider_1/tspc_2/Z4 0.22fF
C359 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/clk 0.14fF
C360 ro_complete_buffered_0/tapered_buf_3/a_1650_0# ro_complete_buffered_0/tapered_buf_3/a_4670_0# 4.78fF
C361 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C362 div_pd_buffered_0/tapered_buf_1/a_160_n140# div_pd_buffered_0/tapered_buf_1/a_160_230# 0.17fF
C363 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/tspc_0/Z2 0.23fF
C364 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C365 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C366 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/a_740_n680# 0.19fF
C367 ro_complete_buffered_0/tapered_buf_0/a_160_n140# ro_complete_buffered_0/tapered_buf_0/a_580_0# 0.35fF
C368 ro_complete_0/cbank_1/switch_5/vin ro_complete_0/cbank_1/v 1.30fF
C369 pd_buffered_0/tapered_buf_3/a_160_n140# pd_buffered_0/tapered_buf_3/a_580_0# 0.35fF
C370 ro_complete_buffered_0/tapered_buf_1/a_580_0# ro_complete_buffered_0/tapered_buf_1/a_1650_0# 1.27fF
C371 ro_complete_buffered_0/ro_complete_0/cbank_0/v ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.04fF
C372 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/div 0.03fF
C373 pll_full_1/divider_0/and_0/OUT pll_full_1/vco 0.06fF
C374 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C375 ro_complete_buffered_0/tapered_buf_5/a_160_n140# ro_complete_buffered_0/tapered_buf_5/a_n10_n140# 0.05fF
C376 ro_complete_buffered_0/tapered_buf_5/a_580_0# ro_complete_buffered_0/tapered_buf_5/a_210_n610# 0.84fF
C377 pd_buffered_0/pd_0/REF pd_buffered_0/tapered_buf_0/a_210_n610# 26.29fF
C378 pd_buffered_0/pd_0/tspc_r_0/Qbar pd_buffered_0/pd_0/and_pd_0/Out1 0.05fF
C379 pd_buffered_0/pd_0/tspc_r_1/Qbar1 pd_buffered_0/pd_0/tspc_r_1/Qbar 0.01fF
C380 pd_buffered_0/pd_0/tspc_r_1/Z3 pd_buffered_0/pd_0/R 0.27fF
C381 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/a_630_n680# 0.05fF
C382 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/nor_1/B 0.03fF
C383 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C384 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C385 divider_1/tspc_1/Z3 divider_1/tspc_1/Z4 0.65fF
C386 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/Out 0.21fF
C387 divider_1/and_0/A divider_1/and_0/B 0.18fF
C388 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.04fF
C389 ro_complete_buffered_0/tapered_buf_2/a_1650_0# ro_complete_buffered_0/tapered_buf_2/a_580_0# 1.27fF
C390 ro_complete_0/a4 ro_complete_0/cbank_1/switch_1/vin 0.09fF
C391 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C392 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Z1 0.07fF
C393 div_pd_buffered_0/tapered_buf_0/a_160_n140# div_pd_buffered_0/tapered_buf_0/a_n10_n140# 0.05fF
C394 div_pd_buffered_0/divider_0/nor_1/Z1 div_pd_buffered_0/divider_0/and_0/B 0.18fF
C395 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C396 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/vco 0.64fF
C397 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/Qbar 0.01fF
C398 divider_1/tspc_0/Z3 divider_1/nor_1/A 0.38fF
C399 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z3 0.05fF
C400 divider_0/nor_0/B divider_0/tspc_2/Z1 0.03fF
C401 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Z1 0.09fF
C402 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C403 pll_full_1/cp_0/upbar pll_full_1/cp_0/down 0.02fF
C404 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C405 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C406 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C407 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/vco 1.46fF
C408 divider_1/prescaler_0/tspc_2/D divider_1/prescaler_0/nand_0/z1 0.24fF
C409 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/A 0.01fF
C410 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/Q 0.05fF
C411 div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 div_pd_buffered_0/pd_0/tspc_r_0/z5 0.20fF
C412 div_pd_buffered_0/tapered_buf_2/a_580_0# div_pd_buffered_0/tapered_buf_2/a_210_n610# 0.84fF
C413 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/and_pd_0/Out1 0.18fF
C414 pll_full_0/pd_0/tspc_r_0/Qbar pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C415 div_pd_buffered_0/divider_0/tspc_0/Z4 div_pd_buffered_0/divider_0/nor_1/A 0.21fF
C416 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C417 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C418 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C419 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C420 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z4 0.14fF
C421 div_pd_buffered_0/divider_0/tspc_0/Z2 div_pd_buffered_0/divider_0/tspc_0/Z3 0.16fF
C422 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 div_pd_buffered_0/divider_0/clk 0.12fF
C423 ro_complete_buffered_0/ro_complete_0/a1 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_4/vin 0.09fF
C424 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.15fF
C425 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/and_0/A 0.01fF
C426 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/nand_0/z1 0.07fF
C427 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/D 0.05fF
C428 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/v 1.30fF
C429 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/Z4 0.20fF
C430 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C431 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/v 0.08fF
C432 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C433 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/vco 0.01fF
C434 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/ref 0.17fF
C435 div_pd_buffered_0/tapered_buf_4/a_n10_230# div_pd_buffered_0/tapered_buf_4/in 0.02fF
C436 divider_1/prescaler_0/tspc_2/D divider_1/clk 0.26fF
C437 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/ref 0.04fF
C438 div_pd_buffered_0/pd_0/tspc_r_0/z5 div_pd_buffered_0/pd_0/tspc_r_1/z5 0.02fF
C439 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/tspc_r_1/Z2 0.25fF
C440 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/UP 0.03fF
C441 ro_complete_0/a0 ro_complete_0/cbank_1/switch_5/vin 0.09fF
C442 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/tspc_0/Z4 0.21fF
C443 ro_complete_buffered_0/ro_complete_0/a0 ro_complete_buffered_0/tapered_buf_1/in 0.05fF
C444 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_2/Z3 0.45fF
C445 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Q 0.04fF
C446 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/and_0/A 0.26fF
C447 divider_0/tspc_1/Z2 divider_0/tspc_0/Q 0.14fF
C448 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/D 0.03fF
C449 divider_0/prescaler_0/m1_2700_2190# divider_0/clk 0.01fF
C450 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C451 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C452 pd_buffered_0/tapered_buf_2/a_1650_0# pd_buffered_0/tapered_buf_2/a_210_n610# 2.89fF
C453 ro_complete_buffered_0/tapered_buf_6/a_160_n140# ro_complete_buffered_0/tapered_buf_6/a_580_0# 0.35fF
C454 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C455 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C456 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/prescaler_0/Out 0.05fF
C457 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/pd_0/UP 2.89fF
C458 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/tspc_r_1/Z1 0.71fF
C459 div_pd_buffered_0/divider_0/tspc_0/Z4 div_pd_buffered_0/divider_0/tspc_0/Z3 0.65fF
C460 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C461 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/tspc_1/Z4 0.02fF
C462 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C463 divider_1/prescaler_0/Out divider_1/tspc_0/a_630_n680# 0.01fF
C464 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/a_630_n680# 0.12fF
C465 divider_0/tspc_1/Z1 divider_0/tspc_1/Z2 1.07fF
C466 divider_0/prescaler_0/Out divider_0/prescaler_0/m1_2700_2190# 0.11fF
C467 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_0/vin ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.45fF
C468 pll_full_1/divider_0/tspc_2/Z2 pll_full_1/divider_0/tspc_2/Z3 0.16fF
C469 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_2/Z4 0.22fF
C470 divider_1/mc2 divider_1/prescaler_0/tspc_2/a_630_n680# 0.33fF
C471 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/D 0.05fF
C472 pd_buffered_0/tapered_buf_1/a_580_0# pd_buffered_0/tapered_buf_1/a_1650_0# 1.27fF
C473 pd_buffered_0/tapered_buf_1/a_n10_n140# pd_buffered_0/pd_0/UP 0.04fF
C474 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z4 0.36fF
C475 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Q 0.05fF
C476 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 0.12fF
C477 ro_complete_buffered_0/tapered_buf_7/a_160_n140# ro_complete_buffered_0/tapered_buf_7/a_580_0# 0.35fF
C478 ro_complete_buffered_0/tapered_buf_3/a_1650_0# ro_complete_buffered_0/tapered_buf_3/a_210_n610# 2.89fF
C479 ro_complete_buffered_0/tapered_buf_2/a_210_n610# ro_complete_buffered_0/tapered_buf_2/a_580_0# 0.84fF
C480 div_pd_buffered_0/tapered_buf_0/a_160_n140# div_pd_buffered_0/pd_0/UP 0.19fF
C481 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.33fF
C482 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_0/vin 0.12fF
C483 ro_complete_buffered_0/tapered_buf_0/a_160_n140# ro_complete_buffered_0/tapered_buf_0/a_n10_n140# 0.05fF
C484 ro_complete_buffered_0/tapered_buf_0/a_580_0# ro_complete_buffered_0/tapered_buf_0/a_210_n610# 0.84fF
C485 ro_complete_buffered_0/tapered_buf_1/a_210_n610# ro_complete_buffered_0/tapered_buf_1/a_580_0# 0.84fF
C486 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C487 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_2/vin ro_complete_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C488 div_pd_buffered_0/divider_0/tspc_1/Q div_pd_buffered_0/divider_0/tspc_2/a_630_n680# 0.01fF
C489 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_1/Z4 0.21fF
C490 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.06fF
C491 pll_full_1/ro_complete_0/a0 pll_full_1/vco 0.11fF
C492 divider_0/tspc_0/Z4 divider_0/tspc_0/a_630_n680# 0.12fF
C493 divider_0/prescaler_0/tspc_0/Z2 divider_0/and_0/OUT 0.06fF
C494 divider_0/prescaler_0/tspc_1/Z4 divider_0/clk 0.12fF
C495 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z3 0.16fF
C496 pll_full_1/divider_0/and_0/A pll_full_1/divider_0/and_0/B 0.18fF
C497 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C498 ro_complete_buffered_0/tapered_buf_4/a_210_n610# ro_complete_buffered_0/ro_complete_0/a2 26.29fF
C499 divider_1/tspc_1/Q divider_1/tspc_2/Z4 0.15fF
C500 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/UP 0.03fF
C501 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Q 0.15fF
C502 ro_complete_buffered_0/tapered_buf_5/a_210_n610# ro_complete_buffered_0/ro_complete_0/a3 26.29fF
C503 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/divider_0/tspc_2/a_630_n680# 0.04fF
C504 div_pd_buffered_0/divider_0/tspc_0/Z4 div_pd_buffered_0/divider_0/tspc_0/Z2 0.36fF
C505 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C506 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/Z1 0.00fF
C507 divider_0/prescaler_0/tspc_1/Z4 divider_0/prescaler_0/Out 0.28fF
C508 ro_complete_buffered_0/ro_complete_0/a3 ro_complete_buffered_0/tapered_buf_1/in 0.05fF
C509 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/R 0.29fF
C510 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/and_0/Z1 0.04fF
C511 div_pd_buffered_0/divider_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/tspc_2/Z2 0.01fF
C512 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q div_pd_buffered_0/divider_0/clk 0.05fF
C513 pll_full_1/divider_0/prescaler_0/tspc_2/D pll_full_1/divider_0/prescaler_0/nand_0/z1 0.24fF
C514 divider_1/prescaler_0/tspc_0/Z2 divider_1/clk 0.11fF
C515 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/ro_complete_0/cbank_2/v 0.04fF
C516 divider_1/tspc_2/Z2 divider_1/tspc_2/Z4 0.36fF
C517 divider_1/tspc_2/Z3 divider_1/Out 0.05fF
C518 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_0/Q 0.01fF
C519 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/pd_0/and_pd_0/Out1 0.12fF
C520 div_pd_buffered_0/pd_0/tspc_r_0/Qbar div_pd_buffered_0/pd_0/UP 0.21fF
C521 ro_complete_buffered_0/tapered_buf_5/a_n10_230# ro_complete_buffered_0/tapered_buf_5/in 0.02fF
C522 ro_complete_buffered_0/tapered_buf_3/a_160_n140# ro_complete_buffered_0/tapered_buf_3/in 0.19fF
C523 ro_complete_buffered_0/tapered_buf_2/a_1650_0# ro_complete_buffered_0/tapered_buf_2/a_210_n610# 2.89fF
C524 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.13fF
C525 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C526 pd_buffered_0/tapered_buf_3/a_580_0# pd_buffered_0/tapered_buf_3/a_1650_0# 1.27fF
C527 divider_1/tspc_1/a_630_n680# divider_1/nor_1/B 0.35fF
C528 divider_1/prescaler_0/Out divider_1/nor_1/A 0.15fF
C529 div_pd_buffered_0/divider_0/and_0/out1 div_pd_buffered_0/divider_0/and_0/B 0.18fF
C530 pll_full_1/divider_0/prescaler_0/tspc_2/D pll_full_1/vco 0.26fF
C531 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C532 divider_0/tspc_1/Q divider_0/tspc_2/Z1 0.01fF
C533 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z3 0.06fF
C534 pd_buffered_0/tapered_buf_1/a_210_n610# pd_buffered_0/tapered_buf_1/a_1650_0# 2.89fF
C535 pd_buffered_0/pd_0/DOWN pd_buffered_0/pd_0/R 0.36fF
C536 pd_buffered_0/pd_0/tspc_r_1/Z1 pd_buffered_0/pd_0/tspc_r_1/Z2 0.71fF
C537 pd_buffered_0/pd_0/tspc_r_1/Z3 pd_buffered_0/pd_0/tspc_r_1/Z4 0.20fF
C538 pd_buffered_0/pd_0/DIV pd_buffered_0/pd_0/tspc_r_1/z5 0.04fF
C539 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/nor_1/B 0.38fF
C540 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z1 0.00fF
C541 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C542 pll_full_0/ro_complete_0/a2 pll_full_0/vco 0.11fF
C543 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z3 0.05fF
C544 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z1 0.03fF
C545 ro_complete_buffered_0/tapered_buf_6/a_n10_230# ro_complete_buffered_0/tapered_buf_6/in 0.02fF
C546 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C547 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C548 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C549 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/a1 3.18fF
C550 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_0/Z3 0.45fF
C551 pll_full_1/ro_complete_0/a3 pll_full_1/vco 0.11fF
C552 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/nor_0/B 0.00fF
C553 div_pd_buffered_0/divider_0/tspc_1/Z2 div_pd_buffered_0/divider_0/tspc_0/Q 0.14fF
C554 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C555 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/clk 0.01fF
C556 divider_0/prescaler_0/Out divider_0/tspc_0/a_630_n680# 0.01fF
C557 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_5/vin ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C558 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.01fF
C559 divider_1/tspc_0/Q divider_1/tspc_1/Z2 0.14fF
C560 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z4 0.12fF
C561 divider_0/tspc_2/Z1 divider_0/tspc_2/Z2 1.07fF
C562 divider_0/nor_0/B divider_0/tspc_2/Z3 0.38fF
C563 ro_complete_buffered_0/tapered_buf_2/a_210_n610# ro_complete_buffered_0/ro_complete_0/a0 26.29fF
C564 div_pd_buffered_0/tapered_buf_2/a_n10_230# div_pd_buffered_0/tapered_buf_2/a_160_230# 0.09fF
C565 divider_1/nor_1/B divider_1/nor_0/B 0.47fF
C566 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/Q 0.04fF
C567 divider_1/prescaler_0/tspc_1/Z3 divider_1/clk 0.45fF
C568 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C569 pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_0/vco 1.58fF
C570 div_pd_buffered_0/tapered_buf_0/a_4670_0# div_pd_buffered_0/tapered_buf_0/a_1650_0# 4.78fF
C571 div_pd_buffered_0/tapered_buf_1/a_160_n140# div_pd_buffered_0/tapered_buf_1/a_210_n610# 0.22fF
C572 div_pd_buffered_0/divider_0/tspc_1/Z1 div_pd_buffered_0/divider_0/tspc_1/Z3 0.06fF
C573 ro_complete_buffered_0/tapered_buf_7/a_n10_230# ro_complete_buffered_0/tapered_buf_7/in 0.02fF
C574 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C575 ro_complete_buffered_0/tapered_buf_1/a_160_n140# ro_complete_buffered_0/tapered_buf_1/a_580_0# 0.35fF
C576 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.05fF
C577 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/R 0.21fF
C578 divider_1/tspc_0/Z1 divider_1/nor_1/A 0.03fF
C579 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z2 0.01fF
C580 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Q 0.38fF
C581 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_0/D 0.11fF
C582 pd_buffered_0/pd_0/tspc_r_0/Z3 pd_buffered_0/pd_0/tspc_r_0/Z1 0.09fF
C583 pd_buffered_0/pd_0/REF pd_buffered_0/pd_0/tspc_r_0/Z2 0.19fF
C584 div_pd_buffered_0/tapered_buf_2/in div_pd_buffered_0/tapered_buf_2/a_n10_n140# 0.04fF
C585 divider_0/and_0/out1 divider_0/and_0/Z1 0.36fF
C586 divider_0/mc2 divider_0/prescaler_0/tspc_2/a_630_n680# 0.33fF
C587 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z3 0.65fF
C588 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C589 div_pd_buffered_0/pd_0/tspc_r_0/Qbar div_pd_buffered_0/pd_0/and_pd_0/Out1 0.05fF
C590 div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 div_pd_buffered_0/pd_0/tspc_r_1/Qbar 0.01fF
C591 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/R 0.27fF
C592 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C593 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/nor_1/B 1.21fF
C594 divider_0/nor_1/Z1 divider_0/nor_1/B 0.06fF
C595 ro_complete_0/a0 ro_complete_0/cbank_1/v 0.05fF
C596 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z3 0.06fF
C597 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_0/Z2 0.11fF
C598 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C599 divider_1/prescaler_0/Out divider_1/tspc_0/Z3 0.45fF
C600 divider_0/prescaler_0/tspc_1/Z4 divider_0/prescaler_0/tspc_1/Z1 0.00fF
C601 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_2/Z4 0.15fF
C602 divider_0/and_0/OUT divider_0/prescaler_0/nand_0/z1 0.01fF
C603 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/clk 0.01fF
C604 pd_buffered_0/pd_0/tspc_r_0/Qbar pd_buffered_0/pd_0/R 0.03fF
C605 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_1/z5 0.03fF
C606 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/pd_0/tspc_r_1/Z2 0.71fF
C607 pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_0/ro_complete_0/cbank_2/v 1.45fF
C608 divider_1/nor_1/A divider_1/prescaler_0/tspc_1/Q 0.03fF
C609 divider_1/tspc_1/Z1 divider_1/nor_1/B 0.03fF
C610 io_clamp_low[2] io_analog[6] 0.53fF
C611 ro_complete_buffered_0/tapered_buf_6/a_580_0# ro_complete_buffered_0/tapered_buf_6/a_1650_0# 1.27fF
C612 pll_full_0/ref pll_full_0/pd_0/tspc_r_0/Z4 0.02fF
C613 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C614 ro_complete_buffered_0/tapered_buf_4/a_n10_n140# ro_complete_buffered_0/tapered_buf_4/in 0.04fF
C615 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/tspc_0/a_630_n680# 0.12fF
C616 div_pd_buffered_0/tapered_buf_3/a_580_0# div_pd_buffered_0/tapered_buf_3/a_210_n610# 0.84fF
C617 div_pd_buffered_0/tapered_buf_2/a_160_n140# div_pd_buffered_0/tapered_buf_2/a_n10_n140# 0.05fF
C618 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/a_630_n680# 0.19fF
C619 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z3 0.11fF
C620 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z3 0.33fF
C621 divider_0/tspc_1/Z2 divider_0/tspc_1/Z3 0.16fF
C622 pll_full_1/divider_0/tspc_2/Z2 pll_full_1/divider_0/tspc_2/Z4 0.36fF
C623 pll_full_1/divider_0/tspc_2/Z3 pll_full_1/div 0.05fF
C624 divider_1/mc2 divider_1/nor_1/B 0.06fF
C625 divider_0/and_0/OUT divider_0/clk 0.04fF
C626 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C627 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C628 div_pd_buffered_0/tapered_buf_2/a_580_0# div_pd_buffered_0/tapered_buf_2/a_160_n140# 0.35fF
C629 pd_buffered_0/pd_0/tspc_r_0/z5 pd_buffered_0/pd_0/UP 0.03fF
C630 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C631 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z2 0.36fF
C632 div_pd_buffered_0/tapered_buf_4/a_580_0# div_pd_buffered_0/tapered_buf_4/a_1650_0# 1.27fF
C633 divider_1/prescaler_0/tspc_2/Z4 divider_1/prescaler_0/tspc_2/D 0.11fF
C634 div_pd_buffered_0/tapered_buf_4/a_4670_0# div_pd_buffered_0/tapered_buf_4/a_1650_0# 4.78fF
C635 pll_full_0/div pll_full_0/vco 2.26fF
C636 cp_buffered_0/tapered_buf_1/a_210_n610# cp_buffered_0/cp_0/out 26.29fF
C637 cp_buffered_0/tapered_buf_1/a_n10_n140# cp_buffered_0/tapered_buf_1/in 0.04fF
C638 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C639 ro_complete_buffered_0/tapered_buf_7/a_580_0# ro_complete_buffered_0/tapered_buf_7/a_1650_0# 1.27fF
C640 ro_complete_0/a2 ro_complete_0/cbank_2/switch_2/vin 0.14fF
C641 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/v 1.30fF
C642 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# 0.33fF
C643 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C644 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/DOWN 0.07fF
C645 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/and_0/B 0.08fF
C646 div_pd_buffered_0/divider_0/tspc_1/Q div_pd_buffered_0/divider_0/nor_0/B 0.22fF
C647 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C648 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# div_pd_buffered_0/divider_0/clk 0.01fF
C649 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_4/vin ro_complete_buffered_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C650 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C651 div_pd_buffered_0/tapered_buf_3/in div_pd_buffered_0/tapered_buf_3/a_n10_n140# 0.04fF
C652 divider_1/tspc_0/Z1 divider_1/tspc_0/Z3 0.06fF
C653 divider_0/tspc_1/Z2 divider_0/tspc_1/Z4 0.36fF
C654 divider_0/tspc_1/Z3 divider_0/tspc_1/Q 0.05fF
C655 divider_1/tspc_0/Q divider_1/tspc_1/Z4 0.15fF
C656 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C657 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z3 0.16fF
C658 pd_buffered_0/tapered_buf_0/a_160_n140# pd_buffered_0/tapered_buf_0/a_580_0# 0.35fF
C659 divider_0/nor_1/A divider_0/nor_1/B 1.21fF
C660 pd_buffered_0/pd_0/and_pd_0/Z1 pd_buffered_0/pd_0/UP 0.06fF
C661 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/tspc_r_0/Qbar 0.01fF
C662 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/Q 0.55fF
C663 pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_0/vco 1.46fF
C664 divider_1/prescaler_0/tspc_2/Z3 divider_1/clk 0.45fF
C665 cp_buffered_0/tapered_buf_0/a_210_n610# cp_buffered_0/cp_0/down 26.29fF
C666 cp_buffered_0/tapered_buf_0/a_n10_n140# cp_buffered_0/tapered_buf_0/in 0.04fF
C667 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/R 0.27fF
C668 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/divider_0/nor_0/B 0.42fF
C669 div_pd_buffered_0/divider_0/tspc_1/Z3 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# 0.05fF
C670 div_pd_buffered_0/divider_0/tspc_1/Z1 div_pd_buffered_0/divider_0/nor_1/B 0.03fF
C671 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/nor_1/A 0.35fF
C672 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C673 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C674 ro_complete_buffered_0/tapered_buf_4/a_1650_0# ro_complete_buffered_0/tapered_buf_4/a_4670_0# 4.78fF
C675 ro_complete_buffered_0/tapered_buf_4/a_160_n140# ro_complete_buffered_0/tapered_buf_4/a_160_230# 0.17fF
C676 ro_complete_0/a3 ro_complete_0/cbank_1/v 0.05fF
C677 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C678 div_pd_buffered_0/divider_0/nor_0/B div_pd_buffered_0/divider_0/tspc_2/Z2 0.40fF
C679 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D div_pd_buffered_0/divider_0/clk 0.29fF
C680 ro_complete_buffered_0/tapered_buf_1/a_160_n140# ro_complete_buffered_0/tapered_buf_1/in 0.19fF
C681 ro_complete_buffered_0/tapered_buf_1/a_210_n610# ro_complete_buffered_0/tapered_buf_1/a_1650_0# 2.89fF
C682 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C683 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C684 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_2/Z4 0.02fF
C685 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.04fF
C686 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/vco 0.45fF
C687 divider_1/prescaler_0/Out divider_1/clk 0.51fF
C688 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/D 0.15fF
C689 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Z4 0.65fF
C690 pll_full_1/cp_0/down pll_full_1/cp_0/a_1710_0# 0.32fF
C691 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z1 0.01fF
C692 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_0/Q 0.22fF
C693 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C694 ro_complete_buffered_0/tapered_buf_3/a_160_n140# ro_complete_buffered_0/tapered_buf_3/a_160_230# 0.17fF
C695 pd_buffered_0/tapered_buf_2/a_160_n140# pd_buffered_0/tapered_buf_2/a_580_0# 0.35fF
C696 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/R 0.01fF
C697 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/tspc_1/Q 0.04fF
C698 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 div_pd_buffered_0/divider_0/and_0/OUT 0.06fF
C699 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C700 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C701 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C702 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/clk 0.11fF
C703 pd_buffered_0/tapered_buf_3/a_1650_0# pd_buffered_0/tapered_buf_3/a_4670_0# 4.78fF
C704 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.03fF
C705 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z3 0.06fF
C706 divider_0/tspc_1/Q divider_0/tspc_2/Z3 0.45fF
C707 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Q 0.04fF
C708 divider_0/mc2 divider_0/nor_1/B 0.06fF
C709 divider_1/nor_1/B divider_1/tspc_1/Q 0.51fF
C710 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z4 0.00fF
C711 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Q 0.21fF
C712 divider_1/prescaler_0/tspc_1/Z2 divider_1/clk 0.11fF
C713 pd_buffered_0/tapered_buf_1/a_580_0# pd_buffered_0/tapered_buf_1/a_160_n140# 0.35fF
C714 pd_buffered_0/pd_0/tspc_r_1/Qbar1 pd_buffered_0/pd_0/tspc_r_1/z5 0.20fF
C715 pll_full_1/pd_0/DOWN pll_full_1/ref 1.48fF
C716 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C717 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/A 0.80fF
C718 pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C719 cp_buffered_0/tapered_buf_1/a_580_0# cp_buffered_0/tapered_buf_1/a_160_230# 0.02fF
C720 cp_buffered_0/tapered_buf_1/a_160_n140# cp_buffered_0/tapered_buf_1/a_210_n610# 0.22fF
C721 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z4 0.12fF
C722 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z2 1.07fF
C723 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z3 0.38fF
C724 divider_1/and_0/B divider_1/and_0/Z1 0.07fF
C725 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z2 0.25fF
C726 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C727 ro_complete_buffered_0/tapered_buf_2/a_160_230# ro_complete_buffered_0/tapered_buf_2/a_160_n140# 0.17fF
C728 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/nor_0/B 0.47fF
C729 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/tspc_0/Z3 0.05fF
C730 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/clk 0.01fF
C731 ro_complete_buffered_0/tapered_buf_0/a_1650_0# ro_complete_buffered_0/tapered_buf_0/a_210_n610# 2.89fF
C732 ro_complete_buffered_0/tapered_buf_1/a_160_230# ro_complete_buffered_0/tapered_buf_1/a_160_n140# 0.17fF
C733 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C734 divider_0/tspc_1/a_630_n680# divider_0/nor_0/B 0.00fF
C735 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z3 0.33fF
C736 ro_complete_0/a2 ro_complete_0/cbank_2/v 0.05fF
C737 divider_0/tspc_2/Z2 divider_0/tspc_2/Z3 0.16fF
C738 divider_0/nor_0/B divider_0/tspc_2/Z4 0.22fF
C739 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.04fF
C740 divider_1/nor_1/B divider_1/tspc_2/Z2 0.20fF
C741 divider_1/prescaler_0/tspc_1/Z4 divider_1/clk 0.12fF
C742 pd_buffered_0/tapered_buf_0/in pd_buffered_0/tapered_buf_0/a_n10_n140# 0.04fF
C743 pd_buffered_0/tapered_buf_1/a_1650_0# pd_buffered_0/tapered_buf_1/a_4670_0# 4.78fF
C744 pd_buffered_0/tapered_buf_1/a_160_n140# pd_buffered_0/pd_0/UP 0.19fF
C745 pd_buffered_0/pd_0/and_pd_0/Out1 pd_buffered_0/pd_0/and_pd_0/Z1 0.18fF
C746 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z4 0.12fF
C747 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C748 cp_buffered_0/tapered_buf_0/a_580_0# cp_buffered_0/tapered_buf_0/a_160_230# 0.02fF
C749 cp_buffered_0/tapered_buf_0/a_160_n140# cp_buffered_0/tapered_buf_0/a_210_n610# 0.22fF
C750 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/Z1 0.36fF
C751 div_pd_buffered_0/tapered_buf_1/a_n10_n140# div_pd_buffered_0/pd_0/DOWN 0.04fF
C752 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/z5 0.11fF
C753 div_pd_buffered_0/tapered_buf_1/a_4670_0# div_pd_buffered_0/tapered_buf_1/a_210_n610# 29.21fF
C754 ro_complete_buffered_0/tapered_buf_2/a_160_n140# ro_complete_buffered_0/tapered_buf_2/a_580_0# 0.35fF
C755 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/and_0/out1 0.31fF
C756 div_pd_buffered_0/divider_0/tspc_1/Z4 div_pd_buffered_0/divider_0/tspc_0/Q 0.15fF
C757 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/Z3 0.65fF
C758 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/tapered_buf_1/in 0.05fF
C759 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_0/Q 0.01fF
C760 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.11fF
C761 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Q 0.04fF
C762 div_pd_buffered_0/tapered_buf_3/a_n10_230# div_pd_buffered_0/tapered_buf_3/a_n10_n140# 0.01fF
C763 divider_1/nor_1/A divider_1/tspc_1/Z2 0.15fF
C764 divider_1/mc2 divider_1/and_0/out1 0.06fF
C765 divider_0/and_0/A divider_0/and_0/B 0.18fF
C766 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C767 divider_1/tspc_2/a_630_n680# divider_1/nor_0/B 0.35fF
C768 divider_1/prescaler_0/tspc_1/Q divider_1/clk 0.60fF
C769 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C770 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/vco 0.11fF
C771 ro_complete_buffered_0/tapered_buf_5/a_1650_0# ro_complete_buffered_0/tapered_buf_5/a_4670_0# 4.78fF
C772 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/a4 0.12fF
C773 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C774 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/pd_0/R 0.36fF
C775 div_pd_buffered_0/pd_0/tspc_r_1/Z1 div_pd_buffered_0/pd_0/tspc_r_1/Z2 0.71fF
C776 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/tspc_r_1/Z4 0.20fF
C777 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/tspc_r_1/z5 0.04fF
C778 ro_complete_buffered_0/tapered_buf_1/a_n10_n140# ro_complete_buffered_0/tapered_buf_1/a_n10_230# 0.01fF
C779 cp_buffered_0/tapered_buf_2/a_160_230# cp_buffered_0/tapered_buf_2/a_580_0# 0.02fF
C780 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/z5 0.20fF
C781 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/and_0/out1 0.06fF
C782 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/nor_1/B 0.35fF
C783 div_pd_buffered_0/divider_0/tspc_1/Z2 div_pd_buffered_0/divider_0/tspc_1/Z4 0.36fF
C784 div_pd_buffered_0/divider_0/tspc_1/Z3 div_pd_buffered_0/divider_0/tspc_1/Q 0.05fF
C785 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/tspc_0/Z2 0.01fF
C786 div_pd_buffered_0/divider_0/nor_0/B div_pd_buffered_0/divider_0/and_0/B 0.29fF
C787 div_pd_buffered_0/tapered_buf_3/a_4670_0# div_pd_buffered_0/tapered_buf_3/a_210_n610# 29.21fF
C788 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z2 0.19fF
C789 divider_0/prescaler_0/tspc_1/Z4 divider_0/prescaler_0/tspc_1/Z3 0.65fF
C790 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/vco 0.45fF
C791 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C792 divider_0/prescaler_0/tspc_2/D divider_0/prescaler_0/nand_0/z1 0.24fF
C793 divider_1/tspc_1/Z3 divider_1/nor_1/B 0.38fF
C794 divider_1/tspc_0/Z2 divider_1/tspc_0/Z4 0.36fF
C795 pd_buffered_0/tapered_buf_1/a_160_230# pd_buffered_0/tapered_buf_1/a_580_0# 0.02fF
C796 pd_buffered_0/tapered_buf_1/a_210_n610# pd_buffered_0/tapered_buf_1/a_160_n140# 0.22fF
C797 pd_buffered_0/pd_0/DIV pd_buffered_0/pd_0/tspc_r_1/Qbar1 0.12fF
C798 pll_full_0/filter_0/a_4216_n5230# pll_full_0/vco 1.58fF
C799 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/div 0.03fF
C800 pll_full_0/divider_0/and_0/OUT pll_full_0/vco 0.06fF
C801 ro_complete_buffered_0/tapered_buf_6/a_1650_0# ro_complete_buffered_0/tapered_buf_6/a_4670_0# 4.78fF
C802 ro_complete_buffered_0/tapered_buf_6/a_160_n140# ro_complete_buffered_0/tapered_buf_6/a_160_230# 0.17fF
C803 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C804 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C805 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C806 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/a_740_n680# 0.08fF
C807 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C808 pll_full_1/ro_complete_0/a4 pll_full_1/vco 0.01fF
C809 pll_full_0/ref pll_full_0/pd_0/R 0.61fF
C810 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 div_pd_buffered_0/divider_0/and_0/OUT 0.05fF
C811 pll_full_0/pd_0/R pll_full_0/pd_0/UP 0.46fF
C812 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z4 0.28fF
C813 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/tspc_r_0/Qbar 0.05fF
C814 pll_full_1/pd_0/R pll_full_1/pd_0/tspc_r_0/Qbar1 0.30fF
C815 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/UP 0.03fF
C816 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C817 divider_0/prescaler_0/tspc_2/D divider_0/clk 0.26fF
C818 divider_1/nor_1/A divider_1/and_0/A 0.01fF
C819 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/vco 0.64fF
C820 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/tspc_r_0/Z1 0.09fF
C821 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/tspc_r_0/Z2 0.19fF
C822 cp_buffered_0/cp_0/upbar cp_buffered_0/cp_0/down 0.02fF
C823 ro_complete_buffered_0/tapered_buf_7/a_1650_0# ro_complete_buffered_0/tapered_buf_7/a_4670_0# 4.78fF
C824 ro_complete_buffered_0/tapered_buf_7/a_160_n140# ro_complete_buffered_0/tapered_buf_7/a_160_230# 0.17fF
C825 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_5/vin 0.20fF
C826 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/nor_1/A 0.15fF
C827 pll_full_1/ro_complete_0/cbank_0/switch_5/vin pll_full_1/ro_complete_0/a0 0.09fF
C828 div_pd_buffered_0/tapered_buf_0/a_n10_230# div_pd_buffered_0/tapered_buf_0/a_n10_n140# 0.01fF
C829 div_pd_buffered_0/divider_0/tspc_0/Z4 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# 0.12fF
C830 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C831 div_pd_buffered_0/tapered_buf_2/a_4670_0# div_pd_buffered_0/tapered_buf_2/a_1650_0# 4.78fF
C832 ro_complete_buffered_0/ro_complete_0/a5 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C833 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_4/vin ro_complete_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C834 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C835 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.21fF
C836 div_pd_buffered_0/divider_0/tspc_1/Q div_pd_buffered_0/divider_0/tspc_2/Z2 0.14fF
C837 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C838 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/clk 0.01fF
C839 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/z5 0.11fF
C840 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Q 0.91fF
C841 pll_full_1/divider_0/and_0/B pll_full_1/divider_0/and_0/Z1 0.07fF
C842 pd_buffered_0/tapered_buf_0/a_580_0# pd_buffered_0/tapered_buf_0/a_1650_0# 1.27fF
C843 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_0/z5 0.04fF
C844 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C845 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C846 pll_full_0/pd_0/R pll_full_0/div 0.51fF
C847 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z4 0.36fF
C848 div_pd_buffered_0/tapered_buf_4/a_580_0# div_pd_buffered_0/tapered_buf_4/a_210_n610# 0.84fF
C849 divider_1/nor_1/B divider_1/and_0/B 0.31fF
C850 divider_1/prescaler_0/tspc_2/Z4 divider_1/clk 0.12fF
C851 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C852 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/and_0/A 0.01fF
C853 div_pd_buffered_0/tapered_buf_4/a_n10_230# div_pd_buffered_0/tapered_buf_4/a_160_230# 0.09fF
C854 div_pd_buffered_0/tapered_buf_4/a_4670_0# div_pd_buffered_0/tapered_buf_4/a_210_n610# 29.21fF
C855 pll_full_0/cp_0/a_1710_0# pll_full_0/pd_0/DOWN 0.04fF
C856 div_pd_buffered_0/pd_0/tspc_r_0/Qbar div_pd_buffered_0/pd_0/R 0.03fF
C857 ro_complete_buffered_0/tapered_buf_4/a_160_n140# ro_complete_buffered_0/tapered_buf_4/a_n10_n140# 0.05fF
C858 ro_complete_buffered_0/tapered_buf_4/a_580_0# ro_complete_buffered_0/tapered_buf_4/a_210_n610# 0.84fF
C859 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_0/vin 0.19fF
C860 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z4 0.20fF
C861 div_pd_buffered_0/divider_0/tspc_1/Z3 div_pd_buffered_0/divider_0/nor_1/B 0.38fF
C862 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C863 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C864 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C865 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z2 0.01fF
C866 ro_complete_buffered_0/ro_complete_0/a1 ro_complete_buffered_0/tapered_buf_1/in 0.05fF
C867 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_0/Z3 0.06fF
C868 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 pll_full_1/vco 0.12fF
C869 div_pd_buffered_0/divider_0/tspc_2/Z1 div_pd_buffered_0/divider_0/tspc_2/Z3 0.06fF
C870 cp_buffered_0/tapered_buf_2/a_1650_0# cp_buffered_0/tapered_buf_2/a_580_0# 1.27fF
C871 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/D 0.05fF
C872 divider_0/prescaler_0/tspc_0/Z2 divider_0/clk 0.11fF
C873 pd_buffered_0/tapered_buf_1/a_n10_n140# pd_buffered_0/tapered_buf_1/a_n10_230# 0.01fF
C874 pd_buffered_0/pd_0/tspc_r_0/Z4 pd_buffered_0/pd_0/tspc_r_0/z5 0.04fF
C875 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_1/Z4 0.02fF
C876 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/Z4 0.21fF
C877 divider_1/nor_1/A divider_1/tspc_1/Z4 0.02fF
C878 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C879 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z2 0.01fF
C880 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z3 0.45fF
C881 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Q 0.04fF
C882 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/A 0.26fF
C883 pd_buffered_0/tapered_buf_2/a_n10_n140# pd_buffered_0/tapered_buf_2/in 0.04fF
C884 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/tapered_buf_1/a_160_n140# 0.19fF
C885 div_pd_buffered_0/pd_0/tspc_r_0/z5 div_pd_buffered_0/pd_0/UP 0.03fF
C886 ro_complete_buffered_0/tapered_buf_3/a_160_n140# ro_complete_buffered_0/tapered_buf_3/a_n10_n140# 0.05fF
C887 ro_complete_buffered_0/tapered_buf_3/a_580_0# ro_complete_buffered_0/tapered_buf_3/a_210_n610# 0.84fF
C888 ro_complete_buffered_0/tapered_buf_2/in ro_complete_buffered_0/tapered_buf_2/a_n10_n140# 0.04fF
C889 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/a3 0.13fF
C890 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C891 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/a_630_n680# 0.01fF
C892 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C893 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.05fF
C894 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/tspc_1/Q 0.51fF
C895 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C896 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C897 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C898 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/clk 0.51fF
C899 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Q 0.04fF
C900 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z4 0.00fF
C901 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/nor_0/B 0.35fF
C902 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/vco 0.60fF
C903 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C904 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C905 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/div 0.19fF
C906 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/Z3 0.38fF
C907 divider_0/tspc_1/Q divider_0/tspc_2/Z4 0.15fF
C908 pd_buffered_0/pd_0/tspc_r_0/Qbar1 pd_buffered_0/pd_0/UP 0.11fF
C909 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_1/Z4 0.02fF
C910 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C911 div_pd_buffered_0/tapered_buf_3/a_160_n140# div_pd_buffered_0/tapered_buf_3/a_n10_n140# 0.05fF
C912 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Z4 0.65fF
C913 divider_0/mc2 divider_0/and_0/out1 0.06fF
C914 cp_buffered_0/tapered_buf_1/a_1650_0# cp_buffered_0/tapered_buf_1/a_210_n610# 2.89fF
C915 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z3 0.16fF
C916 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z4 0.22fF
C917 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/nor_1/A 0.04fF
C918 div_pd_buffered_0/pd_0/and_pd_0/Z1 div_pd_buffered_0/pd_0/UP 0.06fF
C919 divider_0/mc2 divider_0/nor_1/A 0.04fF
C920 ro_complete_buffered_0/tapered_buf_2/a_210_n610# ro_complete_buffered_0/tapered_buf_2/a_160_n140# 0.22fF
C921 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_4/vin 0.20fF
C922 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/a3 2.04fF
C923 ro_complete_buffered_0/tapered_buf_1/a_n10_n140# ro_complete_buffered_0/tapered_buf_1/in 0.04fF
C924 ro_complete_buffered_0/tapered_buf_1/a_210_n610# ro_complete_buffered_0/tapered_buf_1/a_160_n140# 0.22fF
C925 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_0/Z2 1.07fF
C926 pll_full_1/ro_complete_0/a1 pll_full_1/vco 0.11fF
C927 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/tspc_2/Z2 0.20fF
C928 divider_1/tspc_1/a_630_n680# divider_1/nor_0/B 0.00fF
C929 divider_0/nor_1/B divider_0/nor_0/B 0.47fF
C930 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z3 0.05fF
C931 pll_full_0/pd_0/tspc_r_1/z5 pll_full_0/div 0.04fF
C932 divider_0/tspc_2/Z2 divider_0/tspc_2/Z4 0.36fF
C933 divider_0/tspc_2/Z3 divider_0/Out 0.05fF
C934 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Z4 0.21fF
C935 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C936 pll_full_0/ro_complete_0/a0 pll_full_0/vco 0.11fF
C937 divider_1/tspc_1/Q divider_1/tspc_2/a_630_n680# 0.01fF
C938 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/divider_0/mc2 0.34fF
C939 div_pd_buffered_0/tapered_buf_0/a_160_230# div_pd_buffered_0/tapered_buf_0/a_160_n140# 0.17fF
C940 div_pd_buffered_0/tapered_buf_0/a_n10_230# div_pd_buffered_0/pd_0/UP 0.02fF
C941 cp_buffered_0/tapered_buf_0/a_1650_0# cp_buffered_0/tapered_buf_0/a_210_n610# 2.89fF
C942 pll_full_0/divider_0/and_0/A pll_full_0/divider_0/and_0/B 0.18fF
C943 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_1/Qbar 0.21fF
C944 ro_complete_0/a4 ro_complete_0/cbank_1/v 0.05fF
C945 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C946 ro_complete_buffered_0/ro_complete_0/a1 ro_complete_buffered_0/ro_complete_0/a0 3.46fF
C947 ro_complete_buffered_0/ro_complete_0/a3 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C948 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_0/Q 0.45fF
C949 pd_buffered_0/tapered_buf_3/a_580_0# pd_buffered_0/tapered_buf_3/a_160_230# 0.02fF
C950 pd_buffered_0/tapered_buf_3/a_160_n140# pd_buffered_0/tapered_buf_3/a_210_n610# 0.22fF
C951 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z3 0.06fF
C952 ro_complete_0/a0 ro_complete_0/cbank_2/switch_5/vin 0.09fF
C953 pd_buffered_0/pd_0/REF pd_buffered_0/pd_0/tspc_r_0/Z4 0.02fF
C954 pd_buffered_0/tapered_buf_3/a_n10_n140# pd_buffered_0/pd_0/DOWN 0.04fF
C955 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C956 divider_1/and_0/OUT divider_1/and_0/Z1 0.04fF
C957 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z2 0.01fF
C958 divider_1/prescaler_0/tspc_2/Q divider_1/clk 0.05fF
C959 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/DOWN 0.03fF
C960 div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 div_pd_buffered_0/pd_0/tspc_r_1/z5 0.20fF
C961 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C962 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/and_0/OUT 0.06fF
C963 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/div 0.19fF
C964 cp_buffered_0/tapered_buf_2/a_4670_0# cp_buffered_0/tapered_buf_2/a_1650_0# 4.78fF
C965 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C966 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/tspc_0/Z3 0.16fF
C967 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 pll_full_1/vco 0.12fF
C968 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/R 0.33fF
C969 io_clamp_low[2] io_clamp_high[2] 0.53fF
C970 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/Q 0.04fF
C971 divider_1/nor_1/Z1 divider_1/and_0/B 0.18fF
C972 cp_buffered_0/tapered_buf_2/a_210_n610# cp_buffered_0/tapered_buf_2/a_160_n140# 0.22fF
C973 pd_buffered_0/pd_0/tspc_r_1/Z3 pd_buffered_0/pd_0/DOWN 0.03fF
C974 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C975 ro_complete_buffered_0/tapered_buf_3/a_160_n140# ro_complete_buffered_0/tapered_buf_3/a_580_0# 0.35fF
C976 io_clamp_high[1] io_analog[5] 0.53fF
C977 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/vco 0.26fF
C978 div_pd_buffered_0/tapered_buf_4/a_210_n610# div_pd_buffered_0/tapered_buf_4/a_160_n140# 0.22fF
C979 divider_1/and_0/out1 divider_1/and_0/B 0.18fF
C980 ro_complete_buffered_0/tapered_buf_6/a_160_n140# ro_complete_buffered_0/tapered_buf_6/a_n10_n140# 0.05fF
C981 ro_complete_buffered_0/tapered_buf_6/a_580_0# ro_complete_buffered_0/tapered_buf_6/a_210_n610# 0.84fF
C982 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/DOWN 0.11fF
C983 div_pd_buffered_0/pd_0/and_pd_0/Out1 div_pd_buffered_0/pd_0/and_pd_0/Z1 0.18fF
C984 ro_complete_buffered_0/tapered_buf_2/a_160_230# ro_complete_buffered_0/tapered_buf_2/a_n10_230# 0.09fF
C985 ro_complete_buffered_0/tapered_buf_2/in ro_complete_buffered_0/tapered_buf_2/a_160_n140# 0.19fF
C986 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C987 div_pd_buffered_0/tapered_buf_0/a_580_0# div_pd_buffered_0/tapered_buf_0/a_1650_0# 1.27fF
C988 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C989 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C990 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C991 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z4 0.00fF
C992 divider_0/prescaler_0/Out divider_0/tspc_0/Z4 0.12fF
C993 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C994 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C995 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Q 0.05fF
C996 pd_buffered_0/pd_0/R pd_buffered_0/pd_0/and_pd_0/Z1 0.02fF
C997 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_0/Z3 0.45fF
C998 pll_full_0/ro_complete_0/a3 pll_full_0/vco 0.11fF
C999 ro_complete_buffered_0/tapered_buf_7/a_160_n140# ro_complete_buffered_0/tapered_buf_7/a_n10_n140# 0.05fF
C1000 ro_complete_buffered_0/tapered_buf_7/a_580_0# ro_complete_buffered_0/tapered_buf_7/a_210_n610# 0.84fF
C1001 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/tspc_r_0/Z4 0.04fF
C1002 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C1003 ro_complete_0/a5 ro_complete_0/cbank_1/switch_0/vin 0.09fF
C1004 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/v 1.30fF
C1005 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1006 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1007 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/and_0/B 0.31fF
C1008 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q div_pd_buffered_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C1009 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C1010 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1011 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/vco 0.14fF
C1012 div_pd_buffered_0/tapered_buf_2/a_160_n140# div_pd_buffered_0/tapered_buf_2/a_210_n610# 0.22fF
C1013 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C1014 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/D 0.09fF
C1015 divider_1/mc2 divider_1/nor_0/B 0.15fF
C1016 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C1017 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/div 0.02fF
C1018 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C1019 div_pd_buffered_0/tapered_buf_4/a_n10_230# div_pd_buffered_0/tapered_buf_4/a_n10_n140# 0.01fF
C1020 divider_0/nor_1/A divider_0/tspc_0/Z3 0.38fF
C1021 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/clk 0.01fF
C1022 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C1023 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 0.12fF
C1024 ro_complete_buffered_0/tapered_buf_0/a_1650_0# ro_complete_buffered_0/tapered_buf_0/a_4670_0# 4.78fF
C1025 pll_full_0/cp_0/a_1710_0# pll_full_0/cp_0/down 0.32fF
C1026 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/nor_1/B 0.01fF
C1027 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C1028 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C1029 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/nor_0/B 0.15fF
C1030 ro_complete_0/a1 ro_complete_0/cbank_1/v 0.05fF
C1031 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/tspc_1/Z2 0.15fF
C1032 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_0/a_630_n680# 0.01fF
C1033 div_pd_buffered_0/divider_0/tspc_2/Z1 div_pd_buffered_0/divider_0/tspc_2/Z4 0.00fF
C1034 divider_0/nor_1/B divider_0/tspc_1/Z2 0.30fF
C1035 ro_complete_buffered_0/tapered_buf_1/a_4670_0# ro_complete_buffered_0/tapered_buf_1/a_1650_0# 4.78fF
C1036 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_2/a_630_n680# 0.01fF
C1037 divider_0/prescaler_0/tspc_2/Z4 divider_0/prescaler_0/tspc_2/D 0.11fF
C1038 divider_0/prescaler_0/Out divider_0/clk 0.51fF
C1039 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1040 ro_complete_0/cbank_1/v ro_complete_0/cbank_2/v 1.36fF
C1041 cp_buffered_0/tapered_buf_2/a_n10_n140# cp_buffered_0/tapered_buf_2/in 0.04fF
C1042 pd_buffered_0/pd_0/REF pd_buffered_0/pd_0/R 0.61fF
C1043 pd_buffered_0/tapered_buf_2/a_1650_0# pd_buffered_0/tapered_buf_2/a_580_0# 1.27fF
C1044 pll_full_1/pd_0/R pll_full_1/pd_0/tspc_r_1/Z2 0.21fF
C1045 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z3 0.06fF
C1046 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_0/Z2 0.11fF
C1047 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1048 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/Out 0.04fF
C1049 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z4 0.15fF
C1050 ro_complete_0/a2 ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1051 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_0/vin ro_complete_buffered_0/ro_complete_0/a4 0.12fF
C1052 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1053 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1054 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1055 pd_buffered_0/tapered_buf_2/a_160_n140# pd_buffered_0/tapered_buf_2/a_160_230# 0.17fF
C1056 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/nor_1/B 0.30fF
C1057 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Q 0.04fF
C1058 divider_0/nor_1/B divider_0/tspc_1/Q 0.51fF
C1059 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1060 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/Z1 0.04fF
C1061 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z2 0.01fF
C1062 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/vco 0.05fF
C1063 divider_0/prescaler_0/tspc_2/Z3 divider_0/clk 0.45fF
C1064 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_0/Qbar 0.02fF
C1065 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/a_630_n680# 0.12fF
C1066 div_pd_buffered_0/tapered_buf_2/a_580_0# div_pd_buffered_0/tapered_buf_2/a_1650_0# 1.27fF
C1067 divider_0/nor_1/A divider_0/tspc_0/Z2 0.23fF
C1068 cp_buffered_0/tapered_buf_1/a_160_n140# cp_buffered_0/tapered_buf_1/in 0.19fF
C1069 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z4 0.36fF
C1070 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/div 0.05fF
C1071 ro_complete_buffered_0/tapered_buf_2/a_n10_n140# ro_complete_buffered_0/tapered_buf_2/a_160_n140# 0.05fF
C1072 pll_full_0/pd_0/DOWN pll_full_0/ref 1.48fF
C1073 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C1074 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1075 pll_full_0/pd_0/DOWN pll_full_0/pd_0/UP 4.58fF
C1076 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 div_pd_buffered_0/divider_0/clk 0.11fF
C1077 divider_0/nor_1/B divider_0/tspc_2/Z2 0.20fF
C1078 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/B 0.18fF
C1079 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.33fF
C1080 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1081 divider_1/tspc_0/Q divider_1/nor_1/B 0.22fF
C1082 divider_1/tspc_1/Q divider_1/nor_0/B 0.22fF
C1083 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_2/Q 0.19fF
C1084 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/clk 0.01fF
C1085 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1086 div_pd_buffered_0/pd_0/tspc_r_0/Z4 div_pd_buffered_0/pd_0/tspc_r_0/z5 0.04fF
C1087 cp_buffered_0/cp_0/out cp_buffered_0/cp_0/down 0.79fF
C1088 cp_buffered_0/tapered_buf_0/a_160_n140# cp_buffered_0/tapered_buf_0/in 0.19fF
C1089 pll_full_1/filter_0/a_4216_n5230# pll_full_1/vco 1.58fF
C1090 ro_complete_0/a3 ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1091 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1092 pll_full_0/pd_0/tspc_r_0/Qbar pll_full_0/pd_0/UP 0.21fF
C1093 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1094 ro_complete_buffered_0/ro_complete_0/a5 ro_complete_buffered_0/tapered_buf_1/in 0.10fF
C1095 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_5/vin ro_complete_buffered_0/ro_complete_0/a0 0.09fF
C1096 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/nor_0/B 0.00fF
C1097 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.05fF
C1098 pd_buffered_0/tapered_buf_3/a_1650_0# pd_buffered_0/tapered_buf_3/a_210_n610# 2.89fF
C1099 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1100 ro_complete_0/a0 ro_complete_0/cbank_2/v 0.05fF
C1101 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1102 divider_0/and_0/B divider_0/and_0/Z1 0.07fF
C1103 pd_buffered_0/pd_0/tspc_r_0/Z3 pd_buffered_0/pd_0/tspc_r_0/z5 0.11fF
C1104 divider_1/tspc_2/a_630_n680# divider_1/Out 0.04fF
C1105 divider_1/nor_0/B divider_1/tspc_2/Z2 0.40fF
C1106 divider_1/prescaler_0/tspc_0/D divider_1/clk 0.29fF
C1107 cp_buffered_0/cp_0/a_1710_n2840# cp_buffered_0/cp_0/a_1710_0# 0.83fF
C1108 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/UP 0.11fF
C1109 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_2/Z4 0.02fF
C1110 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1111 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/vco 0.45fF
C1112 div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 div_pd_buffered_0/pd_0/UP 0.11fF
C1113 ro_complete_buffered_0/tapered_buf_5/a_n10_230# ro_complete_buffered_0/tapered_buf_5/a_160_230# 0.09fF
C1114 ro_complete_buffered_0/tapered_buf_5/a_4670_0# ro_complete_buffered_0/tapered_buf_5/a_210_n610# 29.21fF
C1115 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C1116 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/a4 0.09fF
C1117 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/a5 0.09fF
C1118 ro_complete_buffered_0/tapered_buf_7/a_210_n610# ro_complete_buffered_0/ro_complete_0/a5 26.29fF
C1119 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/tspc_0/Z1 0.03fF
C1120 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C1121 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1122 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z3 0.05fF
C1123 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1124 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_0/Qbar1 0.20fF
C1125 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C1126 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z3 0.33fF
C1127 pd_buffered_0/tapered_buf_0/a_580_0# pd_buffered_0/tapered_buf_0/a_160_230# 0.02fF
C1128 pd_buffered_0/tapered_buf_0/a_160_n140# pd_buffered_0/tapered_buf_0/a_210_n610# 0.22fF
C1129 pd_buffered_0/pd_0/tspc_r_1/Z3 pd_buffered_0/pd_0/tspc_r_1/Z1 0.09fF
C1130 pd_buffered_0/pd_0/DIV pd_buffered_0/pd_0/tspc_r_1/Z2 0.19fF
C1131 divider_0/mc2 divider_0/nor_0/B 0.15fF
C1132 io_clamp_low[0] io_analog[4] 0.53fF
C1133 cp_buffered_0/cp_0/a_1710_0# cp_buffered_0/cp_0/out 0.84fF
C1134 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.33fF
C1135 ro_complete_buffered_0/tapered_buf_6/a_n10_230# ro_complete_buffered_0/tapered_buf_6/a_160_230# 0.09fF
C1136 ro_complete_buffered_0/tapered_buf_6/a_4670_0# ro_complete_buffered_0/tapered_buf_6/a_210_n610# 29.21fF
C1137 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1138 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/Out 0.05fF
C1139 ro_complete_buffered_0/tapered_buf_1/a_210_n610# ro_complete_buffered_0/tapered_buf_1/a_4670_0# 29.21fF
C1140 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_1/vin ro_complete_buffered_0/ro_complete_0/a3 0.13fF
C1141 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_1/Z4 0.65fF
C1142 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.15fF
C1143 pll_full_1/ro_complete_0/a5 pll_full_1/vco 0.15fF
C1144 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Out1 0.12fF
C1145 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1146 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z1 0.08fF
C1147 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Z4 0.20fF
C1148 divider_0/tspc_2/a_630_n680# divider_0/nor_0/B 0.35fF
C1149 divider_0/prescaler_0/tspc_1/Q divider_0/clk 0.60fF
C1150 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/tspc_r_0/Z4 0.02fF
C1151 pll_full_0/pd_0/tspc_r_0/Qbar pll_full_0/pd_0/and_pd_0/Out1 0.05fF
C1152 div_pd_buffered_0/tapered_buf_4/a_210_n610# div_pd_buffered_0/divider_0/clk 26.29fF
C1153 ro_complete_buffered_0/tapered_buf_7/a_n10_230# ro_complete_buffered_0/tapered_buf_7/a_160_230# 0.09fF
C1154 ro_complete_buffered_0/tapered_buf_7/a_4670_0# ro_complete_buffered_0/tapered_buf_7/a_210_n610# 29.21fF
C1155 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1156 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_3/vin ro_complete_buffered_0/tapered_buf_1/in 1.30fF
C1157 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/tspc_0/Z3 0.38fF
C1158 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q div_pd_buffered_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C1159 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 div_pd_buffered_0/divider_0/clk 0.11fF
C1160 divider_0/nor_1/B divider_0/and_0/B 0.31fF
C1161 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Q 0.91fF
C1162 ro_complete_0/a3 ro_complete_0/cbank_2/v 0.05fF
C1163 pd_buffered_0/pd_0/REF pd_buffered_0/pd_0/tspc_r_0/Z3 0.65fF
C1164 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_0/Q 0.01fF
C1165 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C1166 divider_1/and_0/OUT divider_1/and_0/out1 0.31fF
C1167 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/DOWN 0.03fF
C1168 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C1169 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C1170 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/prescaler_0/m1_2700_2190# 0.01fF
C1171 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C1172 div_pd_buffered_0/tapered_buf_2/a_160_n140# div_pd_buffered_0/tapered_buf_2/in 0.19fF
C1173 ro_complete_buffered_0/ro_complete_0/a0 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1174 ro_complete_buffered_0/ro_complete_0/cbank_0/v ro_complete_buffered_0/tapered_buf_1/in 1.27fF
C1175 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/nor_0/B 0.22fF
C1176 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.19fF
C1177 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/vco 0.01fF
C1178 div_pd_buffered_0/divider_0/tspc_2/Z3 div_pd_buffered_0/divider_0/tspc_2/Z4 0.65fF
C1179 pd_buffered_0/tapered_buf_2/a_210_n610# pd_buffered_0/tapered_buf_2/a_580_0# 0.84fF
C1180 pll_full_1/pd_0/R pll_full_1/pd_0/DOWN 0.36fF
C1181 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a4 0.12fF
C1182 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1183 pd_buffered_0/tapered_buf_1/a_n10_230# pd_buffered_0/tapered_buf_1/a_160_230# 0.09fF
C1184 pd_buffered_0/pd_0/tspc_r_0/Qbar pd_buffered_0/pd_0/DOWN 0.02fF
C1185 pd_buffered_0/pd_0/tspc_r_0/Qbar1 pd_buffered_0/pd_0/R 0.30fF
C1186 divider_1/tspc_0/a_630_n680# divider_1/nor_1/B 0.01fF
C1187 divider_1/tspc_1/Z1 divider_1/tspc_1/Z3 0.06fF
C1188 divider_0/nor_1/A divider_0/tspc_1/Z2 0.15fF
C1189 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/vco 0.45fF
C1190 divider_1/nor_0/B divider_1/and_0/B 0.29fF
C1191 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C1192 div_pd_buffered_0/pd_0/R div_pd_buffered_0/pd_0/and_pd_0/Z1 0.02fF
C1193 ro_complete_buffered_0/tapered_buf_2/in ro_complete_buffered_0/tapered_buf_2/a_n10_230# 0.02fF
C1194 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/a4 0.12fF
C1195 ro_complete_0/a2 ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1196 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1197 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1198 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1199 ro_complete_buffered_0/tapered_buf_1/a_n10_n140# ro_complete_buffered_0/tapered_buf_1/a_160_n140# 0.05fF
C1200 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C1201 pd_buffered_0/tapered_buf_2/a_160_n140# pd_buffered_0/tapered_buf_2/a_n10_n140# 0.05fF
C1202 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/tspc_0/Z2 0.23fF
C1203 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C1204 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/vco 1.46fF
C1205 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/div 0.04fF
C1206 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_2/Z2 0.40fF
C1207 pll_full_1/divider_0/prescaler_0/tspc_0/D pll_full_1/vco 0.29fF
C1208 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/tspc_r_0/Qbar 0.02fF
C1209 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/a_630_n680# 0.01fF
C1210 divider_0/tspc_0/Z2 divider_0/tspc_0/Z3 0.16fF
C1211 divider_0/prescaler_0/tspc_2/Z4 divider_0/clk 0.12fF
C1212 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1213 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1214 cp_buffered_0/tapered_buf_2/a_210_n610# cp_buffered_0/cp_0/upbar 26.29fF
C1215 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/Z2 0.25fF
C1216 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/ref 0.19fF
C1217 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1218 pll_full_0/ro_complete_0/a4 pll_full_0/vco 0.01fF
C1219 div_pd_buffered_0/tapered_buf_2/a_n10_n140# div_pd_buffered_0/tapered_buf_2/a_n10_230# 0.01fF
C1220 divider_1/prescaler_0/tspc_2/Z2 divider_1/and_0/OUT 0.05fF
C1221 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/tspc_r_1/z5 0.02fF
C1222 div_pd_buffered_0/tapered_buf_1/a_n10_n140# div_pd_buffered_0/tapered_buf_1/a_n10_230# 0.01fF
C1223 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/nor_1/B 0.06fF
C1224 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C1225 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1226 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# 0.05fF
C1227 pll_full_1/pd_0/tspc_r_1/z5 pll_full_1/div 0.04fF
C1228 cp_buffered_0/tapered_buf_2/a_160_230# cp_buffered_0/tapered_buf_2/a_n10_230# 0.09fF
C1229 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_1/Q 0.04fF
C1230 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1231 pll_full_1/ro_complete_0/cbank_0/v pll_full_1/vco 1.27fF
C1232 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/UP 0.33fF
C1233 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/nor_1/A 0.15fF
C1234 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/a0 0.09fF
C1235 cp_buffered_0/tapered_buf_2/in cp_buffered_0/tapered_buf_2/a_n10_230# 0.02fF
C1236 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1237 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1238 divider_1/tspc_1/Q divider_1/tspc_2/Z2 0.14fF
C1239 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_0/D 0.32fF
C1240 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/clk 0.01fF
C1241 pll_full_0/divider_0/and_0/B pll_full_0/divider_0/and_0/Z1 0.07fF
C1242 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/R 0.61fF
C1243 ro_complete_0/a5 ro_complete_0/cbank_1/v 0.10fF
C1244 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/a0 0.09fF
C1245 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/and_0/B 0.01fF
C1246 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C1247 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/nor_0/B 0.47fF
C1248 divider_1/nor_0/Z1 divider_1/nor_1/B 0.18fF
C1249 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z1 1.07fF
C1250 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1251 divider_1/nor_1/A divider_1/nor_1/B 1.21fF
C1252 divider_1/mc2 divider_1/and_0/B 0.20fF
C1253 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z3 0.06fF
C1254 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/vco 0.12fF
C1255 divider_1/nor_0/B divider_1/Out 0.22fF
C1256 divider_1/tspc_2/Z1 divider_1/tspc_2/Z3 0.06fF
C1257 ro_complete_buffered_0/tapered_buf_5/a_n10_230# ro_complete_buffered_0/tapered_buf_5/a_n10_n140# 0.01fF
C1258 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1259 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/and_0/B 0.20fF
C1260 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_0/vin ro_complete_buffered_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C1261 divider_0/nor_1/B divider_0/tspc_0/a_630_n680# 0.01fF
C1262 divider_0/nor_1/Z1 divider_0/and_0/B 0.18fF
C1263 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/out1 0.31fF
C1264 pll_full_1/divider_0/tspc_1/Z4 pll_full_1/divider_0/tspc_0/Q 0.15fF
C1265 io_clamp_low[1] io_clamp_high[1] 0.53fF
C1266 divider_0/tspc_1/Q divider_0/tspc_2/a_630_n680# 0.01fF
C1267 divider_0/prescaler_0/tspc_1/Z3 divider_0/clk 0.45fF
C1268 pd_buffered_0/tapered_buf_2/a_160_n140# pd_buffered_0/tapered_buf_2/in 0.19fF
C1269 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a3 0.13fF
C1270 ro_complete_buffered_0/tapered_buf_5/a_580_0# ro_complete_buffered_0/tapered_buf_5/a_160_230# 0.02fF
C1271 ro_complete_buffered_0/tapered_buf_5/a_160_n140# ro_complete_buffered_0/tapered_buf_5/a_210_n610# 0.22fF
C1272 divider_1/tspc_1/Z2 divider_1/tspc_1/Z4 0.36fF
C1273 divider_1/tspc_1/Z3 divider_1/tspc_1/Q 0.05fF
C1274 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z3 0.05fF
C1275 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z4 0.08fF
C1276 cp_buffered_0/tapered_buf_2/a_n10_n140# cp_buffered_0/tapered_buf_2/a_n10_230# 0.01fF
C1277 pd_buffered_0/tapered_buf_0/a_1650_0# pd_buffered_0/tapered_buf_0/a_210_n610# 2.89fF
C1278 pd_buffered_0/pd_0/DIV pd_buffered_0/pd_0/R 0.51fF
C1279 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C1280 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1281 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C1282 divider_0/nor_1/A divider_0/tspc_0/Z1 0.03fF
C1283 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z3 0.33fF
C1284 cp_buffered_0/tapered_buf_1/a_160_n140# cp_buffered_0/tapered_buf_1/a_580_0# 0.35fF
C1285 pll_full_1/ref pll_full_1/pd_0/tspc_r_0/Z1 0.17fF
C1286 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/nor_0/B 0.35fF
C1287 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/vco 0.60fF
C1288 ro_complete_buffered_0/tapered_buf_6/a_n10_230# ro_complete_buffered_0/tapered_buf_6/a_n10_n140# 0.01fF
C1289 ro_complete_buffered_0/tapered_buf_2/a_n10_n140# ro_complete_buffered_0/tapered_buf_2/a_n10_230# 0.01fF
C1290 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a3 0.13fF
C1291 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1292 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.05fF
C1293 div_pd_buffered_0/tapered_buf_0/a_160_n140# div_pd_buffered_0/tapered_buf_0/a_210_n610# 0.22fF
C1294 div_pd_buffered_0/divider_0/nor_1/Z1 div_pd_buffered_0/divider_0/and_0/A 0.80fF
C1295 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_2/vin 0.22fF
C1296 ro_complete_buffered_0/tapered_buf_5/a_160_n140# ro_complete_buffered_0/tapered_buf_5/a_580_0# 0.35fF
C1297 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/nor_1/B 0.35fF
C1298 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/vco 0.11fF
C1299 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z3 0.11fF
C1300 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/and_0/B 0.29fF
C1301 divider_0/and_0/OUT divider_0/and_0/Z1 0.04fF
C1302 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z2 0.01fF
C1303 divider_0/prescaler_0/tspc_2/Q divider_0/clk 0.05fF
C1304 pd_buffered_0/tapered_buf_3/a_n10_230# pd_buffered_0/tapered_buf_3/a_160_230# 0.09fF
C1305 pd_buffered_0/tapered_buf_2/a_1650_0# pd_buffered_0/tapered_buf_2/a_4670_0# 4.78fF
C1306 divider_0/nor_0/Z1 divider_0/nor_1/B 0.18fF
C1307 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/clk 0.01fF
C1308 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z2 1.07fF
C1309 pll_full_0/ro_complete_0/a1 pll_full_0/vco 0.11fF
C1310 cp_buffered_0/tapered_buf_0/a_160_n140# cp_buffered_0/tapered_buf_0/a_580_0# 0.35fF
C1311 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/tspc_r_0/z5 0.11fF
C1312 ro_complete_buffered_0/tapered_buf_7/a_n10_230# ro_complete_buffered_0/tapered_buf_7/a_n10_n140# 0.01fF
C1313 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/v 1.30fF
C1314 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/nor_1/B 0.06fF
C1315 div_pd_buffered_0/tapered_buf_1/a_n10_230# div_pd_buffered_0/tapered_buf_1/a_160_230# 0.09fF
C1316 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D div_pd_buffered_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C1317 div_pd_buffered_0/tapered_buf_3/a_160_230# div_pd_buffered_0/tapered_buf_3/a_n10_230# 0.09fF
C1318 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/and_0/OUT 0.05fF
C1319 divider_1/prescaler_0/m1_2700_2190# divider_1/and_0/OUT 0.14fF
C1320 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/D 0.09fF
C1321 divider_0/and_0/out1 divider_0/and_0/B 0.18fF
C1322 pd_buffered_0/pd_0/tspc_r_0/Z3 pd_buffered_0/pd_0/tspc_r_0/Qbar1 0.38fF
C1323 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1324 div_pd_buffered_0/tapered_buf_0/a_n10_230# div_pd_buffered_0/tapered_buf_0/a_160_230# 0.09fF
C1325 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_0/Q 0.45fF
C1326 divider_0/nor_1/A divider_0/and_0/B 0.08fF
C1327 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/v 1.30fF
C1328 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/tspc_r_1/Z1 0.09fF
C1329 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/tspc_r_1/Z2 0.19fF
C1330 ro_complete_0/a0 ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1331 ro_complete_0/cbank_0/v ro_complete_0/cbank_1/v 1.27fF
C1332 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1333 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/R 0.02fF
C1334 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z2 0.25fF
C1335 div_pd_buffered_0/tapered_buf_1/a_4670_0# div_pd_buffered_0/tapered_buf_1/a_1650_0# 4.78fF
C1336 div_pd_buffered_0/tapered_buf_1/a_580_0# div_pd_buffered_0/tapered_buf_1/a_160_230# 0.02fF
C1337 div_pd_buffered_0/tapered_buf_3/in div_pd_buffered_0/tapered_buf_3/a_n10_230# 0.02fF
C1338 ro_complete_buffered_0/tapered_buf_0/in ro_complete_buffered_0/tapered_buf_0/a_n10_n140# 0.04fF
C1339 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_2/Z2 0.14fF
C1340 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Z3 0.05fF
C1341 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/tspc_0/D 0.32fF
C1342 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/vco 0.01fF
C1343 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C1344 divider_0/tspc_1/Z1 divider_0/tspc_0/Q 0.01fF
C1345 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Q 0.05fF
C1346 pd_buffered_0/tapered_buf_1/a_210_n610# pd_buffered_0/tapered_buf_1/a_580_0# 0.84fF
C1347 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C1348 divider_0/nor_1/A divider_0/prescaler_0/m1_2700_2190# 0.01fF
C1349 pll_full_1/pd_0/tspc_r_1/Z4 pll_full_1/pd_0/tspc_r_1/Z2 0.14fF
C1350 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z3 0.16fF
C1351 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/vco 0.12fF
C1352 ro_complete_0/a2 ro_complete_0/cbank_2/switch_3/vin 0.09fF
C1353 div_pd_buffered_0/tapered_buf_1/a_580_0# div_pd_buffered_0/tapered_buf_1/a_160_n140# 0.35fF
C1354 ro_complete_buffered_0/ro_complete_0/a2 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C1355 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_1/vin ro_complete_buffered_0/ro_complete_0/a4 0.09fF
C1356 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_0/vin ro_complete_buffered_0/ro_complete_0/a5 0.09fF
C1357 ro_complete_buffered_0/tapered_buf_4/a_n10_230# ro_complete_buffered_0/tapered_buf_4/in 0.02fF
C1358 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/and_0/B 0.18fF
C1359 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1360 div_pd_buffered_0/tapered_buf_1/a_210_n610# div_pd_buffered_0/tapered_buf_1/a_1650_0# 2.89fF
C1361 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C1362 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C1363 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_0/a_630_n680# 0.04fF
C1364 pll_full_1/divider_0/nor_0/B pll_full_1/div 0.27fF
C1365 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z3 0.06fF
C1366 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/DOWN 0.03fF
C1367 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1368 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/ref 0.12fF
C1369 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/UP 0.11fF
C1370 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Q 0.20fF
C1371 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/D 0.09fF
C1372 pd_buffered_0/pd_0/tspc_r_1/Z4 pd_buffered_0/pd_0/tspc_r_1/z5 0.04fF
C1373 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z4 0.00fF
C1374 divider_0/mc2 divider_0/and_0/B 0.20fF
C1375 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/tspc_r_0/Z3 0.65fF
C1376 cp_buffered_0/tapered_buf_1/a_n10_230# cp_buffered_0/tapered_buf_1/in 0.02fF
C1377 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/div 0.17fF
C1378 div_pd_buffered_0/tapered_buf_2/a_580_0# div_pd_buffered_0/tapered_buf_2/a_160_230# 0.02fF
C1379 ro_complete_buffered_0/tapered_buf_4/a_160_n140# ro_complete_buffered_0/tapered_buf_4/a_580_0# 0.35fF
C1380 ro_complete_buffered_0/tapered_buf_3/a_n10_230# ro_complete_buffered_0/tapered_buf_3/in 0.02fF
C1381 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C1382 divider_1/tspc_1/a_630_n680# divider_1/tspc_0/Q 0.01fF
C1383 ro_complete_buffered_0/tapered_buf_0/a_580_0# ro_complete_buffered_0/tapered_buf_0/a_160_230# 0.02fF
C1384 ro_complete_buffered_0/tapered_buf_0/a_160_n140# ro_complete_buffered_0/tapered_buf_0/a_210_n610# 0.22fF
C1385 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_1/Q 0.51fF
C1386 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Z2 0.01fF
C1387 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1388 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1389 div_pd_buffered_0/tapered_buf_0/out div_pd_buffered_0/tapered_buf_0/a_210_n610# 26.29fF
C1390 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/tspc_0/Q 0.55fF
C1391 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z3 0.06fF
C1392 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/pd_0/UP 0.06fF
C1393 ro_complete_0/a4 ro_complete_0/cbank_2/v 0.05fF
C1394 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/DOWN 0.11fF
C1395 pll_full_1/pd_0/R pll_full_1/ref 0.61fF
C1396 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1397 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1398 div_pd_buffered_0/tapered_buf_2/a_1650_0# div_pd_buffered_0/tapered_buf_2/a_210_n610# 2.89fF
C1399 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/nand_1/z1 0.22fF
C1400 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/tspc_0/D 0.04fF
C1401 pd_buffered_0/tapered_buf_0/a_n10_230# pd_buffered_0/tapered_buf_0/a_160_230# 0.09fF
C1402 pd_buffered_0/tapered_buf_0/a_4670_0# pd_buffered_0/tapered_buf_0/a_210_n610# 29.21fF
C1403 pd_buffered_0/pd_0/and_pd_0/Out1 pd_buffered_0/pd_0/UP 0.33fF
C1404 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_1/Qbar 0.21fF
C1405 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1406 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/vco 0.14fF
C1407 div_pd_buffered_0/pd_0/tspc_r_0/Qbar div_pd_buffered_0/pd_0/DOWN 0.02fF
C1408 div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 div_pd_buffered_0/pd_0/R 0.30fF
C1409 cp_buffered_0/tapered_buf_0/a_n10_230# cp_buffered_0/tapered_buf_0/in 0.02fF
C1410 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C1411 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1412 div_pd_buffered_0/divider_0/tspc_1/Z2 div_pd_buffered_0/divider_0/nor_1/A 0.15fF
C1413 div_pd_buffered_0/divider_0/nor_0/Z1 div_pd_buffered_0/divider_0/nor_0/B 0.06fF
C1414 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_2/Z2 0.20fF
C1415 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Q 0.21fF
C1416 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Qbar1 0.38fF
C1417 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C1418 ro_complete_0/cbank_2/switch_2/vin ro_complete_0/cbank_2/v 1.30fF
C1419 pd_buffered_0/pd_0/tspc_r_0/Z2 pd_buffered_0/pd_0/tspc_r_0/Z4 0.14fF
C1420 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_1/Z2 0.15fF
C1421 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C1422 divider_1/tspc_0/a_630_n680# divider_1/tspc_0/Z2 0.01fF
C1423 divider_1/tspc_2/Z1 divider_1/tspc_2/Z4 0.00fF
C1424 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C1425 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/switch_1/vin 0.19fF
C1426 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1427 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/nor_1/B 1.21fF
C1428 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/nor_0/B 0.06fF
C1429 div_pd_buffered_0/tapered_buf_3/a_160_230# div_pd_buffered_0/tapered_buf_3/a_160_n140# 0.17fF
C1430 ro_complete_buffered_0/ro_complete_0/a0 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C1431 div_pd_buffered_0/divider_0/and_0/out1 div_pd_buffered_0/divider_0/and_0/A 0.01fF
C1432 div_pd_buffered_0/divider_0/tspc_0/Z3 div_pd_buffered_0/divider_0/tspc_0/Q 0.05fF
C1433 divider_0/tspc_1/Q divider_0/nor_0/B 0.22fF
C1434 divider_0/tspc_0/Z1 divider_0/tspc_0/Z3 0.06fF
C1435 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_2/Q 0.19fF
C1436 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/clk 0.01fF
C1437 pd_buffered_0/pd_0/tspc_r_1/Qbar1 pd_buffered_0/pd_0/R 0.01fF
C1438 pd_buffered_0/pd_0/DOWN pd_buffered_0/pd_0/tspc_r_1/Qbar 0.21fF
C1439 pd_buffered_0/pd_0/DIV pd_buffered_0/pd_0/tspc_r_1/Z4 0.02fF
C1440 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_1/B 0.30fF
C1441 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z4 0.12fF
C1442 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z2 1.07fF
C1443 divider_0/nor_1/A divider_0/tspc_0/a_630_n680# 0.35fF
C1444 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1445 div_pd_buffered_0/tapered_buf_4/in div_pd_buffered_0/tapered_buf_4/a_160_n140# 0.19fF
C1446 cp_buffered_0/tapered_buf_1/a_580_0# cp_buffered_0/tapered_buf_1/a_1650_0# 1.27fF
C1447 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/Z1 0.04fF
C1448 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z2 0.01fF
C1449 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/vco 0.05fF
C1450 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C1451 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/a5 2.39fF
C1452 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_0/vin ro_complete_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C1453 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/and_0/OUT 0.14fF
C1454 pll_full_1/divider_0/prescaler_0/Out pll_full_1/vco 0.51fF
C1455 div_pd_buffered_0/pd_0/UP div_pd_buffered_0/tapered_buf_0/a_n10_n140# 0.04fF
C1456 div_pd_buffered_0/divider_0/tspc_1/Z1 div_pd_buffered_0/divider_0/tspc_0/Q 0.01fF
C1457 div_pd_buffered_0/tapered_buf_3/in div_pd_buffered_0/tapered_buf_3/a_160_n140# 0.19fF
C1458 pd_buffered_0/tapered_buf_2/a_4670_0# pd_buffered_0/tapered_buf_2/a_210_n610# 29.21fF
C1459 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/and_pd_0/Z1 0.18fF
C1460 divider_1/tspc_0/Q divider_1/tspc_1/Z1 0.01fF
C1461 divider_1/mc2 divider_1/and_0/OUT 0.05fF
C1462 divider_0/tspc_2/a_630_n680# divider_0/Out 0.04fF
C1463 divider_0/nor_0/B divider_0/tspc_2/Z2 0.40fF
C1464 divider_0/prescaler_0/tspc_0/D divider_0/clk 0.29fF
C1465 pd_buffered_0/tapered_buf_3/a_n10_230# pd_buffered_0/tapered_buf_3/a_n10_n140# 0.01fF
C1466 pd_buffered_0/tapered_buf_0/in pd_buffered_0/tapered_buf_0/a_n10_230# 0.02fF
C1467 pll_full_1/pd_0/DOWN pll_full_1/pd_0/UP 4.58fF
C1468 cp_buffered_0/tapered_buf_0/a_580_0# cp_buffered_0/tapered_buf_0/a_1650_0# 1.27fF
C1469 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/B 0.18fF
C1470 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/and_0/OUT 0.05fF
C1471 div_pd_buffered_0/divider_0/tspc_1/Z1 div_pd_buffered_0/divider_0/tspc_1/Z2 1.07fF
C1472 pll_full_1/ro_complete_0/cbank_1/switch_4/vin pll_full_1/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C1473 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/and_0/B 0.08fF
C1474 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.20fF
C1475 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.09fF
C1476 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/vco 0.12fF
C1477 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_2/D 0.16fF
C1478 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z3 0.16fF
C1479 divider_0/tspc_0/Z1 divider_0/tspc_0/Z2 1.07fF
C1480 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1481 ro_complete_0/a1 ro_complete_0/cbank_2/v 0.05fF
C1482 divider_1/nor_1/A divider_1/tspc_0/Z2 0.23fF
C1483 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z3 0.05fF
C1484 pd_buffered_0/pd_0/REF pd_buffered_0/pd_0/tspc_r_0/Z1 0.17fF
C1485 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/z5 0.11fF
C1486 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1487 ro_complete_buffered_0/tapered_buf_3/a_210_n610# ro_complete_buffered_0/ro_complete_0/a1 26.29fF
C1488 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_0/B 0.00fF
C1489 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C1490 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/R 0.51fF
C1491 ro_complete_buffered_0/tapered_buf_3/in ro_complete_buffered_0/tapered_buf_3/a_n10_n140# 0.04fF
C1492 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z2 1.07fF
C1493 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/and_0/B 0.31fF
C1494 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/nand_1/z1 0.22fF
C1495 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/prescaler_0/tspc_0/D 0.04fF
C1496 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C1497 divider_0/tspc_1/Z3 divider_0/tspc_0/Q 0.45fF
C1498 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C1499 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a4 0.09fF
C1500 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a5 0.09fF
C1501 divider_1/tspc_0/a_630_n680# divider_1/tspc_0/Z4 0.12fF
C1502 pd_buffered_0/pd_0/tspc_r_0/Z2 pd_buffered_0/pd_0/R 0.21fF
C1503 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/tspc_r_1/z5 0.20fF
C1504 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/Z1 0.03fF
C1505 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C1506 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1507 div_pd_buffered_0/tapered_buf_2/a_210_n610# div_pd_buffered_0/pd_0/REF 26.29fF
C1508 ro_complete_0/a2 ro_complete_0/cbank_0/switch_2/vin 0.14fF
C1509 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a4 0.09fF
C1510 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/a5 0.09fF
C1511 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/a1 0.14fF
C1512 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1513 pll_full_1/ro_complete_0/cbank_0/switch_2/vin pll_full_1/ro_complete_0/a3 0.09fF
C1514 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# div_pd_buffered_0/divider_0/clk 0.14fF
C1515 divider_1/prescaler_0/m1_2700_2190# divider_1/nor_1/A 0.01fF
C1516 divider_0/tspc_1/Z1 divider_0/tspc_1/Z3 0.06fF
C1517 ro_complete_buffered_0/tapered_buf_1/in ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.36fF
C1518 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z4 0.00fF
C1519 divider_0/and_0/OUT divider_0/and_0/out1 0.31fF
C1520 divider_0/tspc_1/Z4 divider_0/tspc_0/Q 0.15fF
C1521 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/Out 0.05fF
C1522 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Q 0.04fF
C1523 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/clk 0.01fF
C1524 pd_buffered_0/tapered_buf_1/a_210_n610# pd_buffered_0/tapered_buf_1/out 26.29fF
C1525 pd_buffered_0/pd_0/DOWN pd_buffered_0/pd_0/and_pd_0/Z1 0.07fF
C1526 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Z4 0.65fF
C1527 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C1528 pll_full_0/ro_complete_0/a5 pll_full_0/vco 0.15fF
C1529 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1530 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 0.38fF
C1531 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z1 0.09fF
C1532 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/ref 0.65fF
C1533 div_pd_buffered_0/tapered_buf_1/a_580_0# div_pd_buffered_0/tapered_buf_1/a_210_n610# 0.84fF
C1534 div_pd_buffered_0/divider_0/tspc_0/Z1 div_pd_buffered_0/divider_0/nor_1/A 0.03fF
C1535 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1536 ro_complete_buffered_0/tapered_buf_4/a_580_0# ro_complete_buffered_0/tapered_buf_4/a_1650_0# 1.27fF
C1537 ro_complete_buffered_0/tapered_buf_3/a_n10_230# ro_complete_buffered_0/tapered_buf_3/a_160_230# 0.09fF
C1538 ro_complete_buffered_0/tapered_buf_3/a_4670_0# ro_complete_buffered_0/tapered_buf_3/a_210_n610# 29.21fF
C1539 pll_full_1/ro_complete_0/cbank_0/switch_5/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1540 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/R 0.21fF
C1541 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/UP 0.03fF
C1542 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/tspc_0/Q 0.01fF
C1543 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/and_0/A 0.01fF
C1544 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1545 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1546 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1547 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/vco 0.01fF
C1548 divider_0/tspc_1/Z1 divider_0/tspc_1/Z4 0.00fF
C1549 divider_1/tspc_0/Z3 divider_1/tspc_0/Z2 0.16fF
C1550 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z3 0.06fF
C1551 divider_0/nor_0/B divider_0/and_0/B 0.29fF
C1552 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1553 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/nand_1/z1 0.01fF
C1554 divider_1/prescaler_0/tspc_2/Z2 divider_1/clk 0.11fF
C1555 pd_buffered_0/tapered_buf_0/a_n10_230# pd_buffered_0/tapered_buf_0/a_n10_n140# 0.01fF
C1556 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/tspc_r_0/Z1 0.71fF
C1557 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/Z3 0.38fF
C1558 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# div_pd_buffered_0/divider_0/nor_1/A 0.01fF
C1559 div_pd_buffered_0/divider_0/tspc_1/Z2 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# 0.01fF
C1560 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1561 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C1562 div_pd_buffered_0/divider_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/tspc_2/Z3 0.05fF
C1563 div_pd_buffered_0/divider_0/nor_0/B div_pd_buffered_0/divider_0/tspc_2/Z1 0.03fF
C1564 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_2/vin ro_complete_buffered_0/tapered_buf_1/in 1.30fF
C1565 pll_full_1/ro_complete_0/cbank_2/v pll_full_1/vco 1.36fF
C1566 divider_0/prescaler_0/tspc_2/Z2 divider_0/and_0/OUT 0.05fF
C1567 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/switch_5/vin 0.20fF
C1568 divider_1/nor_1/A divider_1/tspc_0/Z4 0.21fF
C1569 divider_1/prescaler_0/tspc_0/Z3 divider_1/clk 0.64fF
C1570 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.01fF
C1571 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C1572 divider_0/mc2 divider_0/and_0/OUT 0.05fF
C1573 divider_1/tspc_2/Z3 divider_1/tspc_2/Z4 0.65fF
C1574 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_0/B 0.22fF
C1575 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C1576 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/vco 0.01fF
C1577 div_pd_buffered_0/pd_0/tspc_r_1/Z4 div_pd_buffered_0/pd_0/tspc_r_1/z5 0.04fF
C1578 pd_buffered_0/tapered_buf_2/a_210_n610# pd_buffered_0/pd_0/DIV 26.29fF
C1579 div_pd_buffered_0/divider_0/nor_1/A div_pd_buffered_0/divider_0/tspc_1/Z4 0.02fF
C1580 div_pd_buffered_0/divider_0/tspc_0/Z1 div_pd_buffered_0/divider_0/tspc_0/Z3 0.06fF
C1581 pll_full_1/divider_0/nor_1/A pll_full_1/divider_0/tspc_0/a_630_n680# 0.35fF
C1582 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.91fF
C1583 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1584 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1585 ro_complete_buffered_0/ro_complete_0/a0 ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C1586 io_clamp_low[0] io_clamp_high[0] 0.53fF
C1587 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1588 divider_1/nor_0/Z1 divider_1/nor_0/B 0.06fF
C1589 divider_0/tspc_1/Q divider_0/tspc_2/Z2 0.14fF
C1590 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z3 0.05fF
C1591 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_0/D 0.32fF
C1592 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/clk 0.01fF
C1593 ro_complete_buffered_0/tapered_buf_5/a_160_n140# ro_complete_buffered_0/tapered_buf_5/in 0.19fF
C1594 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z3 0.16fF
C1595 pd_buffered_0/pd_0/DIV pd_buffered_0/tapered_buf_0/in 0.02fF
C1596 pd_buffered_0/tapered_buf_1/a_210_n610# pd_buffered_0/tapered_buf_1/a_4670_0# 29.21fF
C1597 pd_buffered_0/pd_0/tspc_r_0/Qbar pd_buffered_0/pd_0/and_pd_0/Z1 0.02fF
C1598 pd_buffered_0/pd_0/tspc_r_1/Z3 pd_buffered_0/pd_0/tspc_r_1/z5 0.11fF
C1599 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_1/z5 0.02fF
C1600 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/Z2 0.23fF
C1601 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C1602 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/vco 1.46fF
C1603 cp_buffered_0/tapered_buf_1/a_1650_0# cp_buffered_0/tapered_buf_1/a_4670_0# 4.78fF
C1604 cp_buffered_0/tapered_buf_1/a_160_n140# cp_buffered_0/tapered_buf_1/a_160_230# 0.17fF
C1605 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/div 0.04fF
C1606 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z2 0.40fF
C1607 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/vco 0.29fF
C1608 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/v 1.30fF
C1609 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C1610 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1611 div_pd_buffered_0/divider_0/nor_0/Z1 div_pd_buffered_0/divider_0/nor_1/B 0.18fF
C1612 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1613 div_pd_buffered_0/pd_0/and_pd_0/Out1 div_pd_buffered_0/pd_0/UP 0.33fF
C1614 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_3/vin ro_complete_buffered_0/ro_complete_0/a1 0.14fF
C1615 ro_complete_buffered_0/tapered_buf_0/a_n10_230# ro_complete_buffered_0/tapered_buf_0/in 0.02fF
C1616 div_pd_buffered_0/divider_0/tspc_1/Z3 div_pd_buffered_0/divider_0/tspc_0/Q 0.45fF
C1617 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C1618 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_0/a_630_n680# 0.01fF
C1619 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1620 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_2/D 0.16fF
C1621 pll_full_1/ro_complete_0/cbank_1/switch_2/vin pll_full_1/vco 1.46fF
C1622 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/UP 0.06fF
C1623 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z3 0.33fF
C1624 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.05fF
C1625 divider_1/tspc_0/Q divider_1/tspc_1/Z3 0.45fF
C1626 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/a_630_n680# 0.01fF
C1627 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/clk 0.14fF
C1628 divider_0/nor_0/B divider_0/Out 0.22fF
C1629 divider_0/tspc_2/Z1 divider_0/tspc_2/Z3 0.06fF
C1630 pd_buffered_0/pd_0/R pd_buffered_0/pd_0/UP 0.45fF
C1631 pll_full_1/pd_0/tspc_r_1/Z4 pll_full_1/pd_0/tspc_r_1/z5 0.04fF
C1632 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Q 0.04fF
C1633 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1634 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/vco 1.27fF
C1635 div_pd_buffered_0/pd_0/tspc_r_0/Z2 div_pd_buffered_0/pd_0/tspc_r_0/Z4 0.14fF
C1636 ro_complete_buffered_0/tapered_buf_3/a_580_0# ro_complete_buffered_0/tapered_buf_3/a_1650_0# 1.27fF
C1637 cp_buffered_0/tapered_buf_0/a_1650_0# cp_buffered_0/tapered_buf_0/a_4670_0# 4.78fF
C1638 cp_buffered_0/tapered_buf_0/a_160_n140# cp_buffered_0/tapered_buf_0/a_160_230# 0.17fF
C1639 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/nor_1/B 0.18fF
C1640 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1641 div_pd_buffered_0/divider_0/tspc_1/Z2 div_pd_buffered_0/divider_0/tspc_1/Z3 0.16fF
C1642 div_pd_buffered_0/divider_0/tspc_0/Z1 div_pd_buffered_0/divider_0/tspc_0/Z2 1.07fF
C1643 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C1644 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/Z2 0.36fF
C1645 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_0/Z3 0.05fF
C1646 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C1647 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1648 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/pd_0/tspc_r_1/Z3 0.09fF
C1649 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/nand_0/z1 0.07fF
C1650 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z2 0.01fF
C1651 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1652 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1653 divider_1/tspc_0/Z3 divider_1/tspc_0/Z4 0.65fF
C1654 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z4 0.12fF
C1655 pd_buffered_0/pd_0/tspc_r_0/Z3 pd_buffered_0/pd_0/tspc_r_0/Z2 0.25fF
C1656 pd_buffered_0/tapered_buf_3/a_n10_230# pd_buffered_0/pd_0/DOWN 0.02fF
C1657 div_pd_buffered_0/tapered_buf_4/a_580_0# div_pd_buffered_0/tapered_buf_4/a_160_n140# 0.35fF
C1658 divider_1/and_0/OUT divider_1/and_0/B 0.01fF
C1659 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/nor_0/B 0.47fF
C1660 div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 div_pd_buffered_0/pd_0/R 0.01fF
C1661 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/pd_0/tspc_r_1/Qbar 0.21fF
C1662 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/tspc_r_1/Z4 0.02fF
C1663 ro_complete_buffered_0/tapered_buf_0/a_1650_0# ro_complete_buffered_0/tapered_buf_0/a_580_0# 1.27fF
C1664 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/Z3 0.16fF
C1665 pll_full_1/ro_complete_0/cbank_2/switch_2/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C1666 div_pd_buffered_0/divider_0/tspc_1/Z1 div_pd_buffered_0/divider_0/tspc_1/Z4 0.00fF
C1667 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C1668 div_pd_buffered_0/divider_0/nor_0/Z1 div_pd_buffered_0/divider_0/and_0/B 0.78fF
C1669 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z1 0.08fF
C1670 divider_0/prescaler_0/tspc_1/Z4 divider_0/prescaler_0/tspc_1/Z2 0.36fF
C1671 ro_complete_buffered_0/ro_complete_0/a3 ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C1672 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/prescaler_0/nand_1/z1 0.01fF
C1673 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/vco 0.11fF
C1674 pll_full_1/pd_0/R pll_full_1/pd_0/tspc_r_0/Z2 0.21fF
C1675 divider_1/mc2 divider_1/nor_1/A 0.04fF
C1676 divider_1/prescaler_0/m1_2700_2190# divider_1/clk 0.01fF
C1677 divider_1/tspc_1/Z2 divider_1/nor_1/B 0.30fF
C1678 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1679 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Q 0.04fF
C1680 pd_buffered_0/pd_0/DIV pd_buffered_0/pd_0/tspc_r_1/Z3 0.65fF
C1681 io_clamp_high[2] io_analog[6] 0.53fF
C1682 div_pd_buffered_0/tapered_buf_4/a_n10_n140# div_pd_buffered_0/tapered_buf_4/in 0.04fF
C1683 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/out1 0.31fF
C1684 pll_full_0/divider_0/tspc_1/Z4 pll_full_0/divider_0/tspc_0/Q 0.15fF
C1685 div_pd_buffered_0/divider_0/tspc_0/Z1 div_pd_buffered_0/divider_0/tspc_0/Z4 0.00fF
C1686 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/a1 0.14fF
C1687 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_0/a_740_n680# 0.21fF
C1688 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/and_0/B 0.78fF
C1689 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/clk 0.01fF
C1690 divider_1/prescaler_0/Out divider_1/tspc_0/Z2 0.11fF
C1691 pll_full_1/divider_0/tspc_2/Z3 pll_full_1/divider_0/tspc_2/Z4 0.65fF
C1692 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1693 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/div 0.17fF
C1694 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z2 1.07fF
C1695 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/ref 0.04fF
C1696 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_1/B 0.35fF
C1697 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/vco 0.11fF
C1698 pd_buffered_0/tapered_buf_1/a_n10_230# pd_buffered_0/pd_0/UP 0.02fF
C1699 pd_buffered_0/pd_0/R pd_buffered_0/pd_0/and_pd_0/Out1 0.33fF
C1700 divider_0/nor_0/Z1 divider_0/nor_0/B 0.06fF
C1701 div_pd_buffered_0/pd_0/REF div_pd_buffered_0/pd_0/tspc_r_0/Z1 0.17fF
C1702 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/B 0.29fF
C1703 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1704 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C1705 ro_complete_buffered_0/tapered_buf_3/a_n10_230# ro_complete_buffered_0/tapered_buf_3/a_n10_n140# 0.01fF
C1706 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1707 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# 0.21fF
C1708 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C1709 pd_buffered_0/tapered_buf_2/a_160_230# pd_buffered_0/tapered_buf_2/a_n10_230# 0.09fF
C1710 ro_complete_buffered_0/ro_complete_0/a3 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_2/vin 0.21fF
C1711 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1712 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/tspc_r_1/Z4 0.14fF
C1713 div_pd_buffered_0/divider_0/tspc_1/Q div_pd_buffered_0/divider_0/tspc_2/Z1 0.01fF
C1714 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/tspc_0/Q 0.22fF
C1715 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/z5 0.20fF
C1716 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C1717 divider_0/tspc_1/a_630_n680# divider_0/tspc_0/Q 0.01fF
C1718 divider_0/tspc_1/Z3 divider_0/tspc_1/Z4 0.65fF
C1719 ro_complete_0/a5 ro_complete_0/cbank_2/v 0.08fF
C1720 cp_buffered_0/tapered_buf_2/a_210_n610# cp_buffered_0/tapered_buf_2/a_580_0# 0.84fF
C1721 pll_full_1/pd_0/R pll_full_1/pd_0/tspc_r_0/Qbar 0.03fF
C1722 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_1/B 0.06fF
C1723 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_1/Q 0.13fF
C1724 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z4 0.00fF
C1725 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/and_0/OUT 0.05fF
C1726 div_pd_buffered_0/tapered_buf_4/a_580_0# div_pd_buffered_0/tapered_buf_4/a_160_230# 0.02fF
C1727 divider_1/prescaler_0/tspc_0/D divider_1/prescaler_0/nand_1/z1 0.21fF
C1728 divider_1/nor_1/B divider_1/and_0/A 0.26fF
C1729 cp_buffered_0/cp_0/a_10_n50# cp_buffered_0/cp_0/a_1710_0# 0.04fF
C1730 div_pd_buffered_0/pd_0/tspc_r_0/Z2 div_pd_buffered_0/pd_0/R 0.21fF
C1731 div_pd_buffered_0/divider_0/tspc_1/Z2 div_pd_buffered_0/divider_0/nor_1/B 0.30fF
C1732 divider_1/prescaler_0/Out divider_1/prescaler_0/m1_2700_2190# 0.11fF
C1733 ro_complete_buffered_0/tapered_buf_6/a_210_n610# ro_complete_buffered_0/ro_complete_0/a4 26.29fF
C1734 ro_complete_buffered_0/tapered_buf_4/a_580_0# ro_complete_buffered_0/tapered_buf_4/a_160_230# 0.02fF
C1735 ro_complete_buffered_0/tapered_buf_4/a_160_n140# ro_complete_buffered_0/tapered_buf_4/a_210_n610# 0.22fF
C1736 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/v 1.30fF
C1737 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1738 pll_full_1/ro_complete_0/a1 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1739 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_4/vin ro_complete_buffered_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C1740 pll_full_0/pd_0/tspc_r_1/z5 pll_full_0/pd_0/tspc_r_1/Z4 0.04fF
C1741 div_pd_buffered_0/divider_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/tspc_2/Z4 0.12fF
C1742 div_pd_buffered_0/divider_0/tspc_2/Z1 div_pd_buffered_0/divider_0/tspc_2/Z2 1.07fF
C1743 div_pd_buffered_0/divider_0/nor_0/B div_pd_buffered_0/divider_0/tspc_2/Z3 0.38fF
C1744 divider_1/tspc_0/Z1 divider_1/tspc_0/Z2 1.07fF
C1745 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z4 0.01fF
C1746 divider_1/prescaler_0/tspc_0/Z4 divider_1/clk 0.12fF
C1747 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Q 0.20fF
C1748 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/D 0.09fF
C1749 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/v 1.30fF
C1750 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1751 div_pd_buffered_0/tapered_buf_2/in div_pd_buffered_0/tapered_buf_2/a_n10_230# 0.02fF
C1752 cp_buffered_0/cp_0/a_1710_n2840# cp_buffered_0/cp_0/upbar 0.29fF
C1753 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z2 0.14fF
C1754 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z3 0.05fF
C1755 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C1756 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/vco 0.01fF
C1757 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/pd_0/and_pd_0/Z1 0.07fF
C1758 ro_complete_buffered_0/tapered_buf_5/a_n10_n140# ro_complete_buffered_0/tapered_buf_5/in 0.04fF
C1759 ro_complete_buffered_0/tapered_buf_3/a_580_0# ro_complete_buffered_0/tapered_buf_3/a_160_230# 0.02fF
C1760 ro_complete_buffered_0/tapered_buf_3/a_160_n140# ro_complete_buffered_0/tapered_buf_3/a_210_n610# 0.22fF
C1761 pll_full_0/pd_0/DOWN pll_full_0/pd_0/R 0.36fF
C1762 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# div_pd_buffered_0/divider_0/tspc_1/Z4 0.12fF
C1763 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C1764 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/clk 0.64fF
C1765 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C1766 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.09fF
C1767 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1768 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/B 0.01fF
C1769 div_pd_buffered_0/divider_0/and_0/out1 div_pd_buffered_0/divider_0/and_0/Z1 0.36fF
C1770 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Q 0.15fF
C1771 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/nand_1/z1 0.22fF
C1772 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/tspc_0/D 0.04fF
C1773 cp_buffered_0/tapered_buf_2/a_580_0# cp_buffered_0/tapered_buf_2/a_160_n140# 0.35fF
C1774 pd_buffered_0/pd_0/DOWN pd_buffered_0/pd_0/tspc_r_1/z5 0.03fF
C1775 pd_buffered_0/pd_0/tspc_r_1/Z2 pd_buffered_0/pd_0/R 0.21fF
C1776 pd_buffered_0/pd_0/tspc_r_0/Z3 pd_buffered_0/pd_0/UP 0.03fF
C1777 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/B 0.18fF
C1778 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1779 divider_1/nor_1/B divider_1/tspc_1/Z4 0.21fF
C1780 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z4 0.36fF
C1781 cp_buffered_0/tapered_buf_1/a_160_n140# cp_buffered_0/tapered_buf_1/a_n10_n140# 0.05fF
C1782 cp_buffered_0/tapered_buf_1/a_580_0# cp_buffered_0/tapered_buf_1/a_210_n610# 0.84fF
C1783 pll_full_1/pd_0/R pll_full_1/div 0.51fF
C1784 pll_full_0/divider_0/nor_0/B pll_full_0/div 0.27fF
C1785 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z3 0.06fF
C1786 pll_full_0/pd_0/tspc_r_0/Qbar pll_full_0/pd_0/R 0.03fF
C1787 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1788 ro_complete_buffered_0/tapered_buf_6/a_n10_n140# ro_complete_buffered_0/tapered_buf_6/in 0.04fF
C1789 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/a0 0.13fF
C1790 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# div_pd_buffered_0/divider_0/tspc_0/Q 0.04fF
C1791 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C1792 ro_complete_buffered_0/tapered_buf_0/a_n10_230# ro_complete_buffered_0/tapered_buf_0/a_160_230# 0.09fF
C1793 ro_complete_buffered_0/tapered_buf_0/a_4670_0# ro_complete_buffered_0/tapered_buf_0/a_210_n610# 29.21fF
C1794 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_3/vin ro_complete_buffered_0/ro_complete_0/a1 0.14fF
C1795 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_1/vin ro_complete_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C1796 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_2/vin ro_complete_buffered_0/ro_complete_0/a3 0.09fF
C1797 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/nand_0/z1 0.07fF
C1798 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1799 divider_1/prescaler_0/Out divider_1/tspc_0/Z4 0.12fF
C1800 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z4 0.08fF
C1801 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1802 divider_0/tspc_2/Z1 divider_0/tspc_2/Z4 0.00fF
C1803 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C1804 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Q 0.51fF
C1805 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z2 0.01fF
C1806 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1807 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1808 cp_buffered_0/tapered_buf_0/a_160_n140# cp_buffered_0/tapered_buf_0/a_n10_n140# 0.05fF
C1809 cp_buffered_0/tapered_buf_0/a_580_0# cp_buffered_0/tapered_buf_0/a_210_n610# 0.84fF
C1810 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Qbar 0.01fF
C1811 div_pd_buffered_0/pd_0/DOWN div_pd_buffered_0/tapered_buf_1/a_n10_230# 0.02fF
C1812 ro_complete_buffered_0/tapered_buf_7/a_n10_n140# ro_complete_buffered_0/tapered_buf_7/in 0.04fF
C1813 ro_complete_0/a4 ro_complete_0/cbank_2/switch_0/vin 0.12fF
C1814 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_0/Z4 0.12fF
C1815 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# 0.19fF
C1816 div_pd_buffered_0/divider_0/and_0/OUT div_pd_buffered_0/divider_0/clk 0.04fF
C1817 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_1/vin ro_complete_buffered_0/tapered_buf_1/in 1.30fF
C1818 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_5/vin ro_complete_buffered_0/ro_complete_0/cbank_0/v 1.30fF
C1819 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_0/Q 0.14fF
C1820 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/vco 0.01fF
C1821 cp_buffered_0/tapered_buf_2/a_4670_0# cp_buffered_0/tapered_buf_2/a_210_n610# 29.21fF
C1822 pd_buffered_0/tapered_buf_3/a_160_n140# pd_buffered_0/tapered_buf_3/a_160_230# 0.17fF
C1823 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Q 0.38fF
C1824 divider_0/prescaler_0/tspc_1/Z2 divider_0/and_0/OUT 0.06fF
C1825 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1826 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1827 ro_complete_0/cbank_0/v ro_complete_0/cbank_2/v 0.04fF
C1828 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/D 0.03fF
C1829 pd_buffered_0/pd_0/tspc_r_0/Qbar1 pd_buffered_0/pd_0/tspc_r_0/Qbar 0.01fF
C1830 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C1831 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1832 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z4 0.01fF
C1833 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_2/Z2 0.20fF
C1834 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Qbar1 0.38fF
C1835 div_pd_buffered_0/tapered_buf_0/a_160_230# div_pd_buffered_0/tapered_buf_0/a_580_0# 0.02fF
C1836 div_pd_buffered_0/pd_0/tspc_r_0/Qbar div_pd_buffered_0/pd_0/and_pd_0/Z1 0.02fF
C1837 div_pd_buffered_0/pd_0/tspc_r_1/Z3 div_pd_buffered_0/pd_0/tspc_r_1/z5 0.11fF
C1838 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_1/z5 0.03fF
C1839 pll_full_0/ref pll_full_0/pd_0/tspc_r_0/Z2 0.19fF
C1840 div_pd_buffered_0/divider_0/mc2 div_pd_buffered_0/divider_0/clk 0.04fF
C1841 div_pd_buffered_0/tapered_buf_0/a_4670_0# div_pd_buffered_0/tapered_buf_0/a_210_n610# 29.21fF
C1842 div_pd_buffered_0/divider_0/tspc_1/Z3 div_pd_buffered_0/divider_0/tspc_1/Z4 0.65fF
C1843 pll_full_1/ro_complete_0/cbank_2/switch_4/vin pll_full_1/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C1844 div_pd_buffered_0/tapered_buf_3/a_580_0# div_pd_buffered_0/tapered_buf_3/a_1650_0# 1.27fF
C1845 pll_full_1/divider_0/and_0/OUT pll_full_1/div 0.01fF
C1846 pll_full_1/divider_0/prescaler_0/tspc_0/D pll_full_1/divider_0/prescaler_0/nand_1/z1 0.21fF
C1847 divider_1/tspc_0/Z1 divider_1/tspc_0/Z4 0.00fF
C1848 divider_1/nor_1/Z1 divider_1/and_0/A 0.80fF
C1849 pd_buffered_0/tapered_buf_1/a_n10_n140# pd_buffered_0/tapered_buf_1/a_160_n140# 0.05fF
C1850 pd_buffered_0/pd_0/tspc_r_1/Z3 pd_buffered_0/pd_0/tspc_r_1/Qbar1 0.38fF
C1851 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1852 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/nor_1/B 1.21fF
C1853 divider_0/nor_1/A divider_0/tspc_0/Z4 0.21fF
C1854 io_clamp_low[1] io_analog[5] 0.53fF
C1855 div_pd_buffered_0/tapered_buf_4/a_160_230# div_pd_buffered_0/tapered_buf_4/a_160_n140# 0.17fF
C1856 divider_1/and_0/out1 divider_1/and_0/A 0.01fF
C1857 ro_complete_buffered_0/tapered_buf_6/a_580_0# ro_complete_buffered_0/tapered_buf_6/a_160_230# 0.02fF
C1858 ro_complete_buffered_0/tapered_buf_6/a_160_n140# ro_complete_buffered_0/tapered_buf_6/a_210_n610# 0.22fF
C1859 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C1860 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C1861 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1862 div_pd_buffered_0/pd_0/R div_pd_buffered_0/pd_0/UP 0.45fF
C1863 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C1864 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/vco 1.46fF
C1865 ro_complete_buffered_0/tapered_buf_2/a_1650_0# ro_complete_buffered_0/tapered_buf_2/a_4670_0# 4.78fF
C1866 div_pd_buffered_0/tapered_buf_3/a_1650_0# div_pd_buffered_0/tapered_buf_3/a_210_n610# 2.89fF
C1867 divider_1/nor_0/Z1 divider_1/and_0/B 0.78fF
C1868 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C1869 divider_1/nor_1/A divider_1/and_0/B 0.08fF
C1870 pll_full_1/pd_0/DOWN pll_full_1/cp_0/a_1710_0# 0.04fF
C1871 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/and_0/OUT 0.14fF
C1872 pll_full_0/divider_0/prescaler_0/Out pll_full_0/vco 0.51fF
C1873 div_pd_buffered_0/pd_0/tspc_r_0/Z3 div_pd_buffered_0/pd_0/tspc_r_0/Z2 0.25fF
C1874 div_pd_buffered_0/tapered_buf_3/a_160_230# div_pd_buffered_0/tapered_buf_3/a_580_0# 0.02fF
C1875 ro_complete_buffered_0/tapered_buf_7/a_580_0# ro_complete_buffered_0/tapered_buf_7/a_160_230# 0.02fF
C1876 ro_complete_buffered_0/tapered_buf_7/a_160_n140# ro_complete_buffered_0/tapered_buf_7/a_210_n610# 0.22fF
C1877 ro_complete_0/a3 ro_complete_0/cbank_1/switch_2/vin 0.09fF
C1878 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1879 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/nor_1/A 0.15fF
C1880 ro_complete_buffered_0/ro_complete_0/a3 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C1881 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_3/vin ro_complete_buffered_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1882 pd_buffered_0/tapered_buf_2/a_n10_n140# pd_buffered_0/tapered_buf_2/a_n10_230# 0.01fF
C1883 pll_full_0/cp_0/upbar pll_full_0/cp_0/down 0.02fF
C1884 div_pd_buffered_0/divider_0/tspc_1/Q div_pd_buffered_0/divider_0/tspc_2/Z3 0.45fF
C1885 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/and_0/A 0.26fF
C1886 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C1887 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_1/Q 0.21fF
C1888 divider_0/nor_1/B divider_0/tspc_0/Q 0.22fF
C1889 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C1890 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/tspc_r_0/Z3 0.09fF
C1891 div_pd_buffered_0/tapered_buf_4/a_1650_0# div_pd_buffered_0/tapered_buf_4/a_210_n610# 2.89fF
C1892 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/and_0/B 0.08fF
C1893 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C1894 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C1895 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/vco 0.12fF
C1896 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/tspc_r_0/Z3 0.11fF
C1897 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/pd_0/tspc_r_1/Z3 0.65fF
C1898 ro_complete_buffered_0/tapered_buf_4/a_1650_0# ro_complete_buffered_0/tapered_buf_4/a_210_n610# 2.89fF
C1899 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_5/vin 0.20fF
C1900 div_pd_buffered_0/pd_0/DIV div_pd_buffered_0/divider_0/tspc_2/Z3 0.05fF
C1901 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C1902 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z1 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C1903 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z3 0.05fF
C1904 divider_0/nor_1/B divider_0/tspc_1/Z1 0.03fF
C1905 divider_0/prescaler_0/tspc_1/Z4 divider_0/prescaler_0/m1_2700_2190# 0.08fF
C1906 ro_complete_buffered_0/ro_complete_0/a4 ro_complete_buffered_0/ro_complete_0/cbank_2/v 0.05fF
C1907 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_4/vin ro_complete_buffered_0/tapered_buf_1/in 1.30fF
C1908 div_pd_buffered_0/tapered_buf_0/a_1650_0# div_pd_buffered_0/tapered_buf_0/a_210_n610# 2.89fF
C1909 div_pd_buffered_0/divider_0/tspc_2/Z2 div_pd_buffered_0/divider_0/tspc_2/Z3 0.16fF
C1910 div_pd_buffered_0/divider_0/nor_0/B div_pd_buffered_0/divider_0/tspc_2/Z4 0.22fF
C1911 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Q 0.04fF
C1912 divider_0/prescaler_0/tspc_0/Z3 divider_0/clk 0.64fF
C1913 ro_complete_0/cbank_2/switch_0/vin ro_complete_0/cbank_2/v 1.45fF
C1914 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z2 1.07fF
C1915 divider_0/nor_1/A divider_0/prescaler_0/Out 0.15fF
C1916 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z3 0.05fF
C1917 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/B 0.31fF
C1918 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C1919 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C1920 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C1921 div_pd_buffered_0/pd_0/R div_pd_buffered_0/pd_0/and_pd_0/Out1 0.33fF
C1922 ro_complete_buffered_0/tapered_buf_1/out ro_complete_buffered_0/tapered_buf_1/a_210_n610# 26.29fF
C1923 ro_complete_buffered_0/tapered_buf_4/a_n10_230# ro_complete_buffered_0/tapered_buf_4/a_160_230# 0.09fF
C1924 ro_complete_buffered_0/tapered_buf_4/a_4670_0# ro_complete_buffered_0/tapered_buf_4/a_210_n610# 29.21fF
C1925 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_1/a_630_n680# 0.05fF
C1926 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/nor_1/B 0.03fF
C1927 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C1928 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C1929 div_pd_buffered_0/divider_0/nor_1/B div_pd_buffered_0/divider_0/tspc_1/Z4 0.21fF
C1930 div_pd_buffered_0/divider_0/prescaler_0/Out div_pd_buffered_0/divider_0/tspc_0/Z3 0.45fF
C1931 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z4 0.12fF
C1932 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z4 0.36fF
C1933 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/Out 0.05fF
C1934 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_2/vin ro_complete_buffered_0/ro_complete_0/cbank_2/v 1.30fF
C1935 div_pd_buffered_0/divider_0/and_0/A div_pd_buffered_0/divider_0/and_0/B 0.18fF
C1936 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C1937 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1938 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/a3 0.09fF
C1939 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/nand_1/z1 0.01fF
C1940 divider_0/prescaler_0/tspc_2/Z2 divider_0/clk 0.11fF
C1941 pd_buffered_0/pd_0/tspc_r_1/Z2 pd_buffered_0/pd_0/tspc_r_1/Z4 0.14fF
Xpd_buffered_0/tapered_buf_2 vdda1 vssa1 pd_buffered_0/tapered_buf_2/in pd_buffered_0/pd_0/DIV
+ tapered_buf
Xpd_buffered_0/tapered_buf_3 vdd vssa1 pd_buffered_0/pd_0/DOWN pd_buffered_0/tapered_buf_3/out
+ tapered_buf
Xpd_buffered_0/pd_0 vssa1 pd_buffered_0/pd_0/REF pd_buffered_0/pd_0/DIV pd_buffered_0/pd_0/UP
+ pd_buffered_0/pd_0/DOWN pd_buffered_0/pd_0/R vssa1 vdd pd
Xpd_buffered_0/tapered_buf_1 vdd vssa1 pd_buffered_0/pd_0/UP pd_buffered_0/tapered_buf_1/out
+ tapered_buf
Xpd_buffered_0/tapered_buf_0 vdda1 vssa1 pd_buffered_0/tapered_buf_0/in pd_buffered_0/pd_0/REF
+ tapered_buf
Xcp_buffered_0 vdda1 vdda1 cp_buffered
Xfilter_0 vssa1 filter_0/v filter
Xro_complete_0 ro_complete_0/a0 ro_complete_0/a1 ro_complete_0/a5 ro_complete_0/a4
+ ro_complete_0/a3 ro_complete_0/a2 ro_complete
Xro_complete_buffered_0 vdda1 ro_complete_buffered
Xdivider_0 vdda1 vdd divider_0/Out divider_0/clk divider_0/mc2 vdda1 vdd divider
Xdivider_1 vssa1 vdda1 divider_1/Out divider_1/clk divider_1/mc2 vssa1 vdda1 divider
Xdiv_pd_buffered_0 vdda1 vssa1 div_pd_buffered
Xpll_full_0 vdd pll_full_0/ref pll_full_0/div pll_full_0/vco pll_full
Xpll_full_1 vdd pll_full_1/ref pll_full_1/div pll_full_1/vco pll_full
C1942 io_analog[4] vssa1 43.96fF
C1943 io_analog[5] vssa1 44.13fF
C1944 io_analog[6] vssa1 43.46fF
C1945 io_in_3v3[0] vssa1 0.61fF
C1946 io_oeb[26] vssa1 0.61fF
C1947 io_in[0] vssa1 0.61fF
C1948 io_out[26] vssa1 0.61fF
C1949 io_out[0] vssa1 0.61fF
C1950 io_in[26] vssa1 0.61fF
C1951 io_oeb[0] vssa1 0.61fF
C1952 io_in_3v3[26] vssa1 0.61fF
C1953 io_in_3v3[1] vssa1 0.61fF
C1954 io_oeb[25] vssa1 0.61fF
C1955 io_in[1] vssa1 0.61fF
C1956 io_out[25] vssa1 0.61fF
C1957 io_out[1] vssa1 0.61fF
C1958 io_in[25] vssa1 0.61fF
C1959 io_oeb[1] vssa1 0.61fF
C1960 io_in_3v3[25] vssa1 0.61fF
C1961 io_in_3v3[2] vssa1 0.61fF
C1962 io_oeb[24] vssa1 0.61fF
C1963 io_in[2] vssa1 0.61fF
C1964 io_out[24] vssa1 0.61fF
C1965 io_out[2] vssa1 0.61fF
C1966 io_in[24] vssa1 0.61fF
C1967 io_oeb[2] vssa1 0.61fF
C1968 io_in_3v3[24] vssa1 0.61fF
C1969 io_in_3v3[3] vssa1 0.61fF
C1970 gpio_noesd[17] vssa1 2.32fF
C1971 io_in[3] vssa1 0.61fF
C1972 gpio_analog[17] vssa1 2.30fF
C1973 io_out[3] vssa1 0.61fF
C1974 io_oeb[3] vssa1 0.61fF
C1975 io_in_3v3[4] vssa1 0.61fF
C1976 io_in[4] vssa1 0.61fF
C1977 io_out[4] vssa1 0.61fF
C1978 io_oeb[4] vssa1 0.61fF
C1979 io_oeb[23] vssa1 0.61fF
C1980 io_out[23] vssa1 0.61fF
C1981 io_in[23] vssa1 0.61fF
C1982 io_in_3v3[23] vssa1 0.61fF
C1983 gpio_noesd[16] vssa1 2.30fF
C1984 gpio_analog[16] vssa1 2.30fF
C1985 io_in_3v3[5] vssa1 0.61fF
C1986 io_in[5] vssa1 0.61fF
C1987 io_out[5] vssa1 0.61fF
C1988 io_oeb[5] vssa1 0.61fF
C1989 io_oeb[22] vssa1 0.61fF
C1990 io_out[22] vssa1 0.61fF
C1991 io_in[22] vssa1 0.61fF
C1992 io_in_3v3[22] vssa1 0.61fF
C1993 gpio_noesd[15] vssa1 2.31fF
C1994 gpio_analog[15] vssa1 2.30fF
C1995 io_in_3v3[6] vssa1 0.61fF
C1996 io_in[6] vssa1 0.61fF
C1997 io_out[6] vssa1 0.61fF
C1998 io_oeb[6] vssa1 0.61fF
C1999 io_oeb[21] vssa1 0.61fF
C2000 io_out[21] vssa1 0.61fF
C2001 io_in[21] vssa1 0.61fF
C2002 io_in_3v3[21] vssa1 0.61fF
C2003 gpio_noesd[14] vssa1 2.30fF
C2004 gpio_analog[14] vssa1 2.29fF
C2005 vssd2 vssa1 38.54fF
C2006 vssd1 vssa1 13.04fF
C2007 vdda2 vssa1 38.30fF
C2008 io_oeb[20] vssa1 0.61fF
C2009 io_out[20] vssa1 0.61fF
C2010 io_in[20] vssa1 0.61fF
C2011 io_in_3v3[20] vssa1 0.61fF
C2012 gpio_noesd[13] vssa1 2.31fF
C2013 gpio_analog[13] vssa1 2.30fF
C2014 gpio_analog[0] vssa1 0.61fF
C2015 gpio_noesd[0] vssa1 0.61fF
C2016 io_in_3v3[7] vssa1 0.61fF
C2017 io_in[7] vssa1 0.61fF
C2018 io_out[7] vssa1 0.61fF
C2019 io_oeb[7] vssa1 0.61fF
C2020 io_oeb[19] vssa1 0.61fF
C2021 io_out[19] vssa1 0.61fF
C2022 io_in[19] vssa1 0.61fF
C2023 io_in_3v3[19] vssa1 0.61fF
C2024 gpio_noesd[12] vssa1 2.32fF
C2025 gpio_analog[12] vssa1 2.30fF
C2026 gpio_analog[1] vssa1 0.61fF
C2027 gpio_noesd[1] vssa1 0.61fF
C2028 io_in_3v3[8] vssa1 0.61fF
C2029 io_in[8] vssa1 0.61fF
C2030 io_out[8] vssa1 0.61fF
C2031 io_oeb[8] vssa1 0.61fF
C2032 io_oeb[18] vssa1 0.61fF
C2033 io_out[18] vssa1 0.61fF
C2034 io_in[18] vssa1 0.61fF
C2035 io_in_3v3[18] vssa1 0.61fF
C2036 gpio_noesd[11] vssa1 2.30fF
C2037 gpio_analog[11] vssa1 2.29fF
C2038 gpio_analog[2] vssa1 0.61fF
C2039 gpio_noesd[2] vssa1 0.61fF
C2040 io_in_3v3[9] vssa1 0.61fF
C2041 io_in[9] vssa1 0.61fF
C2042 io_out[9] vssa1 0.61fF
C2043 io_oeb[9] vssa1 0.61fF
C2044 io_oeb[17] vssa1 0.61fF
C2045 io_out[17] vssa1 0.61fF
C2046 io_in[17] vssa1 0.61fF
C2047 io_in_3v3[17] vssa1 0.61fF
C2048 gpio_noesd[10] vssa1 2.31fF
C2049 gpio_analog[10] vssa1 2.29fF
C2050 gpio_analog[3] vssa1 0.61fF
C2051 gpio_noesd[3] vssa1 0.61fF
C2052 io_in_3v3[10] vssa1 0.61fF
C2053 io_in[10] vssa1 0.61fF
C2054 io_out[10] vssa1 0.61fF
C2055 io_oeb[10] vssa1 0.61fF
C2056 io_oeb[16] vssa1 0.61fF
C2057 io_out[16] vssa1 0.61fF
C2058 io_in[16] vssa1 0.61fF
C2059 io_in_3v3[16] vssa1 0.61fF
C2060 gpio_noesd[9] vssa1 2.28fF
C2061 gpio_analog[9] vssa1 2.28fF
C2062 gpio_analog[4] vssa1 0.61fF
C2063 gpio_noesd[4] vssa1 0.61fF
C2064 io_in_3v3[11] vssa1 0.61fF
C2065 io_in[11] vssa1 0.61fF
C2066 io_out[11] vssa1 0.61fF
C2067 io_oeb[11] vssa1 0.61fF
C2068 io_oeb[15] vssa1 0.61fF
C2069 io_out[15] vssa1 0.61fF
C2070 io_in[15] vssa1 0.61fF
C2071 io_in_3v3[15] vssa1 0.61fF
C2072 gpio_noesd[8] vssa1 2.28fF
C2073 gpio_analog[8] vssa1 2.26fF
C2074 gpio_analog[5] vssa1 0.61fF
C2075 gpio_noesd[5] vssa1 0.61fF
C2076 io_in_3v3[12] vssa1 0.61fF
C2077 io_in[12] vssa1 0.61fF
C2078 io_out[12] vssa1 0.61fF
C2079 io_oeb[12] vssa1 0.61fF
C2080 io_oeb[14] vssa1 0.61fF
C2081 io_out[14] vssa1 0.61fF
C2082 io_in[14] vssa1 0.61fF
C2083 io_in_3v3[14] vssa1 0.61fF
C2084 gpio_noesd[7] vssa1 2.30fF
C2085 gpio_analog[7] vssa1 2.28fF
C2086 vssa2 vssa1 38.35fF
C2087 gpio_analog[6] vssa1 5.71fF
C2088 gpio_noesd[6] vssa1 5.70fF
C2089 io_in_3v3[13] vssa1 0.61fF
C2090 io_in[13] vssa1 0.61fF
C2091 io_out[13] vssa1 0.61fF
C2092 io_oeb[13] vssa1 0.61fF
C2093 vccd1 vssa1 39.84fF
C2094 vccd2 vssa1 38.46fF
C2095 io_analog[0] vssa1 19.99fF
C2096 io_analog[10] vssa1 19.36fF
C2097 io_analog[1] vssa1 13.17fF
C2098 io_analog[2] vssa1 12.57fF
C2099 io_analog[3] vssa1 12.83fF
C2100 io_clamp_high[0] vssa1 3.58fF
C2101 io_clamp_low[0] vssa1 3.58fF
C2102 io_clamp_high[1] vssa1 3.58fF
C2103 io_clamp_low[1] vssa1 3.58fF
C2104 io_clamp_high[2] vssa1 3.58fF
C2105 io_clamp_low[2] vssa1 3.58fF
C2106 io_analog[7] vssa1 12.74fF
C2107 io_analog[8] vssa1 13.08fF
C2108 io_analog[9] vssa1 13.08fF
C2109 user_irq[2] vssa1 0.63fF
C2110 user_irq[1] vssa1 0.63fF
C2111 user_irq[0] vssa1 0.63fF
C2112 user_clock2 vssa1 0.63fF
C2113 la_oenb[127] vssa1 0.63fF
C2114 la_data_out[127] vssa1 0.63fF
C2115 la_data_in[127] vssa1 0.63fF
C2116 la_oenb[126] vssa1 0.63fF
C2117 la_data_out[126] vssa1 0.63fF
C2118 la_data_in[126] vssa1 0.63fF
C2119 la_oenb[125] vssa1 0.63fF
C2120 la_data_out[125] vssa1 0.63fF
C2121 la_data_in[125] vssa1 0.63fF
C2122 la_oenb[124] vssa1 0.63fF
C2123 la_data_out[124] vssa1 0.63fF
C2124 la_data_in[124] vssa1 0.63fF
C2125 la_oenb[123] vssa1 0.63fF
C2126 la_data_out[123] vssa1 0.63fF
C2127 la_data_in[123] vssa1 0.63fF
C2128 la_oenb[122] vssa1 0.63fF
C2129 la_data_out[122] vssa1 0.63fF
C2130 la_data_in[122] vssa1 0.63fF
C2131 la_oenb[121] vssa1 0.63fF
C2132 la_data_out[121] vssa1 0.63fF
C2133 la_data_in[121] vssa1 0.63fF
C2134 la_oenb[120] vssa1 0.63fF
C2135 la_data_out[120] vssa1 0.63fF
C2136 la_data_in[120] vssa1 0.63fF
C2137 la_oenb[119] vssa1 0.63fF
C2138 la_data_out[119] vssa1 0.63fF
C2139 la_data_in[119] vssa1 0.63fF
C2140 la_oenb[118] vssa1 0.63fF
C2141 la_data_out[118] vssa1 0.63fF
C2142 la_data_in[118] vssa1 0.63fF
C2143 la_oenb[117] vssa1 0.63fF
C2144 la_data_out[117] vssa1 0.63fF
C2145 la_data_in[117] vssa1 0.63fF
C2146 la_oenb[116] vssa1 0.63fF
C2147 la_data_out[116] vssa1 0.63fF
C2148 la_data_in[116] vssa1 0.63fF
C2149 la_oenb[115] vssa1 0.63fF
C2150 la_data_out[115] vssa1 0.63fF
C2151 la_data_in[115] vssa1 0.63fF
C2152 la_oenb[114] vssa1 0.63fF
C2153 la_data_out[114] vssa1 0.63fF
C2154 la_data_in[114] vssa1 0.63fF
C2155 la_oenb[113] vssa1 0.63fF
C2156 la_data_out[113] vssa1 0.63fF
C2157 la_data_in[113] vssa1 0.63fF
C2158 la_oenb[112] vssa1 0.63fF
C2159 la_data_out[112] vssa1 0.63fF
C2160 la_data_in[112] vssa1 0.63fF
C2161 la_oenb[111] vssa1 0.63fF
C2162 la_data_out[111] vssa1 0.63fF
C2163 la_data_in[111] vssa1 0.63fF
C2164 la_oenb[110] vssa1 0.63fF
C2165 la_data_out[110] vssa1 0.63fF
C2166 la_data_in[110] vssa1 0.63fF
C2167 la_oenb[109] vssa1 0.63fF
C2168 la_data_out[109] vssa1 0.63fF
C2169 la_data_in[109] vssa1 0.63fF
C2170 la_oenb[108] vssa1 0.63fF
C2171 la_data_out[108] vssa1 0.63fF
C2172 la_data_in[108] vssa1 0.63fF
C2173 la_oenb[107] vssa1 0.63fF
C2174 la_data_out[107] vssa1 0.63fF
C2175 la_data_in[107] vssa1 0.63fF
C2176 la_oenb[106] vssa1 0.63fF
C2177 la_data_out[106] vssa1 0.63fF
C2178 la_data_in[106] vssa1 0.63fF
C2179 la_oenb[105] vssa1 0.63fF
C2180 la_data_out[105] vssa1 0.63fF
C2181 la_data_in[105] vssa1 0.63fF
C2182 la_oenb[104] vssa1 0.63fF
C2183 la_data_out[104] vssa1 0.63fF
C2184 la_data_in[104] vssa1 0.63fF
C2185 la_oenb[103] vssa1 0.63fF
C2186 la_data_out[103] vssa1 0.63fF
C2187 la_data_in[103] vssa1 0.63fF
C2188 la_oenb[102] vssa1 0.63fF
C2189 la_data_out[102] vssa1 0.63fF
C2190 la_data_in[102] vssa1 0.63fF
C2191 la_oenb[101] vssa1 0.63fF
C2192 la_data_out[101] vssa1 0.63fF
C2193 la_data_in[101] vssa1 0.63fF
C2194 la_oenb[100] vssa1 0.63fF
C2195 la_data_out[100] vssa1 0.63fF
C2196 la_data_in[100] vssa1 0.63fF
C2197 la_oenb[99] vssa1 0.63fF
C2198 la_data_out[99] vssa1 0.63fF
C2199 la_data_in[99] vssa1 0.63fF
C2200 la_oenb[98] vssa1 0.63fF
C2201 la_data_out[98] vssa1 0.63fF
C2202 la_data_in[98] vssa1 0.63fF
C2203 la_oenb[97] vssa1 0.63fF
C2204 la_data_out[97] vssa1 0.63fF
C2205 la_data_in[97] vssa1 0.63fF
C2206 la_oenb[96] vssa1 0.63fF
C2207 la_data_out[96] vssa1 0.63fF
C2208 la_data_in[96] vssa1 0.63fF
C2209 la_oenb[95] vssa1 0.63fF
C2210 la_data_out[95] vssa1 0.63fF
C2211 la_data_in[95] vssa1 0.63fF
C2212 la_oenb[94] vssa1 0.63fF
C2213 la_data_out[94] vssa1 0.63fF
C2214 la_data_in[94] vssa1 0.63fF
C2215 la_oenb[93] vssa1 0.63fF
C2216 la_data_out[93] vssa1 0.63fF
C2217 la_data_in[93] vssa1 0.63fF
C2218 la_oenb[92] vssa1 0.63fF
C2219 la_data_out[92] vssa1 0.63fF
C2220 la_data_in[92] vssa1 0.63fF
C2221 la_oenb[91] vssa1 0.63fF
C2222 la_data_out[91] vssa1 0.63fF
C2223 la_data_in[91] vssa1 0.63fF
C2224 la_oenb[90] vssa1 0.63fF
C2225 la_data_out[90] vssa1 0.63fF
C2226 la_data_in[90] vssa1 0.63fF
C2227 la_oenb[89] vssa1 0.63fF
C2228 la_data_out[89] vssa1 0.63fF
C2229 la_data_in[89] vssa1 0.63fF
C2230 la_oenb[88] vssa1 0.63fF
C2231 la_data_out[88] vssa1 0.63fF
C2232 la_data_in[88] vssa1 0.63fF
C2233 la_oenb[87] vssa1 0.63fF
C2234 la_data_out[87] vssa1 0.63fF
C2235 la_data_in[87] vssa1 0.63fF
C2236 la_oenb[86] vssa1 0.63fF
C2237 la_data_out[86] vssa1 0.63fF
C2238 la_data_in[86] vssa1 0.63fF
C2239 la_oenb[85] vssa1 0.63fF
C2240 la_data_out[85] vssa1 0.63fF
C2241 la_data_in[85] vssa1 0.63fF
C2242 la_oenb[84] vssa1 0.63fF
C2243 la_data_out[84] vssa1 0.63fF
C2244 la_data_in[84] vssa1 0.63fF
C2245 la_oenb[83] vssa1 0.63fF
C2246 la_data_out[83] vssa1 0.63fF
C2247 la_data_in[83] vssa1 0.63fF
C2248 la_oenb[82] vssa1 0.63fF
C2249 la_data_out[82] vssa1 0.63fF
C2250 la_data_in[82] vssa1 0.63fF
C2251 la_oenb[81] vssa1 0.63fF
C2252 la_data_out[81] vssa1 0.63fF
C2253 la_data_in[81] vssa1 0.63fF
C2254 la_oenb[80] vssa1 0.63fF
C2255 la_data_out[80] vssa1 0.63fF
C2256 la_data_in[80] vssa1 0.63fF
C2257 la_oenb[79] vssa1 0.63fF
C2258 la_data_out[79] vssa1 0.63fF
C2259 la_data_in[79] vssa1 0.63fF
C2260 la_oenb[78] vssa1 0.63fF
C2261 la_data_out[78] vssa1 0.63fF
C2262 la_data_in[78] vssa1 0.63fF
C2263 la_oenb[77] vssa1 0.63fF
C2264 la_data_out[77] vssa1 0.63fF
C2265 la_data_in[77] vssa1 0.63fF
C2266 la_oenb[76] vssa1 0.63fF
C2267 la_data_out[76] vssa1 0.63fF
C2268 la_data_in[76] vssa1 0.63fF
C2269 la_oenb[75] vssa1 0.63fF
C2270 la_data_out[75] vssa1 0.63fF
C2271 la_data_in[75] vssa1 0.63fF
C2272 la_oenb[74] vssa1 0.63fF
C2273 la_data_out[74] vssa1 0.63fF
C2274 la_data_in[74] vssa1 0.63fF
C2275 la_oenb[73] vssa1 0.63fF
C2276 la_data_out[73] vssa1 0.63fF
C2277 la_data_in[73] vssa1 0.63fF
C2278 la_oenb[72] vssa1 0.63fF
C2279 la_data_out[72] vssa1 0.63fF
C2280 la_data_in[72] vssa1 0.63fF
C2281 la_oenb[71] vssa1 0.63fF
C2282 la_data_out[71] vssa1 0.63fF
C2283 la_data_in[71] vssa1 0.63fF
C2284 la_oenb[70] vssa1 0.63fF
C2285 la_data_out[70] vssa1 0.63fF
C2286 la_data_in[70] vssa1 0.63fF
C2287 la_oenb[69] vssa1 0.63fF
C2288 la_data_out[69] vssa1 0.63fF
C2289 la_data_in[69] vssa1 0.63fF
C2290 la_oenb[68] vssa1 0.63fF
C2291 la_data_out[68] vssa1 0.63fF
C2292 la_data_in[68] vssa1 0.63fF
C2293 la_oenb[67] vssa1 0.63fF
C2294 la_data_out[67] vssa1 0.63fF
C2295 la_data_in[67] vssa1 0.63fF
C2296 la_oenb[66] vssa1 0.63fF
C2297 la_data_out[66] vssa1 0.63fF
C2298 la_data_in[66] vssa1 0.63fF
C2299 la_oenb[65] vssa1 0.63fF
C2300 la_data_out[65] vssa1 0.63fF
C2301 la_data_in[65] vssa1 0.63fF
C2302 la_oenb[64] vssa1 0.63fF
C2303 la_data_out[64] vssa1 0.63fF
C2304 la_data_in[64] vssa1 0.63fF
C2305 la_oenb[63] vssa1 0.63fF
C2306 la_data_out[63] vssa1 0.63fF
C2307 la_data_in[63] vssa1 0.63fF
C2308 la_oenb[62] vssa1 0.63fF
C2309 la_data_out[62] vssa1 0.63fF
C2310 la_data_in[62] vssa1 0.63fF
C2311 la_oenb[61] vssa1 0.63fF
C2312 la_data_out[61] vssa1 0.63fF
C2313 la_data_in[61] vssa1 0.63fF
C2314 la_oenb[60] vssa1 0.63fF
C2315 la_data_out[60] vssa1 0.63fF
C2316 la_data_in[60] vssa1 0.63fF
C2317 la_oenb[59] vssa1 0.63fF
C2318 la_data_out[59] vssa1 0.63fF
C2319 la_data_in[59] vssa1 0.63fF
C2320 la_oenb[58] vssa1 0.63fF
C2321 la_data_out[58] vssa1 0.63fF
C2322 la_data_in[58] vssa1 0.63fF
C2323 la_oenb[57] vssa1 0.63fF
C2324 la_data_out[57] vssa1 0.63fF
C2325 la_data_in[57] vssa1 0.63fF
C2326 la_oenb[56] vssa1 0.63fF
C2327 la_data_out[56] vssa1 0.63fF
C2328 la_data_in[56] vssa1 0.63fF
C2329 la_oenb[55] vssa1 0.63fF
C2330 la_data_out[55] vssa1 0.63fF
C2331 la_data_in[55] vssa1 0.63fF
C2332 la_oenb[54] vssa1 0.63fF
C2333 la_data_out[54] vssa1 0.63fF
C2334 la_data_in[54] vssa1 0.63fF
C2335 la_oenb[53] vssa1 0.63fF
C2336 la_data_out[53] vssa1 0.63fF
C2337 la_data_in[53] vssa1 0.63fF
C2338 la_oenb[52] vssa1 0.63fF
C2339 la_data_out[52] vssa1 0.63fF
C2340 la_data_in[52] vssa1 0.63fF
C2341 la_oenb[51] vssa1 0.63fF
C2342 la_data_out[51] vssa1 0.63fF
C2343 la_data_in[51] vssa1 0.63fF
C2344 la_oenb[50] vssa1 0.63fF
C2345 la_data_out[50] vssa1 0.63fF
C2346 la_data_in[50] vssa1 0.63fF
C2347 la_oenb[49] vssa1 0.63fF
C2348 la_data_out[49] vssa1 0.63fF
C2349 la_data_in[49] vssa1 0.63fF
C2350 la_oenb[48] vssa1 0.63fF
C2351 la_data_out[48] vssa1 0.63fF
C2352 la_data_in[48] vssa1 0.63fF
C2353 la_oenb[47] vssa1 0.63fF
C2354 la_data_out[47] vssa1 0.63fF
C2355 la_data_in[47] vssa1 0.63fF
C2356 la_oenb[46] vssa1 0.63fF
C2357 la_data_out[46] vssa1 0.63fF
C2358 la_data_in[46] vssa1 0.63fF
C2359 la_oenb[45] vssa1 0.63fF
C2360 la_data_out[45] vssa1 0.63fF
C2361 la_data_in[45] vssa1 0.63fF
C2362 la_oenb[44] vssa1 0.63fF
C2363 la_data_out[44] vssa1 0.63fF
C2364 la_data_in[44] vssa1 0.63fF
C2365 la_oenb[43] vssa1 0.63fF
C2366 la_data_out[43] vssa1 0.63fF
C2367 la_data_in[43] vssa1 0.63fF
C2368 la_oenb[42] vssa1 0.63fF
C2369 la_data_out[42] vssa1 0.63fF
C2370 la_data_in[42] vssa1 0.63fF
C2371 la_oenb[41] vssa1 0.63fF
C2372 la_data_out[41] vssa1 0.63fF
C2373 la_data_in[41] vssa1 0.63fF
C2374 la_oenb[40] vssa1 0.63fF
C2375 la_data_out[40] vssa1 0.63fF
C2376 la_data_in[40] vssa1 0.63fF
C2377 la_oenb[39] vssa1 0.63fF
C2378 la_data_out[39] vssa1 0.63fF
C2379 la_data_in[39] vssa1 0.63fF
C2380 la_oenb[38] vssa1 0.63fF
C2381 la_data_out[38] vssa1 0.63fF
C2382 la_data_in[38] vssa1 0.63fF
C2383 la_oenb[37] vssa1 0.63fF
C2384 la_data_out[37] vssa1 0.63fF
C2385 la_data_in[37] vssa1 0.63fF
C2386 la_oenb[36] vssa1 0.63fF
C2387 la_data_out[36] vssa1 0.63fF
C2388 la_data_in[36] vssa1 0.63fF
C2389 la_oenb[35] vssa1 0.63fF
C2390 la_data_out[35] vssa1 0.63fF
C2391 la_data_in[35] vssa1 0.63fF
C2392 la_oenb[34] vssa1 0.63fF
C2393 la_data_out[34] vssa1 0.63fF
C2394 la_data_in[34] vssa1 0.63fF
C2395 la_oenb[33] vssa1 0.63fF
C2396 la_data_out[33] vssa1 0.63fF
C2397 la_data_in[33] vssa1 0.63fF
C2398 la_oenb[32] vssa1 0.63fF
C2399 la_data_out[32] vssa1 0.63fF
C2400 la_data_in[32] vssa1 0.63fF
C2401 la_oenb[31] vssa1 0.63fF
C2402 la_data_out[31] vssa1 0.63fF
C2403 la_data_in[31] vssa1 0.63fF
C2404 la_oenb[30] vssa1 0.63fF
C2405 la_data_out[30] vssa1 0.63fF
C2406 la_data_in[30] vssa1 0.63fF
C2407 la_oenb[29] vssa1 0.63fF
C2408 la_data_out[29] vssa1 0.63fF
C2409 la_data_in[29] vssa1 0.63fF
C2410 la_oenb[28] vssa1 0.63fF
C2411 la_data_out[28] vssa1 0.63fF
C2412 la_data_in[28] vssa1 0.63fF
C2413 la_oenb[27] vssa1 0.63fF
C2414 la_data_out[27] vssa1 0.63fF
C2415 la_data_in[27] vssa1 0.63fF
C2416 la_oenb[26] vssa1 0.63fF
C2417 la_data_out[26] vssa1 0.63fF
C2418 la_data_in[26] vssa1 0.63fF
C2419 la_oenb[25] vssa1 0.63fF
C2420 la_data_out[25] vssa1 0.63fF
C2421 la_data_in[25] vssa1 0.63fF
C2422 la_oenb[24] vssa1 0.63fF
C2423 la_data_out[24] vssa1 0.63fF
C2424 la_data_in[24] vssa1 0.63fF
C2425 la_oenb[23] vssa1 0.63fF
C2426 la_data_out[23] vssa1 0.63fF
C2427 la_data_in[23] vssa1 0.63fF
C2428 la_oenb[22] vssa1 0.63fF
C2429 la_data_out[22] vssa1 0.63fF
C2430 la_data_in[22] vssa1 0.63fF
C2431 la_oenb[21] vssa1 0.63fF
C2432 la_data_out[21] vssa1 0.63fF
C2433 la_data_in[21] vssa1 0.63fF
C2434 la_oenb[20] vssa1 0.63fF
C2435 la_data_out[20] vssa1 0.63fF
C2436 la_data_in[20] vssa1 0.63fF
C2437 la_oenb[19] vssa1 0.63fF
C2438 la_data_out[19] vssa1 0.63fF
C2439 la_data_in[19] vssa1 0.63fF
C2440 la_oenb[18] vssa1 0.63fF
C2441 la_data_out[18] vssa1 0.63fF
C2442 la_data_in[18] vssa1 0.63fF
C2443 la_oenb[17] vssa1 0.63fF
C2444 la_data_out[17] vssa1 0.63fF
C2445 la_data_in[17] vssa1 0.63fF
C2446 la_oenb[16] vssa1 0.63fF
C2447 la_data_out[16] vssa1 0.63fF
C2448 la_data_in[16] vssa1 0.63fF
C2449 la_oenb[15] vssa1 0.63fF
C2450 la_data_out[15] vssa1 0.63fF
C2451 la_data_in[15] vssa1 0.63fF
C2452 la_oenb[14] vssa1 0.63fF
C2453 la_data_out[14] vssa1 0.63fF
C2454 la_data_in[14] vssa1 0.63fF
C2455 la_oenb[13] vssa1 0.63fF
C2456 la_data_out[13] vssa1 0.63fF
C2457 la_data_in[13] vssa1 0.63fF
C2458 la_oenb[12] vssa1 0.63fF
C2459 la_data_out[12] vssa1 0.63fF
C2460 la_data_in[12] vssa1 0.63fF
C2461 la_oenb[11] vssa1 0.63fF
C2462 la_data_out[11] vssa1 0.63fF
C2463 la_data_in[11] vssa1 0.63fF
C2464 la_oenb[10] vssa1 0.63fF
C2465 la_data_out[10] vssa1 0.63fF
C2466 la_data_in[10] vssa1 0.63fF
C2467 la_oenb[9] vssa1 0.63fF
C2468 la_data_out[9] vssa1 0.63fF
C2469 la_data_in[9] vssa1 0.63fF
C2470 la_oenb[8] vssa1 0.63fF
C2471 la_data_out[8] vssa1 0.63fF
C2472 la_data_in[8] vssa1 0.63fF
C2473 la_oenb[7] vssa1 0.63fF
C2474 la_data_out[7] vssa1 0.63fF
C2475 la_data_in[7] vssa1 0.63fF
C2476 la_oenb[6] vssa1 0.63fF
C2477 la_data_out[6] vssa1 0.63fF
C2478 la_data_in[6] vssa1 0.63fF
C2479 la_oenb[5] vssa1 0.63fF
C2480 la_data_out[5] vssa1 0.63fF
C2481 la_data_in[5] vssa1 0.63fF
C2482 la_oenb[4] vssa1 0.63fF
C2483 la_data_out[4] vssa1 0.63fF
C2484 la_data_in[4] vssa1 0.63fF
C2485 la_oenb[3] vssa1 0.63fF
C2486 la_data_out[3] vssa1 0.63fF
C2487 la_data_in[3] vssa1 0.63fF
C2488 la_oenb[2] vssa1 0.63fF
C2489 la_data_out[2] vssa1 0.63fF
C2490 la_data_in[2] vssa1 0.63fF
C2491 la_oenb[1] vssa1 0.63fF
C2492 la_data_out[1] vssa1 0.63fF
C2493 la_data_in[1] vssa1 0.63fF
C2494 la_oenb[0] vssa1 0.63fF
C2495 la_data_out[0] vssa1 0.63fF
C2496 la_data_in[0] vssa1 0.63fF
C2497 wbs_dat_o[31] vssa1 0.63fF
C2498 wbs_dat_i[31] vssa1 0.63fF
C2499 wbs_adr_i[31] vssa1 0.63fF
C2500 wbs_dat_o[30] vssa1 0.63fF
C2501 wbs_dat_i[30] vssa1 0.63fF
C2502 wbs_adr_i[30] vssa1 0.63fF
C2503 wbs_dat_o[29] vssa1 0.63fF
C2504 wbs_dat_i[29] vssa1 0.63fF
C2505 wbs_adr_i[29] vssa1 0.63fF
C2506 wbs_dat_o[28] vssa1 0.63fF
C2507 wbs_dat_i[28] vssa1 0.63fF
C2508 wbs_adr_i[28] vssa1 0.63fF
C2509 wbs_dat_o[27] vssa1 0.63fF
C2510 wbs_dat_i[27] vssa1 0.63fF
C2511 wbs_adr_i[27] vssa1 0.63fF
C2512 wbs_dat_o[26] vssa1 0.63fF
C2513 wbs_dat_i[26] vssa1 0.63fF
C2514 wbs_adr_i[26] vssa1 0.63fF
C2515 wbs_dat_o[25] vssa1 0.63fF
C2516 wbs_dat_i[25] vssa1 0.63fF
C2517 wbs_adr_i[25] vssa1 0.63fF
C2518 wbs_dat_o[24] vssa1 0.63fF
C2519 wbs_dat_i[24] vssa1 0.63fF
C2520 wbs_adr_i[24] vssa1 0.63fF
C2521 wbs_dat_o[23] vssa1 0.63fF
C2522 wbs_dat_i[23] vssa1 0.63fF
C2523 wbs_adr_i[23] vssa1 0.63fF
C2524 wbs_dat_o[22] vssa1 0.63fF
C2525 wbs_dat_i[22] vssa1 0.63fF
C2526 wbs_adr_i[22] vssa1 0.63fF
C2527 wbs_dat_o[21] vssa1 0.63fF
C2528 wbs_dat_i[21] vssa1 0.63fF
C2529 wbs_adr_i[21] vssa1 0.63fF
C2530 wbs_dat_o[20] vssa1 0.63fF
C2531 wbs_dat_i[20] vssa1 0.63fF
C2532 wbs_adr_i[20] vssa1 0.63fF
C2533 wbs_dat_o[19] vssa1 0.63fF
C2534 wbs_dat_i[19] vssa1 0.63fF
C2535 wbs_adr_i[19] vssa1 0.63fF
C2536 wbs_dat_o[18] vssa1 0.63fF
C2537 wbs_dat_i[18] vssa1 0.63fF
C2538 wbs_adr_i[18] vssa1 0.63fF
C2539 wbs_dat_o[17] vssa1 0.63fF
C2540 wbs_dat_i[17] vssa1 0.63fF
C2541 wbs_adr_i[17] vssa1 0.63fF
C2542 wbs_dat_o[16] vssa1 0.63fF
C2543 wbs_dat_i[16] vssa1 0.63fF
C2544 wbs_adr_i[16] vssa1 0.63fF
C2545 wbs_dat_o[15] vssa1 0.63fF
C2546 wbs_dat_i[15] vssa1 0.63fF
C2547 wbs_adr_i[15] vssa1 0.63fF
C2548 wbs_dat_o[14] vssa1 0.63fF
C2549 wbs_dat_i[14] vssa1 0.63fF
C2550 wbs_adr_i[14] vssa1 0.63fF
C2551 wbs_dat_o[13] vssa1 0.63fF
C2552 wbs_dat_i[13] vssa1 0.63fF
C2553 wbs_adr_i[13] vssa1 0.63fF
C2554 wbs_dat_o[12] vssa1 0.63fF
C2555 wbs_dat_i[12] vssa1 0.63fF
C2556 wbs_adr_i[12] vssa1 0.63fF
C2557 wbs_dat_o[11] vssa1 0.63fF
C2558 wbs_dat_i[11] vssa1 0.63fF
C2559 wbs_adr_i[11] vssa1 0.63fF
C2560 wbs_dat_o[10] vssa1 0.63fF
C2561 wbs_dat_i[10] vssa1 0.63fF
C2562 wbs_adr_i[10] vssa1 0.63fF
C2563 wbs_dat_o[9] vssa1 0.63fF
C2564 wbs_dat_i[9] vssa1 0.63fF
C2565 wbs_adr_i[9] vssa1 0.63fF
C2566 wbs_dat_o[8] vssa1 0.63fF
C2567 wbs_dat_i[8] vssa1 0.63fF
C2568 wbs_adr_i[8] vssa1 0.63fF
C2569 wbs_dat_o[7] vssa1 0.63fF
C2570 wbs_dat_i[7] vssa1 0.63fF
C2571 wbs_adr_i[7] vssa1 0.63fF
C2572 wbs_dat_o[6] vssa1 0.63fF
C2573 wbs_dat_i[6] vssa1 0.63fF
C2574 wbs_adr_i[6] vssa1 0.63fF
C2575 wbs_dat_o[5] vssa1 0.63fF
C2576 wbs_dat_i[5] vssa1 0.63fF
C2577 wbs_adr_i[5] vssa1 0.63fF
C2578 wbs_dat_o[4] vssa1 0.63fF
C2579 wbs_dat_i[4] vssa1 0.63fF
C2580 wbs_adr_i[4] vssa1 0.63fF
C2581 wbs_sel_i[3] vssa1 0.63fF
C2582 wbs_dat_o[3] vssa1 0.63fF
C2583 wbs_dat_i[3] vssa1 0.63fF
C2584 wbs_adr_i[3] vssa1 0.63fF
C2585 wbs_sel_i[2] vssa1 0.63fF
C2586 wbs_dat_o[2] vssa1 0.63fF
C2587 wbs_dat_i[2] vssa1 0.63fF
C2588 wbs_adr_i[2] vssa1 0.63fF
C2589 wbs_sel_i[1] vssa1 0.63fF
C2590 wbs_dat_o[1] vssa1 0.63fF
C2591 wbs_dat_i[1] vssa1 0.63fF
C2592 wbs_adr_i[1] vssa1 0.63fF
C2593 wbs_sel_i[0] vssa1 0.63fF
C2594 wbs_dat_o[0] vssa1 0.63fF
C2595 wbs_dat_i[0] vssa1 0.63fF
C2596 wbs_adr_i[0] vssa1 0.63fF
C2597 wbs_we_i vssa1 0.63fF
C2598 wbs_stb_i vssa1 0.63fF
C2599 wbs_cyc_i vssa1 0.63fF
C2600 wbs_ack_o vssa1 0.63fF
C2601 wb_rst_i vssa1 0.63fF
C2602 wb_clk_i vssa1 0.63fF
C2603 pll_full_1/divider_0/and_0/Z1 vssa1 0.65fF
C2604 pll_full_1/divider_0/and_0/B vssa1 2.45fF
C2605 pll_full_1/divider_0/and_0/A vssa1 2.35fF
C2606 pll_full_1/divider_0/and_0/out1 vssa1 2.99fF
C2607 pll_full_1/divider_0/tspc_2/Z4 vssa1 0.86fF
C2608 pll_full_1/div vssa1 14.90fF
C2609 pll_full_1/divider_0/tspc_2/Z3 vssa1 2.26fF
C2610 pll_full_1/divider_0/tspc_2/Z2 vssa1 1.46fF
C2611 pll_full_1/divider_0/tspc_2/Z1 vssa1 0.99fF
C2612 pll_full_1/divider_0/nor_0/B vssa1 6.48fF
C2613 pll_full_1/divider_0/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C2614 pll_full_1/divider_0/tspc_1/Z4 vssa1 0.86fF
C2615 pll_full_1/divider_0/tspc_1/Q vssa1 3.12fF
C2616 pll_full_1/divider_0/tspc_1/Z3 vssa1 2.26fF
C2617 pll_full_1/divider_0/tspc_1/Z2 vssa1 1.46fF
C2618 pll_full_1/divider_0/tspc_1/Z1 vssa1 0.99fF
C2619 pll_full_1/divider_0/nor_1/B vssa1 7.12fF
C2620 pll_full_1/divider_0/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C2621 pll_full_1/divider_0/tspc_0/Z4 vssa1 0.86fF
C2622 pll_full_1/divider_0/tspc_0/Q vssa1 3.14fF
C2623 pll_full_1/divider_0/tspc_0/Z3 vssa1 2.26fF
C2624 pll_full_1/divider_0/tspc_0/Z2 vssa1 1.46fF
C2625 pll_full_1/divider_0/tspc_0/Z1 vssa1 0.99fF
C2626 pll_full_1/divider_0/nor_1/A vssa1 7.08fF
C2627 pll_full_1/divider_0/tspc_0/a_630_n680# vssa1 1.15fF **FLOATING
C2628 pll_full_1/vco vssa1 35.22fF
C2629 pll_full_1/divider_0/prescaler_0/nand_1/z1 vssa1 0.36fF
C2630 pll_full_1/divider_0/prescaler_0/tspc_0/D vssa1 2.64fF
C2631 pll_full_1/divider_0/prescaler_0/tspc_2/Q vssa1 3.72fF
C2632 pll_full_1/divider_0/prescaler_0/tspc_1/Q vssa1 3.61fF
C2633 pll_full_1/divider_0/prescaler_0/nand_0/z1 vssa1 0.36fF
C2634 pll_full_1/divider_0/prescaler_0/tspc_2/D vssa1 3.12fF
C2635 pll_full_1/divider_0/and_0/OUT vssa1 5.67fF
C2636 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C2637 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C2638 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 vssa1 1.19fF
C2639 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C2640 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# vssa1 1.47fF **FLOATING
C2641 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C2642 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C2643 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C2644 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C2645 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C2646 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C2647 pll_full_1/divider_0/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C2648 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C2649 pll_full_1/divider_0/prescaler_0/Out vssa1 4.59fF
C2650 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C2651 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C2652 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C2653 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C2654 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C2655 pll_full_1/divider_0/nor_1/Z1 vssa1 1.34fF
C2656 pll_full_1/divider_0/nor_0/Z1 vssa1 1.34fF
C2657 pll_full_1/ro_complete_0/cbank_2/v vssa1 16.43fF
C2658 pll_full_1/ro_complete_0/cbank_2/switch_5/vin vssa1 0.78fF
C2659 pll_full_1/ro_complete_0/cbank_2/switch_4/vin vssa1 1.50fF
C2660 pll_full_1/ro_complete_0/cbank_2/switch_2/vin vssa1 1.30fF
C2661 pll_full_1/ro_complete_0/cbank_2/switch_3/vin vssa1 0.56fF
C2662 pll_full_1/ro_complete_0/cbank_2/switch_1/vin vssa1 1.14fF
C2663 pll_full_1/ro_complete_0/cbank_2/switch_0/vin vssa1 1.02fF
C2664 pll_full_1/ro_complete_0/cbank_1/switch_5/vin vssa1 0.78fF
C2665 pll_full_1/ro_complete_0/a0 vssa1 5.35fF
C2666 pll_full_1/ro_complete_0/cbank_1/switch_4/vin vssa1 1.50fF
C2667 pll_full_1/ro_complete_0/a1 vssa1 6.54fF
C2668 pll_full_1/ro_complete_0/cbank_1/switch_2/vin vssa1 1.30fF
C2669 pll_full_1/ro_complete_0/a3 vssa1 5.96fF
C2670 pll_full_1/ro_complete_0/cbank_1/switch_3/vin vssa1 0.56fF
C2671 pll_full_1/ro_complete_0/a2 vssa1 5.21fF
C2672 pll_full_1/ro_complete_0/cbank_1/switch_1/vin vssa1 1.14fF
C2673 pll_full_1/ro_complete_0/a4 vssa1 5.81fF
C2674 pll_full_1/ro_complete_0/cbank_1/switch_0/vin vssa1 1.02fF
C2675 pll_full_1/ro_complete_0/a5 vssa1 6.74fF
C2676 pll_full_1/ro_complete_0/cbank_0/v vssa1 15.12fF
C2677 pll_full_1/ro_complete_0/cbank_0/switch_5/vin vssa1 0.78fF
C2678 pll_full_1/ro_complete_0/cbank_0/switch_4/vin vssa1 1.50fF
C2679 pll_full_1/ro_complete_0/cbank_0/switch_2/vin vssa1 1.30fF
C2680 pll_full_1/ro_complete_0/cbank_0/switch_3/vin vssa1 0.56fF
C2681 pll_full_1/ro_complete_0/cbank_0/switch_1/vin vssa1 1.14fF
C2682 pll_full_1/ro_complete_0/cbank_0/switch_0/vin vssa1 1.02fF
C2683 pll_full_1/filter_0/a_4216_n5230# vssa1 418.90fF **FLOATING
C2684 pll_full_1/filter_0/a_4216_n2998# vssa1 1.39fF **FLOATING
C2685 pll_full_1/cp_0/down vssa1 1.54fF
C2686 pll_full_1/cp_0/upbar vssa1 1.79fF
C2687 pll_full_1/cp_0/a_7110_n2840# vssa1 0.17fF **FLOATING
C2688 pll_full_1/cp_0/a_3060_n2840# vssa1 1.71fF **FLOATING
C2689 pll_full_1/cp_0/a_7110_0# vssa1 0.17fF **FLOATING
C2690 pll_full_1/cp_0/a_6370_0# vssa1 0.40fF **FLOATING
C2691 pll_full_1/cp_0/a_3060_0# vssa1 2.50fF **FLOATING
C2692 pll_full_1/cp_0/a_1710_0# vssa1 7.47fF **FLOATING
C2693 pll_full_1/pd_0/UP vssa1 5.89fF
C2694 pll_full_1/pd_0/and_pd_0/Z1 vssa1 0.39fF
C2695 pll_full_1/pd_0/and_pd_0/Out1 vssa1 2.22fF
C2696 pll_full_1/pd_0/tspc_r_1/z5 vssa1 1.10fF
C2697 pll_full_1/pd_0/tspc_r_1/Z4 vssa1 1.07fF
C2698 pll_full_1/pd_0/R vssa1 3.05fF
C2699 pll_full_1/pd_0/tspc_r_1/Qbar vssa1 0.79fF
C2700 pll_full_1/pd_0/tspc_r_1/Z2 vssa1 1.22fF
C2701 pll_full_1/pd_0/tspc_r_1/Z1 vssa1 0.67fF
C2702 pll_full_1/pd_0/DOWN vssa1 7.38fF
C2703 pll_full_1/pd_0/tspc_r_1/Qbar1 vssa1 1.34fF
C2704 pll_full_1/pd_0/tspc_r_1/Z3 vssa1 2.12fF
C2705 pll_full_1/pd_0/tspc_r_0/z5 vssa1 1.10fF
C2706 pll_full_1/pd_0/tspc_r_0/Z4 vssa1 1.07fF
C2707 pll_full_1/pd_0/tspc_r_0/Qbar vssa1 0.88fF
C2708 pll_full_1/pd_0/tspc_r_0/Z2 vssa1 1.22fF
C2709 pll_full_1/pd_0/tspc_r_0/Z1 vssa1 0.67fF
C2710 pll_full_1/pd_0/tspc_r_0/Qbar1 vssa1 1.34fF
C2711 pll_full_1/pd_0/tspc_r_0/Z3 vssa1 2.12fF
C2712 pll_full_1/ref vssa1 4.34fF
C2713 pll_full_0/divider_0/and_0/Z1 vssa1 0.65fF
C2714 pll_full_0/divider_0/and_0/B vssa1 2.45fF
C2715 pll_full_0/divider_0/and_0/A vssa1 2.35fF
C2716 pll_full_0/divider_0/and_0/out1 vssa1 2.99fF
C2717 pll_full_0/divider_0/tspc_2/Z4 vssa1 0.86fF
C2718 pll_full_0/div vssa1 14.90fF
C2719 pll_full_0/divider_0/tspc_2/Z3 vssa1 2.26fF
C2720 pll_full_0/divider_0/tspc_2/Z2 vssa1 1.46fF
C2721 pll_full_0/divider_0/tspc_2/Z1 vssa1 0.99fF
C2722 pll_full_0/divider_0/nor_0/B vssa1 6.48fF
C2723 pll_full_0/divider_0/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C2724 pll_full_0/divider_0/tspc_1/Z4 vssa1 0.86fF
C2725 pll_full_0/divider_0/tspc_1/Q vssa1 3.12fF
C2726 pll_full_0/divider_0/tspc_1/Z3 vssa1 2.26fF
C2727 pll_full_0/divider_0/tspc_1/Z2 vssa1 1.46fF
C2728 pll_full_0/divider_0/tspc_1/Z1 vssa1 0.99fF
C2729 pll_full_0/divider_0/nor_1/B vssa1 7.12fF
C2730 pll_full_0/divider_0/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C2731 pll_full_0/divider_0/tspc_0/Z4 vssa1 0.86fF
C2732 pll_full_0/divider_0/tspc_0/Q vssa1 3.14fF
C2733 pll_full_0/divider_0/tspc_0/Z3 vssa1 2.26fF
C2734 pll_full_0/divider_0/tspc_0/Z2 vssa1 1.46fF
C2735 pll_full_0/divider_0/tspc_0/Z1 vssa1 0.99fF
C2736 pll_full_0/divider_0/nor_1/A vssa1 7.08fF
C2737 pll_full_0/divider_0/tspc_0/a_630_n680# vssa1 1.15fF **FLOATING
C2738 pll_full_0/vco vssa1 35.22fF
C2739 pll_full_0/divider_0/prescaler_0/nand_1/z1 vssa1 0.36fF
C2740 pll_full_0/divider_0/prescaler_0/tspc_0/D vssa1 2.64fF
C2741 pll_full_0/divider_0/prescaler_0/tspc_2/Q vssa1 3.72fF
C2742 pll_full_0/divider_0/prescaler_0/tspc_1/Q vssa1 3.61fF
C2743 pll_full_0/divider_0/prescaler_0/nand_0/z1 vssa1 0.36fF
C2744 pll_full_0/divider_0/prescaler_0/tspc_2/D vssa1 3.12fF
C2745 pll_full_0/divider_0/and_0/OUT vssa1 5.67fF
C2746 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C2747 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C2748 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 vssa1 1.19fF
C2749 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C2750 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# vssa1 1.47fF **FLOATING
C2751 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C2752 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C2753 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C2754 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C2755 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C2756 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C2757 pll_full_0/divider_0/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C2758 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C2759 pll_full_0/divider_0/prescaler_0/Out vssa1 4.59fF
C2760 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C2761 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C2762 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C2763 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C2764 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C2765 pll_full_0/divider_0/nor_1/Z1 vssa1 1.34fF
C2766 pll_full_0/divider_0/nor_0/Z1 vssa1 1.34fF
C2767 pll_full_0/ro_complete_0/cbank_2/v vssa1 16.43fF
C2768 pll_full_0/ro_complete_0/cbank_2/switch_5/vin vssa1 0.78fF
C2769 pll_full_0/ro_complete_0/cbank_2/switch_4/vin vssa1 1.50fF
C2770 pll_full_0/ro_complete_0/cbank_2/switch_2/vin vssa1 1.30fF
C2771 pll_full_0/ro_complete_0/cbank_2/switch_3/vin vssa1 0.56fF
C2772 pll_full_0/ro_complete_0/cbank_2/switch_1/vin vssa1 1.14fF
C2773 pll_full_0/ro_complete_0/cbank_2/switch_0/vin vssa1 1.02fF
C2774 pll_full_0/ro_complete_0/cbank_1/switch_5/vin vssa1 0.78fF
C2775 pll_full_0/ro_complete_0/a0 vssa1 5.35fF
C2776 pll_full_0/ro_complete_0/cbank_1/switch_4/vin vssa1 1.50fF
C2777 pll_full_0/ro_complete_0/a1 vssa1 6.54fF
C2778 pll_full_0/ro_complete_0/cbank_1/switch_2/vin vssa1 1.30fF
C2779 pll_full_0/ro_complete_0/a3 vssa1 5.96fF
C2780 pll_full_0/ro_complete_0/cbank_1/switch_3/vin vssa1 0.56fF
C2781 pll_full_0/ro_complete_0/a2 vssa1 5.21fF
C2782 pll_full_0/ro_complete_0/cbank_1/switch_1/vin vssa1 1.14fF
C2783 pll_full_0/ro_complete_0/a4 vssa1 5.81fF
C2784 pll_full_0/ro_complete_0/cbank_1/switch_0/vin vssa1 1.02fF
C2785 pll_full_0/ro_complete_0/a5 vssa1 6.74fF
C2786 pll_full_0/ro_complete_0/cbank_0/v vssa1 15.12fF
C2787 pll_full_0/ro_complete_0/cbank_0/switch_5/vin vssa1 0.78fF
C2788 pll_full_0/ro_complete_0/cbank_0/switch_4/vin vssa1 1.50fF
C2789 pll_full_0/ro_complete_0/cbank_0/switch_2/vin vssa1 1.30fF
C2790 pll_full_0/ro_complete_0/cbank_0/switch_3/vin vssa1 0.56fF
C2791 pll_full_0/ro_complete_0/cbank_0/switch_1/vin vssa1 1.14fF
C2792 pll_full_0/ro_complete_0/cbank_0/switch_0/vin vssa1 1.02fF
C2793 pll_full_0/filter_0/a_4216_n5230# vssa1 418.90fF **FLOATING
C2794 pll_full_0/filter_0/a_4216_n2998# vssa1 1.39fF **FLOATING
C2795 pll_full_0/cp_0/down vssa1 1.54fF
C2796 pll_full_0/cp_0/upbar vssa1 1.79fF
C2797 pll_full_0/cp_0/a_7110_n2840# vssa1 0.17fF **FLOATING
C2798 pll_full_0/cp_0/a_3060_n2840# vssa1 1.71fF **FLOATING
C2799 pll_full_0/cp_0/a_7110_0# vssa1 0.17fF **FLOATING
C2800 pll_full_0/cp_0/a_6370_0# vssa1 0.40fF **FLOATING
C2801 pll_full_0/cp_0/a_3060_0# vssa1 2.50fF **FLOATING
C2802 pll_full_0/cp_0/a_1710_0# vssa1 7.47fF **FLOATING
C2803 pll_full_0/pd_0/UP vssa1 5.89fF
C2804 pll_full_0/pd_0/and_pd_0/Z1 vssa1 0.39fF
C2805 pll_full_0/pd_0/and_pd_0/Out1 vssa1 2.22fF
C2806 pll_full_0/pd_0/tspc_r_1/z5 vssa1 1.10fF
C2807 pll_full_0/pd_0/tspc_r_1/Z4 vssa1 1.07fF
C2808 pll_full_0/pd_0/R vssa1 3.05fF
C2809 pll_full_0/pd_0/tspc_r_1/Qbar vssa1 0.79fF
C2810 pll_full_0/pd_0/tspc_r_1/Z2 vssa1 1.22fF
C2811 pll_full_0/pd_0/tspc_r_1/Z1 vssa1 0.67fF
C2812 pll_full_0/pd_0/DOWN vssa1 7.38fF
C2813 pll_full_0/pd_0/tspc_r_1/Qbar1 vssa1 1.34fF
C2814 pll_full_0/pd_0/tspc_r_1/Z3 vssa1 2.12fF
C2815 pll_full_0/pd_0/tspc_r_0/z5 vssa1 1.10fF
C2816 pll_full_0/pd_0/tspc_r_0/Z4 vssa1 1.07fF
C2817 pll_full_0/pd_0/tspc_r_0/Qbar vssa1 0.88fF
C2818 pll_full_0/pd_0/tspc_r_0/Z2 vssa1 1.22fF
C2819 pll_full_0/pd_0/tspc_r_0/Z1 vssa1 0.67fF
C2820 pll_full_0/pd_0/tspc_r_0/Qbar1 vssa1 1.34fF
C2821 pll_full_0/pd_0/tspc_r_0/Z3 vssa1 2.12fF
C2822 pll_full_0/ref vssa1 4.34fF
C2823 div_pd_buffered_0/tapered_buf_0/out vssa1 385.91fF
C2824 div_pd_buffered_0/tapered_buf_0/a_n10_n140# vssa1 0.06fF **FLOATING
C2825 div_pd_buffered_0/tapered_buf_0/a_210_n610# vssa1 592.97fF **FLOATING
C2826 div_pd_buffered_0/tapered_buf_0/a_160_230# vssa1 0.15fF **FLOATING
C2827 div_pd_buffered_0/tapered_buf_0/a_n10_230# vssa1 0.13fF **FLOATING
C2828 div_pd_buffered_0/tapered_buf_0/a_4670_0# vssa1 252.41fF **FLOATING
C2829 div_pd_buffered_0/tapered_buf_0/a_1650_0# vssa1 63.61fF **FLOATING
C2830 div_pd_buffered_0/tapered_buf_0/a_580_0# vssa1 16.76fF **FLOATING
C2831 div_pd_buffered_0/tapered_buf_0/a_160_n140# vssa1 4.09fF **FLOATING
C2832 div_pd_buffered_0/tapered_buf_1/out vssa1 385.93fF
C2833 div_pd_buffered_0/tapered_buf_1/a_n10_n140# vssa1 0.06fF **FLOATING
C2834 div_pd_buffered_0/tapered_buf_1/a_210_n610# vssa1 592.97fF **FLOATING
C2835 div_pd_buffered_0/tapered_buf_1/a_160_230# vssa1 0.15fF **FLOATING
C2836 div_pd_buffered_0/tapered_buf_1/a_n10_230# vssa1 0.13fF **FLOATING
C2837 div_pd_buffered_0/tapered_buf_1/a_4670_0# vssa1 252.41fF **FLOATING
C2838 div_pd_buffered_0/tapered_buf_1/a_1650_0# vssa1 63.61fF **FLOATING
C2839 div_pd_buffered_0/tapered_buf_1/a_580_0# vssa1 16.76fF **FLOATING
C2840 div_pd_buffered_0/tapered_buf_1/a_160_n140# vssa1 4.09fF **FLOATING
C2841 div_pd_buffered_0/divider_0/and_0/Z1 vssa1 0.74fF
C2842 div_pd_buffered_0/divider_0/and_0/B vssa1 2.25fF
C2843 div_pd_buffered_0/divider_0/and_0/A vssa1 2.19fF
C2844 div_pd_buffered_0/divider_0/and_0/out1 vssa1 2.93fF
C2845 div_pd_buffered_0/divider_0/tspc_2/Z4 vssa1 0.86fF
C2846 div_pd_buffered_0/divider_0/tspc_2/Z3 vssa1 2.26fF
C2847 div_pd_buffered_0/divider_0/tspc_2/Z2 vssa1 1.46fF
C2848 div_pd_buffered_0/divider_0/tspc_2/Z1 vssa1 0.99fF
C2849 div_pd_buffered_0/divider_0/nor_0/B vssa1 6.37fF
C2850 div_pd_buffered_0/divider_0/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C2851 div_pd_buffered_0/divider_0/tspc_1/Z4 vssa1 0.86fF
C2852 div_pd_buffered_0/divider_0/tspc_1/Q vssa1 3.12fF
C2853 div_pd_buffered_0/divider_0/tspc_1/Z3 vssa1 2.26fF
C2854 div_pd_buffered_0/divider_0/tspc_1/Z2 vssa1 1.46fF
C2855 div_pd_buffered_0/divider_0/tspc_1/Z1 vssa1 0.99fF
C2856 div_pd_buffered_0/divider_0/nor_1/B vssa1 7.05fF
C2857 div_pd_buffered_0/divider_0/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C2858 div_pd_buffered_0/divider_0/tspc_0/Z4 vssa1 0.86fF
C2859 div_pd_buffered_0/divider_0/tspc_0/Q vssa1 3.14fF
C2860 div_pd_buffered_0/divider_0/tspc_0/Z3 vssa1 2.26fF
C2861 div_pd_buffered_0/divider_0/tspc_0/Z2 vssa1 1.46fF
C2862 div_pd_buffered_0/divider_0/tspc_0/Z1 vssa1 0.99fF
C2863 div_pd_buffered_0/divider_0/nor_1/A vssa1 7.04fF
C2864 div_pd_buffered_0/divider_0/tspc_0/a_630_n680# vssa1 1.15fF **FLOATING
C2865 div_pd_buffered_0/divider_0/clk vssa1 399.47fF
C2866 div_pd_buffered_0/divider_0/prescaler_0/nand_1/z1 vssa1 0.36fF
C2867 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/D vssa1 2.64fF
C2868 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Q vssa1 3.64fF
C2869 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Q vssa1 3.61fF
C2870 div_pd_buffered_0/divider_0/prescaler_0/nand_0/z1 vssa1 0.36fF
C2871 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/D vssa1 3.12fF
C2872 div_pd_buffered_0/divider_0/and_0/OUT vssa1 5.62fF
C2873 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C2874 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C2875 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z2 vssa1 1.46fF
C2876 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C2877 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C2878 div_pd_buffered_0/divider_0/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C2879 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C2880 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C2881 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C2882 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C2883 div_pd_buffered_0/divider_0/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C2884 div_pd_buffered_0/divider_0/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C2885 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C2886 div_pd_buffered_0/divider_0/prescaler_0/Out vssa1 4.59fF
C2887 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C2888 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C2889 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C2890 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C2891 div_pd_buffered_0/divider_0/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C2892 div_pd_buffered_0/divider_0/nor_1/Z1 vssa1 1.34fF
C2893 div_pd_buffered_0/divider_0/nor_0/Z1 vssa1 1.34fF
C2894 div_pd_buffered_0/divider_0/mc2 vssa1 393.11fF
C2895 div_pd_buffered_0/pd_0/UP vssa1 5.85fF
C2896 div_pd_buffered_0/pd_0/and_pd_0/Z1 vssa1 0.39fF
C2897 div_pd_buffered_0/pd_0/and_pd_0/Out1 vssa1 2.22fF
C2898 div_pd_buffered_0/pd_0/tspc_r_1/z5 vssa1 1.10fF
C2899 div_pd_buffered_0/pd_0/tspc_r_1/Z4 vssa1 1.07fF
C2900 div_pd_buffered_0/pd_0/R vssa1 3.05fF
C2901 div_pd_buffered_0/pd_0/tspc_r_1/Qbar vssa1 0.79fF
C2902 div_pd_buffered_0/pd_0/tspc_r_1/Z2 vssa1 1.22fF
C2903 div_pd_buffered_0/pd_0/tspc_r_1/Z1 vssa1 0.67fF
C2904 div_pd_buffered_0/pd_0/DOWN vssa1 9.94fF
C2905 div_pd_buffered_0/pd_0/tspc_r_1/Qbar1 vssa1 1.34fF
C2906 div_pd_buffered_0/pd_0/tspc_r_1/Z3 vssa1 2.12fF
C2907 div_pd_buffered_0/pd_0/DIV vssa1 5.85fF
C2908 div_pd_buffered_0/pd_0/tspc_r_0/z5 vssa1 1.10fF
C2909 div_pd_buffered_0/pd_0/tspc_r_0/Z4 vssa1 1.07fF
C2910 div_pd_buffered_0/pd_0/tspc_r_0/Qbar vssa1 0.88fF
C2911 div_pd_buffered_0/pd_0/tspc_r_0/Z2 vssa1 1.22fF
C2912 div_pd_buffered_0/pd_0/tspc_r_0/Z1 vssa1 0.67fF
C2913 div_pd_buffered_0/pd_0/tspc_r_0/Qbar1 vssa1 1.34fF
C2914 div_pd_buffered_0/pd_0/tspc_r_0/Z3 vssa1 2.12fF
C2915 div_pd_buffered_0/pd_0/REF vssa1 391.02fF
C2916 div_pd_buffered_0/tapered_buf_4/in vssa1 1.13fF
C2917 div_pd_buffered_0/tapered_buf_4/a_n10_n140# vssa1 0.06fF **FLOATING
C2918 div_pd_buffered_0/tapered_buf_4/a_210_n610# vssa1 592.97fF **FLOATING
C2919 div_pd_buffered_0/tapered_buf_4/a_160_230# vssa1 0.15fF **FLOATING
C2920 div_pd_buffered_0/tapered_buf_4/a_n10_230# vssa1 0.13fF **FLOATING
C2921 div_pd_buffered_0/tapered_buf_4/a_4670_0# vssa1 252.41fF **FLOATING
C2922 div_pd_buffered_0/tapered_buf_4/a_1650_0# vssa1 63.61fF **FLOATING
C2923 div_pd_buffered_0/tapered_buf_4/a_580_0# vssa1 16.76fF **FLOATING
C2924 div_pd_buffered_0/tapered_buf_4/a_160_n140# vssa1 4.09fF **FLOATING
C2925 div_pd_buffered_0/tapered_buf_3/in vssa1 1.13fF
C2926 div_pd_buffered_0/tapered_buf_3/a_n10_n140# vssa1 0.06fF **FLOATING
C2927 div_pd_buffered_0/tapered_buf_3/a_210_n610# vssa1 592.97fF **FLOATING
C2928 div_pd_buffered_0/tapered_buf_3/a_160_230# vssa1 0.15fF **FLOATING
C2929 div_pd_buffered_0/tapered_buf_3/a_n10_230# vssa1 0.13fF **FLOATING
C2930 div_pd_buffered_0/tapered_buf_3/a_4670_0# vssa1 252.41fF **FLOATING
C2931 div_pd_buffered_0/tapered_buf_3/a_1650_0# vssa1 63.61fF **FLOATING
C2932 div_pd_buffered_0/tapered_buf_3/a_580_0# vssa1 16.76fF **FLOATING
C2933 div_pd_buffered_0/tapered_buf_3/a_160_n140# vssa1 4.09fF **FLOATING
C2934 div_pd_buffered_0/tapered_buf_2/in vssa1 1.13fF
C2935 div_pd_buffered_0/tapered_buf_2/a_n10_n140# vssa1 0.06fF **FLOATING
C2936 div_pd_buffered_0/tapered_buf_2/a_210_n610# vssa1 592.97fF **FLOATING
C2937 div_pd_buffered_0/tapered_buf_2/a_160_230# vssa1 0.15fF **FLOATING
C2938 div_pd_buffered_0/tapered_buf_2/a_n10_230# vssa1 0.13fF **FLOATING
C2939 div_pd_buffered_0/tapered_buf_2/a_4670_0# vssa1 252.41fF **FLOATING
C2940 div_pd_buffered_0/tapered_buf_2/a_1650_0# vssa1 63.61fF **FLOATING
C2941 div_pd_buffered_0/tapered_buf_2/a_580_0# vssa1 16.76fF **FLOATING
C2942 div_pd_buffered_0/tapered_buf_2/a_160_n140# vssa1 4.09fF **FLOATING
C2943 divider_1/and_0/Z1 vssa1 0.74fF
C2944 divider_1/and_0/B vssa1 2.25fF
C2945 divider_1/and_0/A vssa1 2.19fF
C2946 divider_1/and_0/out1 vssa1 2.93fF
C2947 divider_1/tspc_2/Z4 vssa1 0.86fF
C2948 divider_1/Out vssa1 1.60fF
C2949 divider_1/tspc_2/Z3 vssa1 2.26fF
C2950 divider_1/tspc_2/Z2 vssa1 1.46fF
C2951 divider_1/tspc_2/Z1 vssa1 0.99fF
C2952 divider_1/nor_0/B vssa1 6.33fF
C2953 divider_1/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C2954 divider_1/tspc_1/Z4 vssa1 0.86fF
C2955 divider_1/tspc_1/Q vssa1 3.12fF
C2956 divider_1/tspc_1/Z3 vssa1 2.26fF
C2957 divider_1/tspc_1/Z2 vssa1 1.46fF
C2958 divider_1/tspc_1/Z1 vssa1 0.99fF
C2959 divider_1/nor_1/B vssa1 7.05fF
C2960 divider_1/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C2961 divider_1/tspc_0/Z4 vssa1 0.86fF
C2962 divider_1/tspc_0/Q vssa1 3.14fF
C2963 divider_1/tspc_0/Z3 vssa1 2.26fF
C2964 divider_1/tspc_0/Z2 vssa1 1.46fF
C2965 divider_1/tspc_0/Z1 vssa1 0.99fF
C2966 divider_1/nor_1/A vssa1 7.04fF
C2967 divider_1/tspc_0/a_630_n680# vssa1 1.15fF **FLOATING
C2968 divider_1/clk vssa1 5.63fF
C2969 divider_1/prescaler_0/nand_1/z1 vssa1 0.36fF
C2970 divider_1/prescaler_0/tspc_0/D vssa1 2.64fF
C2971 divider_1/prescaler_0/tspc_2/Q vssa1 3.74fF
C2972 divider_1/prescaler_0/tspc_1/Q vssa1 3.61fF
C2973 divider_1/prescaler_0/nand_0/z1 vssa1 0.36fF
C2974 divider_1/prescaler_0/tspc_2/D vssa1 3.12fF
C2975 divider_1/and_0/OUT vssa1 5.62fF
C2976 divider_1/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C2977 divider_1/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C2978 divider_1/prescaler_0/tspc_2/Z2 vssa1 1.46fF
C2979 divider_1/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C2980 divider_1/prescaler_0/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C2981 divider_1/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C2982 divider_1/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C2983 divider_1/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C2984 divider_1/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C2985 divider_1/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C2986 divider_1/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C2987 divider_1/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C2988 divider_1/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C2989 divider_1/prescaler_0/Out vssa1 4.59fF
C2990 divider_1/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C2991 divider_1/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C2992 divider_1/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C2993 divider_1/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C2994 divider_1/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C2995 divider_1/nor_1/Z1 vssa1 1.34fF
C2996 divider_1/nor_0/Z1 vssa1 1.34fF
C2997 divider_1/mc2 vssa1 5.29fF
C2998 divider_0/and_0/Z1 vssa1 0.74fF
C2999 divider_0/and_0/B vssa1 2.25fF
C3000 divider_0/and_0/A vssa1 2.19fF
C3001 divider_0/and_0/out1 vssa1 2.93fF
C3002 divider_0/tspc_2/Z4 vssa1 0.86fF
C3003 divider_0/Out vssa1 1.60fF
C3004 divider_0/tspc_2/Z3 vssa1 2.26fF
C3005 divider_0/tspc_2/Z2 vssa1 1.46fF
C3006 divider_0/tspc_2/Z1 vssa1 0.99fF
C3007 divider_0/nor_0/B vssa1 6.33fF
C3008 divider_0/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C3009 divider_0/tspc_1/Z4 vssa1 0.86fF
C3010 divider_0/tspc_1/Q vssa1 3.12fF
C3011 divider_0/tspc_1/Z3 vssa1 2.26fF
C3012 divider_0/tspc_1/Z2 vssa1 1.46fF
C3013 divider_0/tspc_1/Z1 vssa1 0.99fF
C3014 divider_0/nor_1/B vssa1 7.05fF
C3015 divider_0/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C3016 divider_0/tspc_0/Z4 vssa1 0.86fF
C3017 divider_0/tspc_0/Q vssa1 3.14fF
C3018 divider_0/tspc_0/Z3 vssa1 2.26fF
C3019 divider_0/tspc_0/Z2 vssa1 1.46fF
C3020 divider_0/tspc_0/Z1 vssa1 0.99fF
C3021 divider_0/nor_1/A vssa1 7.04fF
C3022 divider_0/tspc_0/a_630_n680# vssa1 1.15fF **FLOATING
C3023 divider_0/clk vssa1 5.63fF
C3024 divider_0/prescaler_0/nand_1/z1 vssa1 0.36fF
C3025 divider_0/prescaler_0/tspc_0/D vssa1 2.64fF
C3026 divider_0/prescaler_0/tspc_2/Q vssa1 3.64fF
C3027 divider_0/prescaler_0/tspc_1/Q vssa1 3.61fF
C3028 divider_0/prescaler_0/nand_0/z1 vssa1 0.36fF
C3029 divider_0/prescaler_0/tspc_2/D vssa1 3.12fF
C3030 divider_0/and_0/OUT vssa1 5.62fF
C3031 divider_0/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C3032 divider_0/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C3033 divider_0/prescaler_0/tspc_2/Z2 vssa1 1.46fF
C3034 divider_0/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C3035 divider_0/prescaler_0/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C3036 divider_0/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C3037 divider_0/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C3038 divider_0/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C3039 divider_0/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C3040 divider_0/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C3041 divider_0/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C3042 divider_0/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C3043 divider_0/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C3044 divider_0/prescaler_0/Out vssa1 4.59fF
C3045 divider_0/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C3046 divider_0/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C3047 divider_0/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C3048 divider_0/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C3049 divider_0/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C3050 divider_0/nor_1/Z1 vssa1 1.34fF
C3051 divider_0/nor_0/Z1 vssa1 1.34fF
C3052 divider_0/mc2 vssa1 5.29fF
C3053 ro_complete_buffered_0/tapered_buf_0/in vssa1 1.13fF
C3054 ro_complete_buffered_0/tapered_buf_0/a_n10_n140# vssa1 0.06fF **FLOATING
C3055 ro_complete_buffered_0/tapered_buf_0/a_210_n610# vssa1 619.27fF **FLOATING
C3056 ro_complete_buffered_0/tapered_buf_0/a_160_230# vssa1 0.15fF **FLOATING
C3057 ro_complete_buffered_0/tapered_buf_0/a_n10_230# vssa1 0.13fF **FLOATING
C3058 ro_complete_buffered_0/tapered_buf_0/a_4670_0# vssa1 252.41fF **FLOATING
C3059 ro_complete_buffered_0/tapered_buf_0/a_1650_0# vssa1 63.61fF **FLOATING
C3060 ro_complete_buffered_0/tapered_buf_0/a_580_0# vssa1 16.76fF **FLOATING
C3061 ro_complete_buffered_0/tapered_buf_0/a_160_n140# vssa1 4.09fF **FLOATING
C3062 ro_complete_buffered_0/tapered_buf_1/out vssa1 385.87fF
C3063 ro_complete_buffered_0/tapered_buf_1/a_n10_n140# vssa1 0.06fF **FLOATING
C3064 ro_complete_buffered_0/tapered_buf_1/a_210_n610# vssa1 592.97fF **FLOATING
C3065 ro_complete_buffered_0/tapered_buf_1/a_160_230# vssa1 0.15fF **FLOATING
C3066 ro_complete_buffered_0/tapered_buf_1/a_n10_230# vssa1 0.13fF **FLOATING
C3067 ro_complete_buffered_0/tapered_buf_1/a_4670_0# vssa1 252.41fF **FLOATING
C3068 ro_complete_buffered_0/tapered_buf_1/a_1650_0# vssa1 63.61fF **FLOATING
C3069 ro_complete_buffered_0/tapered_buf_1/a_580_0# vssa1 16.76fF **FLOATING
C3070 ro_complete_buffered_0/tapered_buf_1/a_160_n140# vssa1 4.09fF **FLOATING
C3071 ro_complete_buffered_0/ro_complete_0/cbank_2/v vssa1 16.53fF
C3072 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_5/vin vssa1 0.78fF
C3073 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_4/vin vssa1 1.50fF
C3074 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_2/vin vssa1 1.30fF
C3075 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_3/vin vssa1 0.56fF
C3076 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_1/vin vssa1 1.14fF
C3077 ro_complete_buffered_0/ro_complete_0/cbank_2/switch_0/vin vssa1 1.02fF
C3078 ro_complete_buffered_0/tapered_buf_1/in vssa1 26.52fF
C3079 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_5/vin vssa1 0.78fF
C3080 ro_complete_buffered_0/ro_complete_0/a0 vssa1 416.45fF
C3081 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_4/vin vssa1 1.50fF
C3082 ro_complete_buffered_0/ro_complete_0/a1 vssa1 412.13fF
C3083 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_2/vin vssa1 1.30fF
C3084 ro_complete_buffered_0/ro_complete_0/a3 vssa1 402.70fF
C3085 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_3/vin vssa1 0.56fF
C3086 ro_complete_buffered_0/ro_complete_0/a2 vssa1 407.26fF
C3087 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_1/vin vssa1 1.14fF
C3088 ro_complete_buffered_0/ro_complete_0/a4 vssa1 398.93fF
C3089 ro_complete_buffered_0/ro_complete_0/cbank_1/switch_0/vin vssa1 1.02fF
C3090 ro_complete_buffered_0/ro_complete_0/a5 vssa1 395.79fF
C3091 ro_complete_buffered_0/ro_complete_0/cbank_0/v vssa1 15.13fF
C3092 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_5/vin vssa1 0.78fF
C3093 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_4/vin vssa1 1.50fF
C3094 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_2/vin vssa1 1.30fF
C3095 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_3/vin vssa1 0.56fF
C3096 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_1/vin vssa1 1.14fF
C3097 ro_complete_buffered_0/ro_complete_0/cbank_0/switch_0/vin vssa1 1.02fF
C3098 ro_complete_buffered_0/tapered_buf_7/in vssa1 1.13fF
C3099 ro_complete_buffered_0/tapered_buf_7/a_n10_n140# vssa1 0.06fF **FLOATING
C3100 ro_complete_buffered_0/tapered_buf_7/a_210_n610# vssa1 592.97fF **FLOATING
C3101 ro_complete_buffered_0/tapered_buf_7/a_160_230# vssa1 0.15fF **FLOATING
C3102 ro_complete_buffered_0/tapered_buf_7/a_n10_230# vssa1 0.13fF **FLOATING
C3103 ro_complete_buffered_0/tapered_buf_7/a_4670_0# vssa1 252.41fF **FLOATING
C3104 ro_complete_buffered_0/tapered_buf_7/a_1650_0# vssa1 63.61fF **FLOATING
C3105 ro_complete_buffered_0/tapered_buf_7/a_580_0# vssa1 16.76fF **FLOATING
C3106 ro_complete_buffered_0/tapered_buf_7/a_160_n140# vssa1 4.09fF **FLOATING
C3107 ro_complete_buffered_0/tapered_buf_6/in vssa1 1.13fF
C3108 ro_complete_buffered_0/tapered_buf_6/a_n10_n140# vssa1 0.06fF **FLOATING
C3109 ro_complete_buffered_0/tapered_buf_6/a_210_n610# vssa1 592.97fF **FLOATING
C3110 ro_complete_buffered_0/tapered_buf_6/a_160_230# vssa1 0.15fF **FLOATING
C3111 ro_complete_buffered_0/tapered_buf_6/a_n10_230# vssa1 0.13fF **FLOATING
C3112 ro_complete_buffered_0/tapered_buf_6/a_4670_0# vssa1 252.41fF **FLOATING
C3113 ro_complete_buffered_0/tapered_buf_6/a_1650_0# vssa1 63.61fF **FLOATING
C3114 ro_complete_buffered_0/tapered_buf_6/a_580_0# vssa1 16.76fF **FLOATING
C3115 ro_complete_buffered_0/tapered_buf_6/a_160_n140# vssa1 4.09fF **FLOATING
C3116 ro_complete_buffered_0/tapered_buf_5/in vssa1 1.13fF
C3117 ro_complete_buffered_0/tapered_buf_5/a_n10_n140# vssa1 0.06fF **FLOATING
C3118 ro_complete_buffered_0/tapered_buf_5/a_210_n610# vssa1 592.97fF **FLOATING
C3119 ro_complete_buffered_0/tapered_buf_5/a_160_230# vssa1 0.15fF **FLOATING
C3120 ro_complete_buffered_0/tapered_buf_5/a_n10_230# vssa1 0.13fF **FLOATING
C3121 ro_complete_buffered_0/tapered_buf_5/a_4670_0# vssa1 252.41fF **FLOATING
C3122 ro_complete_buffered_0/tapered_buf_5/a_1650_0# vssa1 63.61fF **FLOATING
C3123 ro_complete_buffered_0/tapered_buf_5/a_580_0# vssa1 16.76fF **FLOATING
C3124 ro_complete_buffered_0/tapered_buf_5/a_160_n140# vssa1 4.09fF **FLOATING
C3125 ro_complete_buffered_0/tapered_buf_4/in vssa1 1.13fF
C3126 ro_complete_buffered_0/tapered_buf_4/a_n10_n140# vssa1 0.06fF **FLOATING
C3127 ro_complete_buffered_0/tapered_buf_4/a_210_n610# vssa1 592.97fF **FLOATING
C3128 ro_complete_buffered_0/tapered_buf_4/a_160_230# vssa1 0.15fF **FLOATING
C3129 ro_complete_buffered_0/tapered_buf_4/a_n10_230# vssa1 0.13fF **FLOATING
C3130 ro_complete_buffered_0/tapered_buf_4/a_4670_0# vssa1 252.41fF **FLOATING
C3131 ro_complete_buffered_0/tapered_buf_4/a_1650_0# vssa1 63.61fF **FLOATING
C3132 ro_complete_buffered_0/tapered_buf_4/a_580_0# vssa1 16.76fF **FLOATING
C3133 ro_complete_buffered_0/tapered_buf_4/a_160_n140# vssa1 4.09fF **FLOATING
C3134 ro_complete_buffered_0/tapered_buf_3/in vssa1 1.13fF
C3135 ro_complete_buffered_0/tapered_buf_3/a_n10_n140# vssa1 0.06fF **FLOATING
C3136 ro_complete_buffered_0/tapered_buf_3/a_210_n610# vssa1 592.97fF **FLOATING
C3137 ro_complete_buffered_0/tapered_buf_3/a_160_230# vssa1 0.15fF **FLOATING
C3138 ro_complete_buffered_0/tapered_buf_3/a_n10_230# vssa1 0.13fF **FLOATING
C3139 ro_complete_buffered_0/tapered_buf_3/a_4670_0# vssa1 252.41fF **FLOATING
C3140 ro_complete_buffered_0/tapered_buf_3/a_1650_0# vssa1 63.61fF **FLOATING
C3141 ro_complete_buffered_0/tapered_buf_3/a_580_0# vssa1 16.76fF **FLOATING
C3142 ro_complete_buffered_0/tapered_buf_3/a_160_n140# vssa1 4.09fF **FLOATING
C3143 ro_complete_buffered_0/tapered_buf_2/in vssa1 1.13fF
C3144 ro_complete_buffered_0/tapered_buf_2/a_n10_n140# vssa1 0.06fF **FLOATING
C3145 ro_complete_buffered_0/tapered_buf_2/a_210_n610# vssa1 592.97fF **FLOATING
C3146 ro_complete_buffered_0/tapered_buf_2/a_160_230# vssa1 0.15fF **FLOATING
C3147 ro_complete_buffered_0/tapered_buf_2/a_n10_230# vssa1 0.13fF **FLOATING
C3148 ro_complete_buffered_0/tapered_buf_2/a_4670_0# vssa1 252.41fF **FLOATING
C3149 ro_complete_buffered_0/tapered_buf_2/a_1650_0# vssa1 63.61fF **FLOATING
C3150 ro_complete_buffered_0/tapered_buf_2/a_580_0# vssa1 16.76fF **FLOATING
C3151 ro_complete_buffered_0/tapered_buf_2/a_160_n140# vssa1 4.09fF **FLOATING
C3152 ro_complete_0/cbank_2/v vssa1 16.43fF
C3153 ro_complete_0/cbank_2/switch_5/vin vssa1 0.78fF
C3154 ro_complete_0/cbank_2/switch_4/vin vssa1 1.50fF
C3155 ro_complete_0/cbank_2/switch_2/vin vssa1 1.30fF
C3156 ro_complete_0/cbank_2/switch_3/vin vssa1 0.56fF
C3157 ro_complete_0/cbank_2/switch_1/vin vssa1 1.14fF
C3158 ro_complete_0/cbank_2/switch_0/vin vssa1 1.02fF
C3159 ro_complete_0/cbank_1/v vssa1 16.43fF
C3160 ro_complete_0/cbank_1/switch_5/vin vssa1 0.78fF
C3161 ro_complete_0/a0 vssa1 5.35fF
C3162 ro_complete_0/cbank_1/switch_4/vin vssa1 1.50fF
C3163 ro_complete_0/a1 vssa1 6.54fF
C3164 ro_complete_0/cbank_1/switch_2/vin vssa1 1.30fF
C3165 ro_complete_0/a3 vssa1 5.96fF
C3166 ro_complete_0/cbank_1/switch_3/vin vssa1 0.56fF
C3167 ro_complete_0/a2 vssa1 5.21fF
C3168 ro_complete_0/cbank_1/switch_1/vin vssa1 1.14fF
C3169 ro_complete_0/a4 vssa1 5.81fF
C3170 ro_complete_0/cbank_1/switch_0/vin vssa1 1.02fF
C3171 ro_complete_0/a5 vssa1 6.74fF
C3172 ro_complete_0/cbank_0/v vssa1 15.12fF
C3173 ro_complete_0/cbank_0/switch_5/vin vssa1 0.78fF
C3174 ro_complete_0/cbank_0/switch_4/vin vssa1 1.50fF
C3175 ro_complete_0/cbank_0/switch_2/vin vssa1 1.30fF
C3176 ro_complete_0/cbank_0/switch_3/vin vssa1 0.56fF
C3177 ro_complete_0/cbank_0/switch_1/vin vssa1 1.14fF
C3178 ro_complete_0/cbank_0/switch_0/vin vssa1 1.02fF
C3179 filter_0/v vssa1 110.47fF
C3180 filter_0/a_4216_n5230# vssa1 418.47fF **FLOATING
C3181 filter_0/a_4216_n2998# vssa1 1.03fF **FLOATING
C3182 cp_buffered_0/cp_0/down vssa1 397.14fF
C3183 cp_buffered_0/tapered_buf_0/in vssa1 1.13fF
C3184 cp_buffered_0/tapered_buf_0/a_n10_n140# vssa1 0.06fF **FLOATING
C3185 cp_buffered_0/tapered_buf_0/a_210_n610# vssa1 592.97fF **FLOATING
C3186 cp_buffered_0/tapered_buf_0/a_160_230# vssa1 0.15fF **FLOATING
C3187 cp_buffered_0/tapered_buf_0/a_n10_230# vssa1 0.13fF **FLOATING
C3188 cp_buffered_0/tapered_buf_0/a_4670_0# vssa1 252.41fF **FLOATING
C3189 cp_buffered_0/tapered_buf_0/a_1650_0# vssa1 63.61fF **FLOATING
C3190 cp_buffered_0/tapered_buf_0/a_580_0# vssa1 16.76fF **FLOATING
C3191 cp_buffered_0/tapered_buf_0/a_160_n140# vssa1 4.09fF **FLOATING
C3192 cp_buffered_0/cp_0/out vssa1 397.36fF
C3193 cp_buffered_0/tapered_buf_1/in vssa1 1.13fF
C3194 cp_buffered_0/tapered_buf_1/a_n10_n140# vssa1 0.06fF **FLOATING
C3195 cp_buffered_0/tapered_buf_1/a_210_n610# vssa1 592.97fF **FLOATING
C3196 cp_buffered_0/tapered_buf_1/a_160_230# vssa1 0.15fF **FLOATING
C3197 cp_buffered_0/tapered_buf_1/a_n10_230# vssa1 0.13fF **FLOATING
C3198 cp_buffered_0/tapered_buf_1/a_4670_0# vssa1 252.41fF **FLOATING
C3199 cp_buffered_0/tapered_buf_1/a_1650_0# vssa1 63.61fF **FLOATING
C3200 cp_buffered_0/tapered_buf_1/a_580_0# vssa1 16.76fF **FLOATING
C3201 cp_buffered_0/tapered_buf_1/a_160_n140# vssa1 4.09fF **FLOATING
C3202 cp_buffered_0/cp_0/upbar vssa1 393.41fF
C3203 cp_buffered_0/cp_0/a_7110_n2840# vssa1 0.17fF **FLOATING
C3204 cp_buffered_0/cp_0/a_3060_n2840# vssa1 1.71fF **FLOATING
C3205 cp_buffered_0/cp_0/a_7110_0# vssa1 0.17fF **FLOATING
C3206 cp_buffered_0/cp_0/a_6370_0# vssa1 0.40fF **FLOATING
C3207 cp_buffered_0/cp_0/a_3060_0# vssa1 1.65fF **FLOATING
C3208 cp_buffered_0/cp_0/a_1710_0# vssa1 5.76fF **FLOATING
C3209 cp_buffered_0/cp_0/a_1710_n2840# vssa1 5.24fF **FLOATING
C3210 cp_buffered_0/cp_0/a_10_n50# vssa1 3.19fF **FLOATING
C3211 cp_buffered_0/tapered_buf_2/in vssa1 1.13fF
C3212 cp_buffered_0/tapered_buf_2/a_n10_n140# vssa1 0.06fF **FLOATING
C3213 cp_buffered_0/tapered_buf_2/a_210_n610# vssa1 592.97fF **FLOATING
C3214 cp_buffered_0/tapered_buf_2/a_160_230# vssa1 0.15fF **FLOATING
C3215 cp_buffered_0/tapered_buf_2/a_n10_230# vssa1 0.13fF **FLOATING
C3216 cp_buffered_0/tapered_buf_2/a_4670_0# vssa1 252.41fF **FLOATING
C3217 cp_buffered_0/tapered_buf_2/a_1650_0# vssa1 63.61fF **FLOATING
C3218 cp_buffered_0/tapered_buf_2/a_580_0# vssa1 16.76fF **FLOATING
C3219 cp_buffered_0/tapered_buf_2/a_160_n140# vssa1 4.09fF **FLOATING
C3220 pd_buffered_0/tapered_buf_0/in vssa1 1.13fF
C3221 pd_buffered_0/tapered_buf_0/a_n10_n140# vssa1 0.06fF **FLOATING
C3222 pd_buffered_0/tapered_buf_0/a_210_n610# vssa1 592.97fF **FLOATING
C3223 pd_buffered_0/tapered_buf_0/a_160_230# vssa1 0.15fF **FLOATING
C3224 pd_buffered_0/tapered_buf_0/a_n10_230# vssa1 0.13fF **FLOATING
C3225 pd_buffered_0/tapered_buf_0/a_4670_0# vssa1 252.41fF **FLOATING
C3226 pd_buffered_0/tapered_buf_0/a_1650_0# vssa1 63.61fF **FLOATING
C3227 pd_buffered_0/tapered_buf_0/a_580_0# vssa1 16.76fF **FLOATING
C3228 pd_buffered_0/tapered_buf_0/a_160_n140# vssa1 4.09fF **FLOATING
C3229 pd_buffered_0/tapered_buf_1/out vssa1 385.91fF
C3230 pd_buffered_0/tapered_buf_1/a_n10_n140# vssa1 0.06fF **FLOATING
C3231 pd_buffered_0/tapered_buf_1/a_210_n610# vssa1 592.97fF **FLOATING
C3232 pd_buffered_0/tapered_buf_1/a_160_230# vssa1 0.15fF **FLOATING
C3233 pd_buffered_0/tapered_buf_1/a_n10_230# vssa1 0.13fF **FLOATING
C3234 pd_buffered_0/tapered_buf_1/a_4670_0# vssa1 252.41fF **FLOATING
C3235 pd_buffered_0/tapered_buf_1/a_1650_0# vssa1 63.61fF **FLOATING
C3236 pd_buffered_0/tapered_buf_1/a_580_0# vssa1 16.76fF **FLOATING
C3237 pd_buffered_0/tapered_buf_1/a_160_n140# vssa1 4.09fF **FLOATING
C3238 pd_buffered_0/pd_0/UP vssa1 5.51fF
C3239 pd_buffered_0/pd_0/and_pd_0/Z1 vssa1 0.39fF
C3240 pd_buffered_0/pd_0/and_pd_0/Out1 vssa1 2.22fF
C3241 pd_buffered_0/pd_0/tspc_r_1/z5 vssa1 1.10fF
C3242 pd_buffered_0/pd_0/tspc_r_1/Z4 vssa1 1.07fF
C3243 pd_buffered_0/pd_0/R vssa1 3.05fF
C3244 pd_buffered_0/pd_0/tspc_r_1/Qbar vssa1 0.79fF
C3245 pd_buffered_0/pd_0/tspc_r_1/Z2 vssa1 1.22fF
C3246 pd_buffered_0/pd_0/tspc_r_1/Z1 vssa1 0.67fF
C3247 pd_buffered_0/pd_0/DOWN vssa1 8.92fF
C3248 pd_buffered_0/pd_0/tspc_r_1/Qbar1 vssa1 1.34fF
C3249 pd_buffered_0/pd_0/tspc_r_1/Z3 vssa1 2.12fF
C3250 pd_buffered_0/pd_0/DIV vssa1 390.67fF
C3251 pd_buffered_0/pd_0/tspc_r_0/z5 vssa1 1.10fF
C3252 pd_buffered_0/pd_0/tspc_r_0/Z4 vssa1 1.07fF
C3253 pd_buffered_0/pd_0/tspc_r_0/Qbar vssa1 0.88fF
C3254 pd_buffered_0/pd_0/tspc_r_0/Z2 vssa1 1.22fF
C3255 pd_buffered_0/pd_0/tspc_r_0/Z1 vssa1 0.67fF
C3256 pd_buffered_0/pd_0/tspc_r_0/Qbar1 vssa1 1.34fF
C3257 pd_buffered_0/pd_0/tspc_r_0/Z3 vssa1 2.12fF
C3258 pd_buffered_0/pd_0/REF vssa1 388.56fF
C3259 pd_buffered_0/tapered_buf_3/out vssa1 385.93fF
C3260 pd_buffered_0/tapered_buf_3/a_n10_n140# vssa1 0.06fF **FLOATING
C3261 pd_buffered_0/tapered_buf_3/a_210_n610# vssa1 592.97fF **FLOATING
C3262 pd_buffered_0/tapered_buf_3/a_160_230# vssa1 0.15fF **FLOATING
C3263 pd_buffered_0/tapered_buf_3/a_n10_230# vssa1 0.13fF **FLOATING
C3264 pd_buffered_0/tapered_buf_3/a_4670_0# vssa1 252.41fF **FLOATING
C3265 pd_buffered_0/tapered_buf_3/a_1650_0# vssa1 63.61fF **FLOATING
C3266 pd_buffered_0/tapered_buf_3/a_580_0# vssa1 16.76fF **FLOATING
C3267 pd_buffered_0/tapered_buf_3/a_160_n140# vssa1 4.09fF **FLOATING
C3268 pd_buffered_0/tapered_buf_2/in vssa1 1.13fF
C3269 pd_buffered_0/tapered_buf_2/a_n10_n140# vssa1 0.06fF **FLOATING
C3270 pd_buffered_0/tapered_buf_2/a_210_n610# vssa1 592.97fF **FLOATING
C3271 pd_buffered_0/tapered_buf_2/a_160_230# vssa1 0.15fF **FLOATING
C3272 pd_buffered_0/tapered_buf_2/a_n10_230# vssa1 0.13fF **FLOATING
C3273 pd_buffered_0/tapered_buf_2/a_4670_0# vssa1 252.41fF **FLOATING
C3274 pd_buffered_0/tapered_buf_2/a_1650_0# vssa1 63.61fF **FLOATING
C3275 pd_buffered_0/tapered_buf_2/a_580_0# vssa1 16.76fF **FLOATING
C3276 pd_buffered_0/tapered_buf_2/a_160_n140# vssa1 4.09fF **FLOATING
.ends
