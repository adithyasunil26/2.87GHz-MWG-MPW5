* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[5] io_analog[6] io_analog[7]
+ io_analog[8] io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
C0 divbuf_18/OUT3 divbuf_18/OUT 0.26fF
C1 divider_2/tspc_2/Q divider_2/nor_0/A 0.55fF
C2 divider_2/nor_1/B divider_2/tspc_1/Q 0.22fF
C3 divbuf_24/OUT2 divbuf_24/OUT5 0.02fF
C4 divbuf_24/OUT3 divbuf_24/OUT4 5.16fF
C5 pd_1/tspc_r_1/Qbar pd_1/UP 0.21fF
C6 divbuf_2/OUT2 divbuf_2/a_492_n240# 0.42fF
C7 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/v 1.30fF
C8 divider_0/nor_0/B divider_0/tspc_0/Z4 0.02fF
C9 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z4 0.00fF
C10 divbuf_6/OUT divbuf_6/a_492_n240# 0.00fF
C11 ro_complete_1/a4 ro_complete_1/cbank_2/switch_0/vin 0.12fF
C12 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/a0 0.09fF
C13 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z4 0.12fF
C14 divider_0/tspc_2/Z1 divider_0/tspc_2/Z2 1.07fF
C15 divider_0/nor_0/A divider_0/tspc_2/Z3 0.38fF
C16 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z3 0.06fF
C17 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C18 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C19 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z3 0.05fF
C20 divider_1/nor_0/A divider_1/tspc_2/Z1 0.03fF
C21 divbuf_7/OUT4 divbuf_7/OUT5 20.26fF
C22 pd_1/R pd_1/tspc_r_1/Z3 0.29fF
C23 pd_1/tspc_r_0/Qbar1 pd_1/tspc_r_0/z5 0.20fF
C24 pd_1/tspc_r_0/Z1 pd_1/DIV 0.17fF
C25 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z1 0.17fF
C26 divbuf_19/OUT5 divbuf_19/a_492_n240# 0.01fF
C27 divider_2/mc2 divider_2/and_0/A 0.16fF
C28 divider_2/prescaler_0/tspc_2/Z2 divider_2/and_0/OUT 0.05fF
C29 divbuf_7/OUT ro_complete_0/cbank_2/switch_4/vin 0.13fF
C30 ro_complete_0/cbank_0/v ro_complete_0/cbank_1/v 1.27fF
C31 divbuf_14/IN divbuf_14/a_492_n240# 0.13fF
C32 divider_0/mc2 divider_0/and_0/A 0.16fF
C33 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z4 0.12fF
C34 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z3 0.06fF
C35 divbuf_3/OUT3 divbuf_3/OUT4 5.16fF
C36 ro_complete_1/a0 ro_complete_1/cbank_1/v 0.05fF
C37 divider_2/tspc_0/Z4 divider_2/tspc_0/a_630_n680# 0.12fF
C38 divbuf_10/a_492_n240# divbuf_10/OUT 0.00fF
C39 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z3 0.05fF
C40 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C41 pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_0/divider_0/clk 1.46fF
C42 divider_2/tspc_2/Q divider_2/tspc_1/Z1 0.01fF
C43 divider_2/tspc_1/a_630_n680# divider_2/nor_0/B 0.35fF
C44 divider_1/and_0/A divider_1/and_0/B 0.18fF
C45 cp_0/a_1710_n2840# cp_0/upbar 0.29fF
C46 pd_1/tspc_r_0/Z4 pd_1/tspc_r_1/Z4 0.02fF
C47 pd_1/REF pd_1/tspc_r_1/Qbar1 0.12fF
C48 divbuf_9/OUT2 divbuf_9/OUT 0.06fF
C49 divbuf_9/OUT3 divbuf_9/OUT5 0.01fF
C50 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z4 0.02fF
C51 divider_2/tspc_1/Z2 divider_2/nor_0/A 0.15fF
C52 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_0/D 0.32fF
C53 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/clk 0.01fF
C54 divider_2/nor_0/B divider_2/and_0/A 0.26fF
C55 divbuf_5/OUT ro_complete_0/cbank_2/switch_3/vin 0.09fF
C56 pll_full_0/cp_0/upbar pll_full_0/cp_0/down 0.02fF
C57 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z4 0.20fF
C58 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C59 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/pd_0/tspc_r_1/Z2 0.71fF
C60 divbuf_1/OUT divbuf_1/OUT4 1.11fF
C61 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_4/vin 0.20fF
C62 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a3 0.13fF
C63 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/Q 0.04fF
C64 divider_0/prescaler_0/tspc_1/Z3 divider_0/clk 0.45fF
C65 divbuf_7/OUT divbuf_7/OUT3 0.26fF
C66 divbuf_4/OUT2 divbuf_4/OUT3 1.37fF
C67 ro_complete_1/cbank_2/switch_0/vin ro_complete_1/cbank_2/v 1.45fF
C68 divbuf_20/OUT4 divbuf_20/OUT 1.11fF
C69 divider_1/prescaler_0/tspc_2/D divider_1/prescaler_0/nand_0/z1 0.24fF
C70 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Z4 0.65fF
C71 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C72 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/clk 0.51fF
C73 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C74 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z4 0.12fF
C75 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z2 1.07fF
C76 divbuf_8/a_492_n240# divbuf_8/OUT5 0.01fF
C77 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Out1 0.05fF
C78 pll_full_0/pd_0/DOWN pll_full_0/cp_0/a_1710_0# 0.04fF
C79 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z2 0.01fF
C80 divider_0/nor_1/Z1 divider_0/nor_1/B 0.06fF
C81 ro_complete_1/a2 ro_complete_1/cbank_1/switch_3/vin 0.09fF
C82 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/UP 0.21fF
C83 divbuf_14/OUT divbuf_14/OUT3 0.26fF
C84 divbuf_5/OUT2 divbuf_5/OUT3 1.37fF
C85 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z3 0.05fF
C86 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/Z1 0.00fF
C87 divider_1/tspc_0/Z1 divider_1/tspc_0/Z4 0.00fF
C88 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z2 0.19fF
C89 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z2 0.01fF
C90 divider_1/and_0/OUT divider_1/and_0/out1 0.31fF
C91 divider_1/prescaler_0/tspc_2/D divider_1/clk 0.26fF
C92 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C93 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/clk 0.11fF
C94 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z4 0.20fF
C95 pd_0/REF pd_0/tspc_r_1/z5 0.04fF
C96 pd_0/tspc_r_1/Z1 pd_0/tspc_r_1/Z2 0.71fF
C97 divider_2/tspc_1/Q divider_2/tspc_0/Z1 0.01fF
C98 divider_2/tspc_1/Z1 divider_2/tspc_1/Z2 1.07fF
C99 divider_2/nor_0/B divider_2/tspc_1/Z3 0.38fF
C100 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z4 0.08fF
C101 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z3 0.05fF
C102 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Q 0.04fF
C103 divbuf_12/OUT3 divbuf_12/OUT 0.26fF
C104 divbuf_12/OUT4 divbuf_12/OUT5 20.26fF
C105 pd_1/and_pd_0/Z1 pd_1/UP 0.06fF
C106 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT5 43.38fF
C107 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_1/Qbar 0.02fF
C108 divbuf_14/OUT2 divbuf_14/a_492_n240# 0.42fF
C109 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_1/Q 0.13fF
C110 divider_0/prescaler_0/m1_2700_2190# divider_0/and_0/OUT 0.14fF
C111 divbuf_5/OUT ro_complete_0/cbank_2/v 0.05fF
C112 ro_complete_1/a3 ro_complete_1/cbank_1/v 0.05fF
C113 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C114 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C115 divider_1/tspc_1/Q divider_1/tspc_1/Z3 0.05fF
C116 divider_1/tspc_1/Z1 divider_1/tspc_1/Z4 0.00fF
C117 divider_1/Out divider_1/nor_1/B 0.22fF
C118 divbuf_11/a_492_n240# divbuf_11/OUT 0.00fF
C119 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z3 0.06fF
C120 pd_0/tspc_r_1/Qbar pd_0/UP 0.21fF
C121 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z2 0.25fF
C122 divbuf_18/OUT5 divbuf_18/OUT 43.38fF
C123 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/switch_1/vin 0.19fF
C124 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar 0.03fF
C125 divider_0/prescaler_0/tspc_2/Z4 divider_0/prescaler_0/tspc_2/D 0.11fF
C126 divider_0/prescaler_0/tspc_0/Z4 divider_0/clk 0.12fF
C127 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_4/vin 0.20fF
C128 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C129 divider_2/tspc_0/Z4 divider_2/tspc_1/Q 0.15fF
C130 divbuf_20/a_492_n240# divbuf_20/IN 0.13fF
C131 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C132 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C133 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/clk 0.14fF
C134 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/B 0.78fF
C135 divider_1/tspc_1/Z2 divider_1/tspc_1/Z4 0.36fF
C136 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/D 0.05fF
C137 divider_1/prescaler_0/tspc_0/Z3 divider_1/clk 0.64fF
C138 divbuf_22/OUT4 divbuf_22/OUT 1.11fF
C139 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z1 0.09fF
C140 pd_0/DIV pd_0/tspc_r_0/Z2 0.19fF
C141 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z3 0.05fF
C142 divider_2/tspc_0/Z3 divider_2/tspc_0/a_630_n680# 0.05fF
C143 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/z5 0.11fF
C144 divbuf_13/a_492_n240# divbuf_13/OUT5 0.01fF
C145 divbuf_5/OUT ro_complete_0/cbank_1/switch_2/vin 0.14fF
C146 divider_0/tspc_0/a_630_n680# divider_0/Out 0.04fF
C147 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT2 0.06fF
C148 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Out1 0.05fF
C149 divider_0/prescaler_0/tspc_2/Z3 divider_0/clk 0.45fF
C150 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/a1 0.14fF
C151 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/a3 0.09fF
C152 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/Z4 0.65fF
C153 ro_complete_1/cbank_2/switch_5/vin ro_complete_1/cbank_2/v 1.30fF
C154 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C155 divbuf_21/OUT2 divbuf_21/OUT3 1.37fF
C156 divider_2/prescaler_0/Out divider_2/tspc_2/Z3 0.45fF
C157 divider_1/tspc_1/Z4 divider_1/nor_0/A 0.02fF
C158 pd_0/R pd_0/tspc_r_1/Qbar 0.03fF
C159 filter_0/a_4216_n2998# filter_0/v 0.36fF
C160 pd_1/and_pd_0/Out1 pd_1/and_pd_0/Z1 0.18fF
C161 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/z5 0.03fF
C162 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/R 0.21fF
C163 divider_2/nor_0/A divider_2/and_0/B 0.08fF
C164 divbuf_24/OUT3 divbuf_24/OUT 0.26fF
C165 divbuf_24/OUT4 divbuf_24/OUT5 20.26fF
C166 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Z4 0.65fF
C167 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/pd_0/UP 0.06fF
C168 divider_0/tspc_2/Z2 divider_0/tspc_2/Z3 0.16fF
C169 divider_0/nor_0/A divider_0/tspc_2/Z4 0.21fF
C170 divbuf_3/IN divbuf_3/a_492_n240# 0.13fF
C171 divbuf_1/a_492_n240# divbuf_1/IN 0.13fF
C172 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/v 1.30fF
C173 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C174 divider_1/nor_0/B divider_1/tspc_0/Z4 0.02fF
C175 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z4 0.00fF
C176 divbuf_6/a_492_n240# divbuf_6/OUT2 0.42fF
C177 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z4 0.12fF
C178 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z3 0.45fF
C179 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/nor_1/B 0.40fF
C180 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C181 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/B 0.01fF
C182 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z4 0.12fF
C183 divider_1/tspc_2/Z1 divider_1/tspc_2/Z2 1.07fF
C184 divider_1/nor_0/A divider_1/tspc_2/Z3 0.38fF
C185 divbuf_23/a_492_n240# divbuf_23/OUT 0.00fF
C186 cp_0/a_1710_0# cp_0/a_1710_n2840# 0.83fF
C187 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Out1 0.05fF
C188 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Q 0.20fF
C189 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/D 0.09fF
C190 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Z1 0.07fF
C191 divbuf_15/OUT divbuf_15/OUT2 0.06fF
C192 divbuf_15/OUT5 divbuf_15/OUT3 0.01fF
C193 divider_0/prescaler_0/Out divider_0/tspc_2/a_630_n680# 0.01fF
C194 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z4 0.00fF
C195 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Q 0.21fF
C196 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C197 divider_0/and_0/B divider_0/and_0/Z1 0.07fF
C198 divbuf_3/OUT4 divbuf_3/OUT5 20.26fF
C199 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z4 0.12fF
C200 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z3 0.06fF
C201 divbuf_10/IN divbuf_10/OUT5 0.00fF
C202 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C203 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C204 divbuf_22/a_492_n240# divbuf_22/IN 0.13fF
C205 divbuf_9/OUT4 divbuf_9/OUT 1.11fF
C206 pd_1/tspc_r_0/z5 pd_1/tspc_r_1/z5 0.02fF
C207 pd_0/and_pd_0/Z1 pd_0/UP 0.06fF
C208 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/nand_1/z1 0.22fF
C209 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/tspc_0/D 0.04fF
C210 io_analog[6] io_clamp_high[2] 0.53fF
C211 divbuf_1/OUT2 divbuf_1/OUT5 0.02fF
C212 divbuf_0/IN divbuf_0/a_492_n240# 0.13fF
C213 divbuf_5/OUT ro_complete_0/cbank_0/switch_2/vin 0.14fF
C214 ro_complete_0/cbank_0/switch_1/vin divbuf_4/OUT 0.09fF
C215 ro_complete_0/cbank_0/switch_0/vin divbuf_2/OUT 0.09fF
C216 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C217 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/z5 0.20fF
C218 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z3 0.33fF
C219 divbuf_5/OUT divbuf_5/a_492_n240# 0.00fF
C220 divbuf_3/OUT divbuf_3/OUT3 0.26fF
C221 divider_0/prescaler_0/tspc_1/Z4 divider_0/clk 0.12fF
C222 divbuf_7/OUT divbuf_7/OUT5 43.38fF
C223 divbuf_4/OUT2 divbuf_4/OUT5 0.02fF
C224 divbuf_4/OUT3 divbuf_4/OUT4 5.16fF
C225 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/Q 0.04fF
C226 divider_1/prescaler_0/tspc_1/Z3 divider_1/clk 0.45fF
C227 divbuf_8/OUT2 divbuf_8/OUT3 1.37fF
C228 divbuf_18/OUT3 divbuf_18/OUT5 0.01fF
C229 divider_2/tspc_0/Z3 divider_2/tspc_1/Q 0.45fF
C230 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z3 0.16fF
C231 divider_2/nor_0/A divider_2/tspc_2/Z2 0.23fF
C232 divbuf_2/IN divbuf_2/OUT5 0.00fF
C233 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/and_pd_0/Z1 0.18fF
C234 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C235 divider_0/prescaler_0/tspc_1/Q divider_0/clk 0.60fF
C236 divider_1/nor_1/Z1 divider_1/nor_1/B 0.06fF
C237 divbuf_5/OUT2 divbuf_5/OUT5 0.02fF
C238 divbuf_5/OUT3 divbuf_5/OUT4 5.16fF
C239 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C240 divbuf_17/OUT4 divbuf_17/OUT5 20.26fF
C241 divbuf_7/a_492_n240# divbuf_7/OUT2 0.42fF
C242 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C243 divbuf_12/OUT5 divbuf_12/OUT 43.38fF
C244 pd_0/R pd_0/and_pd_0/Z1 0.02fF
C245 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/z5 0.20fF
C246 divider_2/nor_0/B divider_2/tspc_1/Z4 0.21fF
C247 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z4 0.12fF
C248 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z2 1.07fF
C249 divider_2/and_0/out1 divider_2/and_0/Z1 0.36fF
C250 divbuf_2/OUT divbuf_2/a_492_n240# 0.00fF
C251 divbuf_15/OUT5 divbuf_15/a_492_n240# 0.01fF
C252 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_1/Q 0.21fF
C253 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_2/D 0.16fF
C254 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/D 0.03fF
C255 ro_complete_1/a4 ro_complete_1/cbank_2/v 0.05fF
C256 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_0/vin 0.19fF
C257 divbuf_25/OUT2 divbuf_25/OUT5 0.02fF
C258 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_1/Q 0.13fF
C259 divider_1/prescaler_0/m1_2700_2190# divider_1/and_0/OUT 0.14fF
C260 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z4 0.15fF
C261 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C262 pll_full_0/ro_complete_0/a0 pll_full_0/divider_0/clk 0.11fF
C263 divbuf_17/OUT3 divbuf_17/OUT5 0.01fF
C264 divbuf_11/IN divbuf_11/OUT5 0.00fF
C265 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z4 0.00fF
C266 divbuf_9/a_492_n240# divbuf_9/IN 0.13fF
C267 pd_1/DIV pd_1/tspc_r_0/Z3 0.65fF
C268 pd_0/and_pd_0/Out1 pd_0/and_pd_0/Z1 0.18fF
C269 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/Qbar 0.01fF
C270 divider_2/prescaler_0/tspc_1/Z2 divider_2/clk 0.11fF
C271 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Qbar1 0.12fF
C272 divbuf_7/OUT ro_complete_0/cbank_2/switch_5/vin 0.09fF
C273 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C274 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a4 0.09fF
C275 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a5 0.09fF
C276 divider_1/prescaler_0/tspc_2/Z4 divider_1/prescaler_0/tspc_2/D 0.11fF
C277 divider_1/prescaler_0/tspc_0/Z4 divider_1/clk 0.12fF
C278 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C279 pd_0/DIV pd_0/R 0.51fF
C280 divbuf_17/OUT4 divbuf_17/OUT 1.11fF
C281 divider_2/mc2 divider_2/prescaler_0/tspc_2/a_630_n680# 0.33fF
C282 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z4 0.12fF
C283 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/a_630_n680# 0.19fF
C284 io_clamp_low[2] io_clamp_high[2] 0.53fF
C285 divbuf_13/OUT2 divbuf_13/OUT3 1.37fF
C286 cp_0/upbar cp_0/down 0.02fF
C287 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/tspc_r_0/Z2 0.71fF
C288 divbuf_4/OUT divbuf_2/OUT 1.95fF
C289 divider_0/mc2 divider_0/prescaler_0/tspc_2/a_630_n680# 0.33fF
C290 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/v 1.30fF
C291 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/a1 0.14fF
C292 divider_0/prescaler_0/tspc_2/Z4 divider_0/clk 0.12fF
C293 divbuf_5/a_492_n240# divbuf_5/IN 0.13fF
C294 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C295 divider_1/tspc_0/a_630_n680# divider_1/Out 0.04fF
C296 divider_2/prescaler_0/Out divider_2/tspc_2/Z4 0.12fF
C297 divider_1/prescaler_0/tspc_2/Z3 divider_1/clk 0.45fF
C298 divbuf_21/OUT2 divbuf_21/OUT5 0.02fF
C299 divbuf_21/OUT3 divbuf_21/OUT4 5.16fF
C300 pd_0/REF pd_0/tspc_r_1/Qbar1 0.12fF
C301 divbuf_17/OUT3 divbuf_17/OUT 0.26fF
C302 divbuf_12/a_492_n240# divbuf_12/OUT2 0.42fF
C303 divbuf_24/OUT5 divbuf_24/OUT 43.38fF
C304 filter_0/a_4216_n5230# filter_0/v 0.91fF
C305 pd_1/tspc_r_1/z5 pd_1/UP 0.03fF
C306 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z4 0.14fF
C307 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/switch_0/vin 0.19fF
C308 divbuf_6/OUT divbuf_6/OUT2 0.06fF
C309 ro_complete_1/a5 ro_complete_1/cbank_2/switch_0/vin 0.09fF
C310 divider_0/tspc_2/Z2 divider_0/tspc_2/Z4 0.36fF
C311 pll_full_0/ro_complete_0/a3 pll_full_0/divider_0/clk 0.11fF
C312 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Z4 0.65fF
C313 divider_1/tspc_2/Z2 divider_1/tspc_2/Z3 0.16fF
C314 divider_1/nor_0/A divider_1/tspc_2/Z4 0.21fF
C315 pd_1/tspc_r_0/Qbar1 pd_1/DIV 0.12fF
C316 divider_2/tspc_1/Z3 divider_2/tspc_1/Z4 0.65fF
C317 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Q 0.04fF
C318 divbuf_23/IN divbuf_23/OUT5 0.00fF
C319 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_492_n240# 0.00fF
C320 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C321 divider_0/prescaler_0/Out divider_0/nor_0/A 0.15fF
C322 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Z4 0.65fF
C323 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/clk 0.14fF
C324 divider_0/nor_1/Z1 divider_0/and_0/B 0.78fF
C325 divbuf_2/OUT3 divbuf_2/OUT5 0.01fF
C326 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C327 divbuf_10/OUT2 divbuf_10/OUT 0.06fF
C328 divbuf_10/OUT3 divbuf_10/OUT5 0.01fF
C329 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C330 divider_1/prescaler_0/Out divider_1/tspc_2/a_630_n680# 0.01fF
C331 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z4 0.00fF
C332 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Q 0.21fF
C333 divbuf_19/OUT5 divbuf_19/OUT 43.38fF
C334 divider_1/and_0/B divider_1/and_0/Z1 0.07fF
C335 pd_1/R pd_1/UP 0.45fF
C336 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z1 0.09fF
C337 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/nand_1/z1 0.01fF
C338 divider_2/prescaler_0/tspc_2/Z2 divider_2/clk 0.11fF
C339 io_analog[5] io_clamp_low[1] 0.53fF
C340 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z4 0.08fF
C341 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z3 0.05fF
C342 divbuf_2/OUT2 divbuf_2/OUT 0.06fF
C343 divbuf_3/OUT divbuf_3/OUT5 43.38fF
C344 ro_complete_0/cbank_1/v ro_complete_0/cbank_2/v 1.36fF
C345 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C346 divbuf_4/OUT4 divbuf_4/OUT5 20.26fF
C347 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C348 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z3 0.33fF
C349 divbuf_16/OUT2 divbuf_16/OUT5 0.02fF
C350 divider_1/prescaler_0/tspc_1/Z4 divider_1/clk 0.12fF
C351 pd_0/tspc_r_0/Z4 pd_0/tspc_r_0/z5 0.04fF
C352 divbuf_18/IN divbuf_18/a_492_n240# 0.13fF
C353 divider_2/tspc_0/a_630_n680# divider_2/tspc_1/Q 0.01fF
C354 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z4 0.36fF
C355 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_0/D 0.09fF
C356 divbuf_8/OUT2 divbuf_8/OUT5 0.02fF
C357 divbuf_8/OUT3 divbuf_8/OUT4 5.16fF
C358 pd_1/tspc_r_1/Z3 pd_1/UP 0.03fF
C359 divider_2/tspc_2/Z1 divider_2/tspc_2/Z3 0.06fF
C360 divbuf_24/a_492_n240# divbuf_24/OUT2 0.42fF
C361 divider_0/tspc_0/Z3 divider_0/Out 0.05fF
C362 divider_0/tspc_0/Z2 divider_0/nor_1/B 0.40fF
C363 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z3 0.33fF
C364 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_0/vin 0.19fF
C365 pll_full_0/pd_0/tspc_r_1/z5 pll_full_0/pd_0/UP 0.03fF
C366 divider_0/and_0/OUT divider_0/and_0/Z1 0.04fF
C367 divider_0/prescaler_0/tspc_2/Q divider_0/clk 0.05fF
C368 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/a0 0.13fF
C369 divbuf_5/OUT4 divbuf_5/OUT5 20.26fF
C370 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C371 divbuf_16/OUT3 divbuf_16/OUT2 1.37fF
C372 divbuf_16/IN divbuf_16/OUT5 0.00fF
C373 divider_1/prescaler_0/tspc_1/Q divider_1/clk 0.60fF
C374 cp_0/a_1710_0# cp_0/a_10_n50# 0.04fF
C375 pd_1/tspc_r_0/Z2 pd_1/DIV 0.19fF
C376 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C377 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z3 0.16fF
C378 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/nand_0/z1 0.07fF
C379 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/D 0.05fF
C380 divbuf_1/OUT5 divbuf_1/OUT 43.38fF
C381 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C382 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/v 1.30fF
C383 divider_1/mc2 divider_1/and_0/out1 0.06fF
C384 divbuf_14/OUT4 divbuf_14/OUT3 5.16fF
C385 ro_complete_1/a1 ro_complete_1/cbank_1/v 0.05fF
C386 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_1/B 0.47fF
C387 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/Z4 0.65fF
C388 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z2 0.19fF
C389 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_1/Q 0.21fF
C390 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_2/D 0.16fF
C391 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/D 0.03fF
C392 divbuf_11/OUT2 divbuf_11/OUT 0.06fF
C393 divbuf_11/OUT3 divbuf_11/OUT5 0.01fF
C394 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divider_0/tspc_2/Z4 0.65fF
C395 cp_0/a_1710_0# cp_0/down 0.32fF
C396 pd_1/DOWN pd_1/tspc_r_1/Qbar 0.02fF
C397 pd_1/R pd_1/and_pd_0/Out1 0.33fF
C398 pd_0/tspc_r_1/z5 pd_0/UP 0.03fF
C399 divider_0/nor_0/Z1 divider_0/nor_0/B 0.06fF
C400 divbuf_7/OUT ro_complete_0/cbank_2/v 0.05fF
C401 divider_1/mc2 divider_1/nor_0/B 0.06fF
C402 divbuf_14/OUT2 divbuf_14/OUT3 1.37fF
C403 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Q 0.05fF
C404 divider_0/prescaler_0/m1_2700_2190# divider_0/clk 0.01fF
C405 divbuf_20/a_492_n240# divbuf_20/OUT5 0.01fF
C406 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C407 divbuf_16/OUT3 divbuf_16/OUT5 0.01fF
C408 pd_0/tspc_r_0/Qbar1 pd_0/R 0.01fF
C409 pd_0/DIV pd_0/tspc_r_0/Z4 0.02fF
C410 pd_0/DOWN pd_0/tspc_r_0/Qbar 0.21fF
C411 divbuf_18/OUT2 divbuf_18/a_492_n240# 0.42fF
C412 divider_2/and_0/OUT divider_2/and_0/B 0.01fF
C413 divbuf_13/OUT2 divbuf_13/OUT5 0.02fF
C414 divbuf_13/OUT3 divbuf_13/OUT4 5.16fF
C415 ro_complete_0/cbank_1/switch_3/vin divbuf_6/OUT 0.14fF
C416 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z4 0.01fF
C417 ro_complete_1/a4 ro_complete_1/cbank_2/switch_1/vin 0.09fF
C418 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/v 1.30fF
C419 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C420 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_1/Q 0.14fF
C421 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/Out 0.04fF
C422 divbuf_21/OUT3 divbuf_21/OUT 0.26fF
C423 divbuf_21/OUT4 divbuf_21/OUT5 20.26fF
C424 divider_2/prescaler_0/tspc_0/Z3 divider_2/clk 0.64fF
C425 divider_1/prescaler_0/tspc_2/Z4 divider_1/clk 0.12fF
C426 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/a_630_n680# 0.19fF
C427 pll_full_0/pd_0/DOWN pll_full_0/pd_0/REF 1.48fF
C428 divbuf_2/OUT divbuf_2/OUT4 1.11fF
C429 divbuf_4/OUT ro_complete_0/cbank_2/switch_0/vin 0.12fF
C430 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Q 0.15fF
C431 divider_0/prescaler_0/tspc_0/Z2 divider_0/and_0/OUT 0.06fF
C432 divbuf_6/OUT divbuf_6/OUT4 1.11fF
C433 divbuf_3/OUT2 divbuf_3/OUT3 1.37fF
C434 ro_complete_1/a3 ro_complete_1/cbank_2/switch_2/vin 0.09fF
C435 divbuf_17/OUT2 divbuf_17/a_492_n240# 0.42fF
C436 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/B 0.18fF
C437 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C438 filter_0/v divbuf_25/OUT5 43.38fF
C439 divbuf_19/OUT2 divbuf_19/a_492_n240# 0.42fF
C440 divider_1/tspc_2/Z2 divider_1/tspc_2/Z4 0.36fF
C441 divbuf_23/OUT2 divbuf_23/OUT 0.06fF
C442 divbuf_23/OUT3 divbuf_23/OUT5 0.01fF
C443 pd_1/R pd_1/tspc_r_1/Z2 0.21fF
C444 pd_1/DOWN pd_1/tspc_r_0/Z3 0.03fF
C445 pll_full_0/pd_0/R pll_full_0/pd_0/REF 0.61fF
C446 divbuf_15/OUT2 divbuf_15/OUT3 1.37fF
C447 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/a3 0.13fF
C448 divbuf_3/OUT ro_complete_0/cbank_2/v 0.05fF
C449 divbuf_15/IN divbuf_15/a_492_n240# 0.13fF
C450 divbuf_25/OUT3 divbuf_25/OUT5 0.01fF
C451 divbuf_25/a_492_n240# divbuf_25/IN 0.13fF
C452 divider_0/prescaler_0/Out divider_0/tspc_2/Z2 0.11fF
C453 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/clk 0.01fF
C454 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/v 1.30fF
C455 divider_2/Out divider_2/nor_1/B 0.22fF
C456 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z2 0.01fF
C457 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C458 divider_1/prescaler_0/Out divider_1/nor_0/A 0.15fF
C459 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Z4 0.65fF
C460 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/clk 0.14fF
C461 divider_1/nor_1/Z1 divider_1/and_0/B 0.78fF
C462 divbuf_10/OUT4 divbuf_10/OUT 1.11fF
C463 divbuf_22/a_492_n240# divbuf_22/OUT5 0.01fF
C464 pd_1/DOWN pd_1/and_pd_0/Z1 0.07fF
C465 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z2 0.25fF
C466 divider_2/prescaler_0/tspc_0/D divider_2/prescaler_0/nand_1/z1 0.21fF
C467 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z4 0.12fF
C468 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z2 1.07fF
C469 divbuf_4/OUT divbuf_4/OUT3 0.26fF
C470 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/v 1.30fF
C471 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT5 0.01fF
C472 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_2/Q 0.19fF
C473 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/clk 0.01fF
C474 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z4 0.08fF
C475 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z3 0.05fF
C476 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C477 divbuf_17/OUT2 divbuf_17/OUT5 0.02fF
C478 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/a_630_n680# 0.04fF
C479 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C480 pd_0/R pd_0/REF 0.61fF
C481 divbuf_8/OUT3 divbuf_8/OUT 0.26fF
C482 divbuf_8/OUT4 divbuf_8/OUT5 20.26fF
C483 divider_2/tspc_2/Z1 divider_2/tspc_2/Z4 0.00fF
C484 divbuf_3/OUT ro_complete_0/cbank_1/switch_2/vin 0.09fF
C485 divider_0/nor_0/B divider_0/tspc_2/Q 0.22fF
C486 divider_0/tspc_0/a_630_n680# divider_0/nor_1/B 0.35fF
C487 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z4 0.08fF
C488 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z3 0.05fF
C489 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_4/vin 0.20fF
C490 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C491 divider_0/tspc_2/a_630_n680# divider_0/nor_0/A 0.35fF
C492 divider_0/prescaler_0/tspc_0/D divider_0/clk 0.29fF
C493 divider_1/tspc_0/Z3 divider_1/Out 0.05fF
C494 divider_1/tspc_0/Z2 divider_1/nor_1/B 0.40fF
C495 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z3 0.33fF
C496 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z1 0.03fF
C497 pll_full_0/ro_complete_0/a4 pll_full_0/divider_0/clk 0.01fF
C498 divider_1/and_0/OUT divider_1/and_0/Z1 0.04fF
C499 divider_1/prescaler_0/tspc_2/Q divider_1/clk 0.05fF
C500 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/nor_0/A 0.03fF
C501 pd_1/R pd_1/DIV 0.51fF
C502 pd_1/tspc_r_0/Qbar1 pd_1/DOWN 0.11fF
C503 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z4 0.36fF
C504 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT3 0.26fF
C505 divbuf_15/OUT2 divbuf_15/a_492_n240# 0.42fF
C506 divider_0/tspc_1/a_630_n680# divider_0/nor_1/B 0.00fF
C507 divider_0/prescaler_0/tspc_1/Z2 divider_0/and_0/OUT 0.06fF
C508 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z3 0.33fF
C509 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Q 0.38fF
C510 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_0/D 0.11fF
C511 divider_0/nor_0/Z1 divider_0/and_0/A 0.80fF
C512 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_5/vin 0.20fF
C513 pll_full_0/pd_0/DIV pll_full_0/divider_0/and_0/OUT 0.01fF
C514 ro_complete_1/a5 ro_complete_1/cbank_2/v 0.08fF
C515 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C516 divider_1/mc2 divider_1/and_0/A 0.16fF
C517 divider_0/and_0/out1 divider_0/and_0/A 0.01fF
C518 divbuf_10/a_492_n240# divbuf_10/IN 0.13fF
C519 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/nand_0/z1 0.07fF
C520 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/D 0.05fF
C521 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z2 0.30fF
C522 divbuf_18/OUT2 divbuf_18/OUT 0.06fF
C523 divbuf_17/OUT2 divbuf_17/OUT 0.06fF
C524 divbuf_16/OUT5 divbuf_16/OUT4 20.26fF
C525 divbuf_11/OUT4 divbuf_11/OUT 1.11fF
C526 divbuf_9/a_492_n240# divbuf_9/OUT5 0.01fF
C527 divider_0/tspc_0/Z2 divider_0/tspc_0/a_630_n680# 0.01fF
C528 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z1 0.09fF
C529 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z2 0.19fF
C530 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/clk 0.01fF
C531 divider_0/nor_0/B divider_0/and_0/A 0.26fF
C532 divbuf_1/OUT2 divbuf_1/OUT3 1.37fF
C533 divbuf_7/OUT divbuf_7/a_492_n240# 0.00fF
C534 divbuf_4/a_492_n240# divbuf_4/OUT2 0.42fF
C535 divbuf_20/OUT2 divbuf_20/OUT3 1.37fF
C536 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_1/Q 0.13fF
C537 divbuf_16/OUT3 divbuf_16/OUT4 5.16fF
C538 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Q 0.05fF
C539 divider_1/prescaler_0/m1_2700_2190# divider_1/clk 0.01fF
C540 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z3 0.45fF
C541 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_0/A 1.21fF
C542 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/z5 0.11fF
C543 divider_2/tspc_0/Z2 divider_2/nor_1/B 0.40fF
C544 io_clamp_low[1] io_clamp_high[1] 0.53fF
C545 divbuf_13/OUT3 divbuf_13/OUT 0.26fF
C546 divbuf_13/OUT4 divbuf_13/OUT5 20.26fF
C547 ro_complete_0/cbank_0/switch_3/vin divbuf_6/OUT 0.14fF
C548 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/v 1.30fF
C549 ro_complete_0/cbank_0/switch_2/vin divbuf_3/OUT 0.09fF
C550 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/UP 0.11fF
C551 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/Out 0.05fF
C552 divider_0/nor_1/B divider_0/and_0/B 0.29fF
C553 ro_complete_1/a2 ro_complete_1/cbank_2/v 0.05fF
C554 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C555 divbuf_5/a_492_n240# divbuf_5/OUT5 0.01fF
C556 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z3 0.16fF
C557 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C558 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/a_630_n680# 0.05fF
C559 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z4 0.01fF
C560 divbuf_21/OUT5 divbuf_21/OUT 43.38fF
C561 divider_2/prescaler_0/tspc_0/Z4 divider_2/clk 0.12fF
C562 pd_1/tspc_r_0/Qbar pd_1/tspc_r_0/Qbar1 0.01fF
C563 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z1 0.09fF
C564 pd_0/REF pd_0/tspc_r_1/Z2 0.19fF
C565 divbuf_12/a_492_n240# divbuf_12/OUT 0.00fF
C566 divider_0/tspc_1/Z1 divider_0/tspc_1/Z2 1.07fF
C567 divider_0/nor_0/B divider_0/tspc_1/Z3 0.38fF
C568 divider_0/tspc_1/Q divider_0/nor_1/B 0.22fF
C569 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/v 1.30fF
C570 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/cbank_0/v 1.30fF
C571 divbuf_3/OUT2 divbuf_3/OUT5 0.02fF
C572 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/a0 0.09fF
C573 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT 43.38fF
C574 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C575 divbuf_6/IN divbuf_6/OUT5 0.00fF
C576 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_2/Q 0.01fF
C577 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/a_630_n680# 0.35fF
C578 pll_full_0/ro_complete_0/a1 pll_full_0/divider_0/clk 0.11fF
C579 divider_1/nor_0/Z1 divider_1/and_0/B 0.18fF
C580 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Q 0.15fF
C581 divider_1/prescaler_0/tspc_0/Z2 divider_1/and_0/OUT 0.06fF
C582 divbuf_11/a_492_n240# divbuf_11/IN 0.13fF
C583 pd_0/tspc_r_1/Qbar1 pd_0/UP 0.11fF
C584 divbuf_23/OUT4 divbuf_23/OUT 1.11fF
C585 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar1 0.30fF
C586 divider_0/prescaler_0/tspc_2/Z2 divider_0/and_0/OUT 0.05fF
C587 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z2 0.14fF
C588 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C589 divbuf_19/IN divbuf_19/OUT5 0.00fF
C590 divbuf_17/OUT4 divbuf_17/OUT3 5.16fF
C591 divider_1/prescaler_0/Out divider_1/tspc_2/Z2 0.11fF
C592 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/clk 0.01fF
C593 divbuf_22/OUT2 divbuf_22/OUT3 1.37fF
C594 pd_0/DIV pd_0/tspc_r_0/Z3 0.65fF
C595 divider_2/mc2 divider_2/nor_1/B 0.15fF
C596 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/B 0.18fF
C597 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/Qbar 0.01fF
C598 io_analog[4] io_clamp_high[0] 0.53fF
C599 divider_0/tspc_0/Z2 divider_0/tspc_1/Q 0.14fF
C600 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z3 0.16fF
C601 divbuf_16/a_492_n240# divbuf_16/OUT2 0.42fF
C602 divider_0/tspc_1/Z2 divider_0/nor_0/A 0.15fF
C603 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_0/D 0.32fF
C604 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/clk 0.01fF
C605 divbuf_4/OUT divbuf_4/OUT5 43.38fF
C606 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/cbank_0/v 1.30fF
C607 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C608 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C609 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/a3 0.09fF
C610 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z4 0.12fF
C611 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z2 1.07fF
C612 divbuf_21/a_492_n240# divbuf_21/OUT2 0.42fF
C613 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/B 0.31fF
C614 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/nor_0/A 0.55fF
C615 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C616 divbuf_18/OUT2 divbuf_18/OUT3 1.37fF
C617 divider_2/nor_1/Z1 divider_2/nor_0/B 0.18fF
C618 divider_2/prescaler_0/Out divider_2/tspc_2/a_630_n680# 0.01fF
C619 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_2/Q 0.19fF
C620 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/clk 0.01fF
C621 divbuf_8/OUT5 divbuf_8/OUT 43.38fF
C622 pd_0/DOWN pd_0/tspc_r_1/Qbar 0.02fF
C623 pd_0/R pd_0/tspc_r_1/Qbar1 0.30fF
C624 divider_2/nor_1/B divider_2/nor_0/B 0.47fF
C625 divider_2/tspc_0/Z2 divider_2/tspc_0/Z1 1.07fF
C626 divider_2/tspc_2/Z3 divider_2/tspc_2/Z4 0.65fF
C627 divbuf_24/a_492_n240# divbuf_24/OUT 0.00fF
C628 divbuf_3/OUT ro_complete_0/cbank_2/switch_1/vin 0.13fF
C629 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C630 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z3 0.33fF
C631 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z4 0.12fF
C632 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z2 1.07fF
C633 divbuf_16/a_492_n240# divbuf_16/IN 0.13fF
C634 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z2 0.01fF
C635 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C636 divider_1/nor_0/B divider_1/tspc_2/Q 0.22fF
C637 divider_1/tspc_0/a_630_n680# divider_1/nor_1/B 0.35fF
C638 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z4 0.08fF
C639 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z3 0.05fF
C640 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Q 0.51fF
C641 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z4 0.36fF
C642 divbuf_7/IN divbuf_7/OUT5 0.00fF
C643 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/clk 0.06fF
C644 divider_1/tspc_2/a_630_n680# divider_1/nor_0/A 0.35fF
C645 divider_1/prescaler_0/tspc_0/D divider_1/clk 0.29fF
C646 divbuf_23/a_492_n240# divbuf_23/IN 0.13fF
C647 divbuf_15/OUT4 divbuf_15/OUT 1.11fF
C648 divbuf_4/OUT ro_complete_0/cbank_2/v 0.05fF
C649 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/v 1.30fF
C650 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT2 0.42fF
C651 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z2 0.01fF
C652 divider_0/tspc_2/Q divider_0/tspc_1/Z3 0.45fF
C653 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z4 0.08fF
C654 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z3 0.05fF
C655 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Q 0.04fF
C656 divider_2/tspc_0/Z4 divider_2/tspc_0/Z2 0.36fF
C657 divider_2/Out divider_2/tspc_0/Z3 0.05fF
C658 divbuf_16/a_492_n240# divbuf_16/OUT5 0.01fF
C659 ro_complete_1/a0 ro_complete_1/cbank_2/switch_4/vin 0.13fF
C660 ro_complete_1/cbank_0/v ro_complete_1/cbank_1/v 1.27fF
C661 divider_1/tspc_1/a_630_n680# divider_1/nor_1/B 0.00fF
C662 divider_1/prescaler_0/tspc_1/Z2 divider_1/and_0/OUT 0.06fF
C663 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z3 0.33fF
C664 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Q 0.38fF
C665 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/D 0.11fF
C666 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C667 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z3 0.06fF
C668 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/A 0.01fF
C669 divbuf_18/IN divbuf_18/OUT5 0.00fF
C670 divider_2/tspc_1/a_630_n680# divider_2/nor_1/B 0.00fF
C671 divider_1/and_0/out1 divider_1/and_0/A 0.01fF
C672 divbuf_9/OUT2 divbuf_9/OUT3 1.37fF
C673 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C674 ro_complete_0/cbank_2/switch_2/vin ro_complete_0/cbank_2/v 1.30fF
C675 divider_1/tspc_0/Z2 divider_1/tspc_0/a_630_n680# 0.01fF
C676 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_1/Q 0.21fF
C677 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/clk 0.01fF
C678 divider_1/nor_0/B divider_1/and_0/A 0.26fF
C679 divbuf_20/OUT2 divbuf_20/OUT5 0.02fF
C680 divbuf_20/OUT3 divbuf_20/OUT4 5.16fF
C681 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/nor_0/A 0.01fF
C682 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z4 0.12fF
C683 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z3 0.16fF
C684 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C685 divbuf_8/a_492_n240# divbuf_8/OUT2 0.42fF
C686 pd_0/DOWN pd_0/tspc_r_0/z5 0.03fF
C687 pd_0/tspc_r_0/Z2 pd_0/R 0.21fF
C688 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z2 0.01fF
C689 divbuf_13/OUT5 divbuf_13/OUT 43.38fF
C690 pd_1/tspc_r_1/Z4 pd_1/tspc_r_1/z5 0.04fF
C691 ro_complete_0/cbank_1/switch_1/vin divbuf_3/OUT 0.14fF
C692 ro_complete_0/cbank_2/switch_3/vin divbuf_6/OUT 0.14fF
C693 pll_full_0/pd_0/REF pll_full_0/divbuf_1/a_492_n240# 0.13fF
C694 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z1 0.08fF
C695 divider_0/mc2 divider_0/nor_1/B 0.15fF
C696 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/cbank_0/v 1.30fF
C697 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C698 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C699 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/a_630_n680# 0.12fF
C700 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C701 divider_1/nor_1/B divider_1/and_0/B 0.29fF
C702 divbuf_12/IN divbuf_12/OUT5 0.00fF
C703 pd_1/R pd_1/DOWN 0.36fF
C704 pd_0/DOWN pd_0/and_pd_0/Z1 0.07fF
C705 pd_1/and_pd_0/Out1 pd_1/UP 0.33fF
C706 ro_complete_0/cbank_1/switch_4/vin divbuf_7/OUT 0.13fF
C707 divbuf_1/OUT2 divbuf_1/a_492_n240# 0.42fF
C708 divbuf_2/OUT ro_complete_0/cbank_2/switch_0/vin 0.09fF
C709 divider_0/nor_0/B divider_0/tspc_1/Z4 0.21fF
C710 divider_0/tspc_0/Z3 divider_0/nor_1/B 0.38fF
C711 divbuf_1/OUT divbuf_1/OUT3 0.26fF
C712 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C713 divider_0/nor_0/A divider_0/and_0/B 0.08fF
C714 divider_1/tspc_1/Z1 divider_1/tspc_1/Z2 1.07fF
C715 divider_1/nor_0/B divider_1/tspc_1/Z3 0.38fF
C716 divider_1/tspc_1/Q divider_1/nor_1/B 0.22fF
C717 divbuf_6/OUT3 divbuf_6/OUT5 0.01fF
C718 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C719 divbuf_18/OUT2 divbuf_18/OUT5 0.02fF
C720 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z3 0.05fF
C721 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z1 0.03fF
C722 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/Z3 0.20fF
C723 pd_1/tspc_r_0/z5 pd_1/DIV 0.04fF
C724 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/DOWN 0.03fF
C725 divbuf_19/OUT5 divbuf_19/OUT3 0.01fF
C726 divider_2/nor_0/B divider_2/tspc_2/a_630_n680# 0.01fF
C727 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/D 0.03fF
C728 pll_full_0/pd_0/DOWN pll_full_0/pd_0/UP 4.58fF
C729 divbuf_6/OUT ro_complete_0/cbank_2/v 0.05fF
C730 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Q 0.20fF
C731 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/D 0.09fF
C732 divider_0/prescaler_0/tspc_0/Z2 divider_0/clk 0.11fF
C733 pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C734 divider_2/tspc_0/Z4 divider_2/nor_0/B 0.02fF
C735 divbuf_19/OUT2 divbuf_19/OUT 0.06fF
C736 divider_1/prescaler_0/tspc_2/Z2 divider_1/and_0/OUT 0.05fF
C737 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z3 0.05fF
C738 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Qbar1 0.38fF
C739 divider_2/tspc_0/Z2 divider_2/tspc_0/Z3 0.16fF
C740 divbuf_22/OUT2 divbuf_22/OUT5 0.02fF
C741 divbuf_22/OUT3 divbuf_22/OUT4 5.16fF
C742 pll_full_0/divider_0/and_0/A pll_full_0/divider_0/and_0/B 0.18fF
C743 divbuf_13/a_492_n240# divbuf_13/OUT2 0.42fF
C744 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z4 0.20fF
C745 pd_1/REF pd_1/tspc_r_1/z5 0.04fF
C746 pd_1/tspc_r_1/Z1 pd_1/tspc_r_1/Z2 0.71fF
C747 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/R 0.27fF
C748 divider_2/prescaler_0/tspc_1/Q divider_2/nor_0/A 0.03fF
C749 divider_0/tspc_0/a_630_n680# divider_0/tspc_1/Q 0.01fF
C750 divider_0/tspc_0/Z2 divider_0/tspc_0/Z3 0.16fF
C751 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z4 0.36fF
C752 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/Out 0.05fF
C753 pll_full_0/pd_0/R pll_full_0/pd_0/UP 0.46fF
C754 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C755 divbuf_5/OUT divbuf_5/OUT3 0.26fF
C756 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT 0.06fF
C757 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT5 0.01fF
C758 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C759 divider_1/mc2 divider_1/prescaler_0/tspc_2/a_630_n680# 0.33fF
C760 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/nand_1/z1 0.22fF
C761 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/tspc_0/D 0.04fF
C762 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_0/B 0.18fF
C763 divider_1/tspc_0/Z2 divider_1/tspc_1/Q 0.14fF
C764 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z3 0.16fF
C765 divider_2/prescaler_0/Out divider_2/nor_0/A 0.15fF
C766 divider_1/tspc_1/Z2 divider_1/nor_0/A 0.15fF
C767 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_0/D 0.32fF
C768 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/clk 0.01fF
C769 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C770 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Qbar1 0.12fF
C771 divbuf_24/IN divbuf_24/OUT5 0.00fF
C772 pll_full_0/pd_0/DOWN pll_full_0/pd_0/R 0.36fF
C773 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z4 0.08fF
C774 divider_0/tspc_1/Q divider_0/tspc_1/a_630_n680# 0.04fF
C775 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z3 0.16fF
C776 divbuf_2/IN divbuf_2/a_492_n240# 0.13fF
C777 divbuf_5/OUT ro_complete_0/cbank_1/v 0.05fF
C778 ro_complete_0/cbank_0/switch_4/vin divbuf_7/OUT 0.13fF
C779 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/UP 0.33fF
C780 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C781 divider_0/nor_0/A divider_0/tspc_2/Z2 0.23fF
C782 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C783 pll_full_0/ro_complete_0/a5 pll_full_0/divider_0/clk 0.15fF
C784 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z4 0.12fF
C785 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z2 1.07fF
C786 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z2 0.01fF
C787 divbuf_7/OUT3 divbuf_7/OUT5 0.01fF
C788 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/out1 0.31fF
C789 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/clk 0.26fF
C790 pd_1/R pd_1/REF 0.61fF
C791 pd_0/R pd_0/UP 0.45fF
C792 pd_0/tspc_r_1/Z4 pd_0/tspc_r_1/z5 0.04fF
C793 divider_2/nor_0/Z1 divider_2/and_0/B 0.18fF
C794 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Out1 0.12fF
C795 divider_0/tspc_2/Q divider_0/tspc_1/Z4 0.15fF
C796 divider_0/tspc_0/Z4 divider_0/nor_1/B 0.22fF
C797 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z4 0.12fF
C798 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z2 1.07fF
C799 divbuf_1/OUT5 divbuf_1/OUT4 20.26fF
C800 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/v 1.43fF
C801 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/IN 0.00fF
C802 pll_full_0/ro_complete_0/a1 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C803 divider_2/Out divider_2/tspc_0/a_630_n680# 0.04fF
C804 divider_0/and_0/out1 divider_0/and_0/Z1 0.36fF
C805 divbuf_10/a_492_n240# divbuf_10/OUT5 0.01fF
C806 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_1/Z3 0.05fF
C807 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z4 0.00fF
C808 pll_full_0/divbuf_0/IN pll_full_0/divider_0/nor_1/B 0.27fF
C809 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z2 0.01fF
C810 divider_1/tspc_2/Q divider_1/tspc_1/Z3 0.45fF
C811 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z4 0.08fF
C812 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z3 0.05fF
C813 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Q 0.04fF
C814 divider_2/tspc_2/Q divider_2/nor_0/B 0.22fF
C815 pd_1/REF pd_1/tspc_r_1/Z3 0.65fF
C816 pd_0/and_pd_0/Out1 pd_0/UP 0.33fF
C817 divbuf_9/OUT2 divbuf_9/OUT5 0.02fF
C818 divbuf_9/OUT3 divbuf_9/OUT4 5.16fF
C819 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C820 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C821 divbuf_25/a_492_n240# divbuf_25/OUT2 0.42fF
C822 divider_0/tspc_2/Q divider_0/tspc_2/Z3 0.05fF
C823 divider_0/prescaler_0/tspc_1/Z2 divider_0/clk 0.11fF
C824 divbuf_3/OUT divbuf_3/a_492_n240# 0.00fF
C825 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/switch_5/vin 0.20fF
C826 pll_full_0/pd_0/DIV pll_full_0/divider_0/clk 2.26fF
C827 divbuf_7/OUT divbuf_7/OUT2 0.06fF
C828 pll_full_0/filter_0/a_4216_n5230# pll_full_0/divider_0/clk 1.58fF
C829 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/a_630_n680# 0.19fF
C830 divbuf_20/OUT3 divbuf_20/OUT 0.26fF
C831 divbuf_20/OUT4 divbuf_20/OUT5 20.26fF
C832 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z4 0.36fF
C833 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C834 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/clk 0.64fF
C835 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/D 0.05fF
C836 pd_0/tspc_r_0/Z2 pd_0/tspc_r_0/Z4 0.14fF
C837 io_clamp_low[0] io_clamp_high[0] 0.53fF
C838 divbuf_4/OUT ro_complete_0/cbank_2/switch_1/vin 0.09fF
C839 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/v 1.30fF
C840 divider_0/tspc_0/Z2 divider_0/tspc_0/Z4 0.36fF
C841 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C842 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z3 0.11fF
C843 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/switch_5/vin 0.20fF
C844 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/a0 0.13fF
C845 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C846 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C847 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/divider_0/clk 1.46fF
C848 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z2 0.16fF
C849 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z1 0.08fF
C850 pll_full_0/divider_0/tspc_1/Z4 pll_full_0/divider_0/nor_0/A 0.02fF
C851 divider_2/tspc_2/Q divider_2/tspc_1/a_630_n680# 0.01fF
C852 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z4 0.14fF
C853 pd_0/R pd_0/and_pd_0/Out1 0.33fF
C854 pd_0/REF pd_0/tspc_r_1/Z4 0.02fF
C855 divider_2/mc2 divider_2/nor_0/A 0.04fF
C856 divider_2/nor_0/B divider_2/tspc_1/Z2 0.30fF
C857 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z2 0.01fF
C858 divbuf_12/OUT2 divbuf_12/OUT 0.06fF
C859 divbuf_12/OUT3 divbuf_12/OUT5 0.01fF
C860 divider_2/and_0/out1 divider_2/and_0/B 0.18fF
C861 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C862 divider_0/mc2 divider_0/nor_0/A 0.04fF
C863 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C864 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/v 1.30fF
C865 filter_0/v divbuf_25/OUT4 1.11fF
C866 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_0/Z4 0.02fF
C867 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C868 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/divider_0/clk 1.27fF
C869 divbuf_17/OUT2 divbuf_17/OUT3 1.37fF
C870 divider_1/nor_0/B divider_1/tspc_1/Z4 0.21fF
C871 divider_1/tspc_0/Z3 divider_1/nor_1/B 0.38fF
C872 divbuf_11/a_492_n240# divbuf_11/OUT5 0.01fF
C873 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z4 0.12fF
C874 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z2 1.07fF
C875 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z3 0.38fF
C876 divider_1/nor_0/A divider_1/and_0/B 0.08fF
C877 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z1 0.09fF
C878 divbuf_19/OUT divbuf_19/OUT4 1.11fF
C879 divider_2/and_0/OUT divider_2/prescaler_0/nand_0/z1 0.01fF
C880 divider_2/nor_0/B divider_2/nor_0/A 1.21fF
C881 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z2 0.21fF
C882 divbuf_15/OUT5 divbuf_15/IN 0.00fF
C883 divbuf_25/OUT3 divbuf_25/OUT4 5.16fF
C884 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a4 0.12fF
C885 ro_complete_0/cbank_1/switch_5/vin ro_complete_0/cbank_1/v 1.30fF
C886 divider_0/tspc_1/Z3 divider_0/tspc_1/Z4 0.65fF
C887 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Q 0.04fF
C888 divider_0/prescaler_0/Out divider_0/clk 0.51fF
C889 ro_complete_1/a0 ro_complete_1/cbank_2/switch_5/vin 0.09fF
C890 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C891 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z4 0.12fF
C892 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C893 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Q 0.20fF
C894 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/D 0.09fF
C895 divider_1/prescaler_0/tspc_0/Z2 divider_1/clk 0.11fF
C896 divbuf_22/OUT3 divbuf_22/OUT 0.26fF
C897 divbuf_22/OUT4 divbuf_22/OUT5 20.26fF
C898 pd_0/DIV pd_0/tspc_r_0/Z1 0.17fF
C899 pd_0/tspc_r_0/Qbar1 pd_0/DOWN 0.11fF
C900 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z2 0.01fF
C901 divider_2/tspc_2/Q divider_2/tspc_1/Z3 0.45fF
C902 divider_2/tspc_0/Z2 divider_2/tspc_0/a_630_n680# 0.01fF
C903 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/z5 0.20fF
C904 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z4 0.20fF
C905 divider_2/and_0/OUT divider_2/clk 0.04fF
C906 divbuf_5/OUT divbuf_3/OUT 3.09fF
C907 divbuf_4/OUT ro_complete_0/cbank_1/switch_1/vin 0.09fF
C908 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z3 0.05fF
C909 divbuf_5/OUT divbuf_5/OUT5 43.38fF
C910 divbuf_1/OUT divbuf_1/a_492_n240# 0.00fF
C911 divbuf_14/OUT divbuf_14/OUT5 43.38fF
C912 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/nand_1/z1 0.01fF
C913 divider_0/prescaler_0/tspc_2/Z2 divider_0/clk 0.11fF
C914 pll_full_0/divbuf_1/OUT4 pll_full_0/divbuf_1/OUT 1.11fF
C915 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C916 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C917 divider_1/tspc_0/a_630_n680# divider_1/tspc_1/Q 0.01fF
C918 divider_1/tspc_0/Z2 divider_1/tspc_0/Z3 0.16fF
C919 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z4 0.36fF
C920 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/Out 0.05fF
C921 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/Out 0.21fF
C922 divbuf_21/a_492_n240# divbuf_21/OUT 0.00fF
C923 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C924 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/clk 0.45fF
C925 divider_2/prescaler_0/Out divider_2/tspc_2/Z2 0.11fF
C926 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/nand_1/z1 0.22fF
C927 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/tspc_0/D 0.04fF
C928 pd_0/R pd_0/tspc_r_1/Z2 0.21fF
C929 divider_2/nor_0/B divider_2/tspc_1/Z1 0.03fF
C930 divbuf_24/OUT2 divbuf_24/OUT 0.06fF
C931 divbuf_24/OUT3 divbuf_24/OUT5 0.01fF
C932 divider_2/nor_0/A divider_2/and_0/A 0.01fF
C933 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C934 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z4 0.36fF
C935 ro_complete_1/a4 ro_complete_1/cbank_1/v 0.05fF
C936 divider_0/tspc_2/Z1 divider_0/tspc_2/Z3 0.06fF
C937 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C938 divider_1/tspc_1/Q divider_1/tspc_1/a_630_n680# 0.04fF
C939 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z3 0.16fF
C940 divbuf_6/a_492_n240# divbuf_6/IN 0.13fF
C941 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/nor_1/B 0.03fF
C942 divider_1/nor_0/A divider_1/tspc_2/Z2 0.23fF
C943 divbuf_23/a_492_n240# divbuf_23/OUT5 0.01fF
C944 pd_1/R pd_1/tspc_r_1/Qbar1 0.30fF
C945 pd_1/DOWN pd_1/tspc_r_0/z5 0.03fF
C946 pd_1/tspc_r_0/Z1 pd_1/tspc_r_0/Z3 0.09fF
C947 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z2 0.19fF
C948 divbuf_19/OUT divbuf_19/a_492_n240# 0.00fF
C949 divider_2/prescaler_0/m1_2700_2190# divider_2/nor_0/A 0.01fF
C950 divider_2/tspc_1/Z2 divider_2/tspc_1/Z3 0.16fF
C951 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/D 0.15fF
C952 divider_2/mc2 divider_2/and_0/B 0.20fF
C953 divbuf_15/OUT5 divbuf_15/OUT2 0.02fF
C954 divbuf_15/OUT4 divbuf_15/OUT3 5.16fF
C955 divbuf_2/OUT ro_complete_0/cbank_2/v 0.08fF
C956 divbuf_7/OUT ro_complete_0/cbank_1/switch_5/vin 0.09fF
C957 pll_full_0/pd_0/DIV pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C958 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT3 1.37fF
C959 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C960 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z3 0.16fF
C961 divider_0/mc2 divider_0/and_0/B 0.20fF
C962 divbuf_3/OUT3 divbuf_3/OUT5 0.01fF
C963 divider_1/tspc_2/Q divider_1/tspc_1/Z4 0.15fF
C964 divider_1/tspc_0/Z4 divider_1/nor_1/B 0.22fF
C965 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z4 0.12fF
C966 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z2 1.07fF
C967 divbuf_10/OUT2 divbuf_10/OUT3 1.37fF
C968 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C969 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/and_0/OUT 0.14fF
C970 divider_1/and_0/out1 divider_1/and_0/Z1 0.36fF
C971 divbuf_9/OUT3 divbuf_9/OUT 0.26fF
C972 divbuf_9/OUT4 divbuf_9/OUT5 20.26fF
C973 cp_0/a_10_n50# cp_0/vbias 0.19fF
C974 cp_0/a_1710_n2840# cp_0/out 0.61fF
C975 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Qbar1 0.38fF
C976 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C977 divider_2/nor_0/B divider_2/and_0/B 0.31fF
C978 io_analog[6] io_clamp_low[2] 0.53fF
C979 divider_0/nor_1/Z1 divider_0/nor_0/B 0.18fF
C980 divbuf_0/OUT4 divbuf_0/OUT5 20.26fF
C981 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C982 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/z5 0.11fF
C983 divbuf_4/OUT divbuf_4/a_492_n240# 0.00fF
C984 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/v 1.30fF
C985 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C986 divbuf_7/OUT divbuf_7/OUT4 1.11fF
C987 divbuf_4/IN divbuf_4/OUT5 0.00fF
C988 ro_complete_1/cbank_1/v ro_complete_1/cbank_2/v 1.36fF
C989 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/D 0.11fF
C990 divider_1/tspc_2/Q divider_1/tspc_2/Z3 0.05fF
C991 divider_1/prescaler_0/tspc_1/Z2 divider_1/clk 0.11fF
C992 divbuf_20/OUT5 divbuf_20/OUT 43.38fF
C993 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C994 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/clk 0.12fF
C995 divbuf_8/a_492_n240# divbuf_8/OUT 0.00fF
C996 divider_2/tspc_0/Z2 divider_2/tspc_1/Q 0.14fF
C997 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z3 0.06fF
C998 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z3 0.05fF
C999 divider_2/nor_0/A divider_2/tspc_2/Z1 0.03fF
C1000 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z4 0.12fF
C1001 divider_0/tspc_1/Q divider_0/tspc_0/Z3 0.45fF
C1002 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z4 0.28fF
C1003 divbuf_2/OUT2 divbuf_2/OUT3 1.37fF
C1004 ro_complete_1/a5 ro_complete_1/cbank_1/switch_0/vin 0.09fF
C1005 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/v 1.30fF
C1006 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C1007 divider_0/and_0/OUT divider_0/and_0/B 0.01fF
C1008 divbuf_5/IN divbuf_5/OUT5 0.00fF
C1009 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/Z2 0.36fF
C1010 divider_1/tspc_0/Z2 divider_1/tspc_0/Z4 0.36fF
C1011 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1012 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z3 0.11fF
C1013 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divbuf_0/IN 0.04fF
C1014 divbuf_7/a_492_n240# divbuf_7/IN 0.13fF
C1015 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/clk 0.45fF
C1016 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/z5 0.11fF
C1017 divbuf_12/OUT4 divbuf_12/OUT 1.11fF
C1018 divider_2/tspc_1/Z1 divider_2/tspc_1/Z3 0.06fF
C1019 divider_2/and_0/A divider_2/and_0/B 0.18fF
C1020 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Q 0.91fF
C1021 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1022 ro_complete_1/a2 ro_complete_1/cbank_0/switch_3/vin 0.09fF
C1023 ro_complete_1/cbank_1/switch_2/vin ro_complete_1/cbank_1/v 1.30fF
C1024 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/v 0.08fF
C1025 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C1026 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C1027 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1028 divbuf_11/OUT2 divbuf_11/OUT3 1.37fF
C1029 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z3 0.16fF
C1030 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z4 0.21fF
C1031 divider_2/prescaler_0/tspc_2/D divider_2/prescaler_0/nand_0/z1 0.24fF
C1032 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z3 0.65fF
C1033 divbuf_2/OUT5 divbuf_2/a_492_n240# 0.01fF
C1034 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/v 1.30fF
C1035 ro_complete_0/cbank_0/v ro_complete_0/cbank_2/v 0.04fF
C1036 pll_full_0/divbuf_0/OUT4 pll_full_0/divbuf_0/OUT5 20.26fF
C1037 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1038 ro_complete_1/a0 ro_complete_1/cbank_2/v 0.05fF
C1039 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/IN 0.13fF
C1040 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1041 filter_0/v divbuf_25/a_492_n240# 0.00fF
C1042 divbuf_20/a_492_n240# divbuf_20/OUT2 0.42fF
C1043 divider_1/tspc_1/Z3 divider_1/tspc_1/Z4 0.65fF
C1044 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Q 0.04fF
C1045 divider_1/prescaler_0/Out divider_1/clk 0.51fF
C1046 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C1047 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1048 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1049 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z2 0.25fF
C1050 divider_2/tspc_2/Q divider_2/tspc_1/Z4 0.15fF
C1051 divbuf_22/OUT5 divbuf_22/OUT 43.38fF
C1052 pll_full_0/divider_0/and_0/B pll_full_0/divider_0/and_0/Z1 0.07fF
C1053 pd_1/DOWN pd_1/UP 0.46fF
C1054 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/z5 0.20fF
C1055 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/Qbar 0.21fF
C1056 divider_2/and_0/OUT divider_2/and_0/out1 0.31fF
C1057 divider_2/prescaler_0/tspc_2/D divider_2/clk 0.26fF
C1058 divbuf_13/a_492_n240# divbuf_13/OUT 0.00fF
C1059 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1060 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1061 divbuf_14/a_492_n240# divbuf_14/OUT5 0.01fF
C1062 divider_0/prescaler_0/tspc_0/D divider_0/prescaler_0/nand_1/z1 0.21fF
C1063 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/nor_0/B 0.20fF
C1064 divider_1/tspc_0/a_630_n680# divider_1/tspc_0/Z3 0.05fF
C1065 divbuf_21/IN divbuf_21/OUT5 0.00fF
C1066 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/nand_1/z1 0.01fF
C1067 divider_1/prescaler_0/tspc_2/Z2 divider_1/clk 0.11fF
C1068 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/clk 0.12fF
C1069 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z1 0.71fF
C1070 pd_0/REF pd_0/tspc_r_1/Z3 0.65fF
C1071 divider_2/tspc_2/Q divider_2/tspc_2/Z3 0.05fF
C1072 divider_2/nor_0/B divider_2/tspc_1/Q 0.51fF
C1073 divbuf_12/a_492_n240# divbuf_12/IN 0.13fF
C1074 divbuf_24/OUT4 divbuf_24/OUT 1.11fF
C1075 divider_0/tspc_1/Q divider_0/tspc_0/Z4 0.15fF
C1076 divider_0/tspc_2/Z1 divider_0/tspc_2/Z4 0.00fF
C1077 divbuf_3/OUT2 divbuf_3/a_492_n240# 0.42fF
C1078 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z4 0.36fF
C1079 divider_1/tspc_2/Z1 divider_1/tspc_2/Z3 0.06fF
C1080 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/clk 0.60fF
C1081 divider_2/tspc_1/Z2 divider_2/tspc_1/Z4 0.36fF
C1082 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/D 0.05fF
C1083 divbuf_23/OUT2 divbuf_23/OUT3 1.37fF
C1084 divbuf_15/OUT divbuf_15/OUT3 0.26fF
C1085 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z4 0.36fF
C1086 divbuf_2/OUT3 divbuf_2/OUT4 5.16fF
C1087 divbuf_7/OUT ro_complete_0/cbank_1/v 0.05fF
C1088 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT4 5.16fF
C1089 ro_complete_1/a3 ro_complete_1/cbank_2/v 0.05fF
C1090 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_0/B 0.06fF
C1091 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/ro_complete_0/cbank_2/v 0.04fF
C1092 divbuf_10/OUT2 divbuf_10/OUT5 0.02fF
C1093 divbuf_10/OUT3 divbuf_10/OUT4 5.16fF
C1094 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1095 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C1096 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C1097 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C1098 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z3 0.16fF
C1099 divbuf_22/a_492_n240# divbuf_22/OUT2 0.42fF
C1100 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Q 0.04fF
C1101 pd_1/DOWN pd_1/and_pd_0/Out1 0.12fF
C1102 pd_1/REF pd_1/tspc_r_1/Z1 0.17fF
C1103 divider_2/tspc_1/Z4 divider_2/nor_0/A 0.02fF
C1104 divbuf_9/OUT5 divbuf_9/OUT 43.38fF
C1105 divbuf_0/OUT4 divbuf_0/OUT 1.11fF
C1106 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/Out 0.21fF
C1107 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z2 0.01fF
C1108 divbuf_3/OUT divbuf_3/OUT4 1.11fF
C1109 ro_complete_1/a4 ro_complete_1/cbank_1/switch_1/vin 0.09fF
C1110 ro_complete_0/cbank_2/switch_0/vin ro_complete_0/cbank_2/v 1.45fF
C1111 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1112 divider_1/nor_1/Z1 divider_1/nor_0/B 0.18fF
C1113 divbuf_4/OUT3 divbuf_4/OUT5 0.01fF
C1114 divbuf_8/IN divbuf_8/OUT5 0.00fF
C1115 divider_2/mc2 divider_2/and_0/OUT 0.05fF
C1116 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z4 0.00fF
C1117 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/D 0.03fF
C1118 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Z1 0.02fF
C1119 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z4 0.12fF
C1120 divider_2/tspc_2/Z1 divider_2/tspc_2/Z2 1.07fF
C1121 divider_2/nor_0/A divider_2/tspc_2/Z3 0.38fF
C1122 divbuf_24/a_492_n240# divbuf_24/IN 0.13fF
C1123 divbuf_4/OUT ro_complete_0/cbank_1/switch_0/vin 0.12fF
C1124 divbuf_2/OUT2 divbuf_2/OUT5 0.02fF
C1125 divbuf_1/OUT2 divbuf_1/OUT 0.06fF
C1126 divbuf_5/OUT ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1127 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/v 1.30fF
C1128 divider_0/mc2 divider_0/and_0/OUT 0.05fF
C1129 divider_0/tspc_0/Z1 divider_0/nor_1/B 0.03fF
C1130 ro_complete_1/a3 ro_complete_1/cbank_1/switch_2/vin 0.09fF
C1131 divider_1/tspc_0/a_630_n680# divider_1/tspc_0/Z4 0.12fF
C1132 divider_1/tspc_1/Q divider_1/tspc_0/Z3 0.45fF
C1133 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z4 0.28fF
C1134 divbuf_5/OUT3 divbuf_5/OUT5 0.01fF
C1135 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/clk 0.12fF
C1136 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/Z2 1.07fF
C1137 divider_1/and_0/OUT divider_1/and_0/B 0.01fF
C1138 divider_2/tspc_1/Q divider_2/tspc_1/Z3 0.05fF
C1139 divider_2/tspc_1/Z1 divider_2/tspc_1/Z4 0.00fF
C1140 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z3 0.06fF
C1141 ro_complete_1/a2 ro_complete_1/cbank_2/switch_3/vin 0.09fF
C1142 divbuf_0/OUT5 divbuf_0/OUT2 0.02fF
C1143 divbuf_3/OUT ro_complete_0/cbank_1/v 0.05fF
C1144 divbuf_15/OUT divbuf_15/a_492_n240# 0.00fF
C1145 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/D 0.09fF
C1146 divbuf_1/OUT4 divbuf_1/OUT3 5.16fF
C1147 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/switch_5/vin 0.20fF
C1148 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z1 0.08fF
C1149 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Q 0.91fF
C1150 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1151 divbuf_11/OUT2 divbuf_11/OUT5 0.02fF
C1152 divbuf_11/OUT3 divbuf_11/OUT4 5.16fF
C1153 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z4 0.36fF
C1154 divbuf_19/OUT2 divbuf_19/OUT3 1.37fF
C1155 divbuf_9/a_492_n240# divbuf_9/OUT2 0.42fF
C1156 divbuf_18/OUT4 divbuf_18/OUT 1.11fF
C1157 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/Q 0.04fF
C1158 divider_2/prescaler_0/tspc_1/Z3 divider_2/clk 0.45fF
C1159 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Qbar1 0.38fF
C1160 divider_0/tspc_0/Z1 divider_0/tspc_0/Z2 1.07fF
C1161 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a5 0.09fF
C1162 divbuf_14/IN divbuf_14/OUT5 0.00fF
C1163 pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_0/ro_complete_0/cbank_2/v 1.45fF
C1164 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/nor_0/A 0.15fF
C1165 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1166 pll_full_0/ro_complete_0/cbank_2/v pll_full_0/divider_0/clk 1.36fF
C1167 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/Qbar 0.01fF
C1168 pd_0/tspc_r_0/Z3 pd_0/R 0.27fF
C1169 divbuf_13/IN divbuf_13/OUT5 0.00fF
C1170 pd_1/tspc_r_1/Z2 pd_1/tspc_r_1/Z4 0.14fF
C1171 divbuf_5/OUT divbuf_6/OUT 3.23fF
C1172 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C1173 divider_0/prescaler_0/Out divider_0/prescaler_0/m1_2700_2190# 0.11fF
C1174 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C1175 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/v 1.30fF
C1176 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1177 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1178 divider_1/mc2 divider_1/nor_1/B 0.15fF
C1179 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C1180 divbuf_5/a_492_n240# divbuf_5/OUT2 0.42fF
C1181 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_1/Q 0.01fF
C1182 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C1183 divider_1/prescaler_0/tspc_0/D divider_1/prescaler_0/nand_1/z1 0.21fF
C1184 divbuf_21/OUT2 divbuf_21/OUT 0.06fF
C1185 divbuf_21/OUT3 divbuf_21/OUT5 0.01fF
C1186 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Qbar1 0.38fF
C1187 divider_2/prescaler_0/m1_2700_2190# divider_2/and_0/OUT 0.14fF
C1188 divbuf_2/OUT divbuf_2/OUT3 0.26fF
C1189 divider_0/nor_0/B divider_0/nor_1/B 0.47fF
C1190 divider_0/tspc_0/Z3 divider_0/tspc_0/Z4 0.65fF
C1191 divbuf_6/OUT divbuf_6/OUT3 0.26fF
C1192 ro_complete_1/a5 ro_complete_1/cbank_1/v 0.10fF
C1193 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/cbank_0/v 1.30fF
C1194 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/OUT2 0.02fF
C1195 divbuf_14/OUT5 divbuf_14/OUT4 20.26fF
C1196 divider_0/tspc_2/Z3 divider_0/tspc_2/Z4 0.65fF
C1197 divider_1/tspc_1/Q divider_1/tspc_0/Z4 0.15fF
C1198 divbuf_6/a_492_n240# divbuf_6/OUT5 0.01fF
C1199 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divbuf_0/IN 0.05fF
C1200 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C1201 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/A 0.80fF
C1202 pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_0/divider_0/clk 1.46fF
C1203 divbuf_19/IN divbuf_19/a_492_n240# 0.13fF
C1204 divider_1/tspc_2/Z1 divider_1/tspc_2/Z4 0.00fF
C1205 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/Z1 0.04fF
C1206 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/clk 0.05fF
C1207 pd_1/tspc_r_0/Qbar1 pd_1/tspc_r_0/Z3 0.38fF
C1208 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/z5 0.04fF
C1209 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Z1 0.02fF
C1210 divbuf_23/OUT2 divbuf_23/OUT5 0.02fF
C1211 divbuf_23/OUT3 divbuf_23/OUT4 5.16fF
C1212 divider_2/prescaler_0/tspc_2/Z4 divider_2/prescaler_0/tspc_2/D 0.11fF
C1213 divbuf_2/OUT4 divbuf_2/OUT5 20.26fF
C1214 divbuf_14/OUT2 divbuf_14/OUT5 0.02fF
C1215 divider_0/nor_0/B divider_0/tspc_2/a_630_n680# 0.01fF
C1216 divider_1/nor_0/Z1 divider_1/nor_0/B 0.06fF
C1217 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z4 0.36fF
C1218 divbuf_10/OUT3 divbuf_10/OUT 0.26fF
C1219 divbuf_10/OUT4 divbuf_10/OUT5 20.26fF
C1220 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C1221 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C1222 pd_1/REF pd_1/tspc_r_1/Z2 0.19fF
C1223 divider_2/prescaler_0/tspc_2/Z3 divider_2/clk 0.45fF
C1224 io_analog[5] io_clamp_high[1] 0.53fF
C1225 divider_0/tspc_0/Z2 divider_0/nor_0/B 0.20fF
C1226 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/Out 0.04fF
C1227 divbuf_0/OUT5 divbuf_0/OUT 43.38fF
C1228 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1229 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/tspc_r_1/Z4 0.14fF
C1230 divbuf_4/OUT divbuf_4/OUT2 0.06fF
C1231 ro_complete_1/a2 ro_complete_1/cbank_1/v 0.05fF
C1232 pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1233 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/Out 0.21fF
C1234 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z2 0.01fF
C1235 divider_2/nor_1/Z1 divider_2/nor_1/B 0.06fF
C1236 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C1237 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/clk 0.01fF
C1238 divbuf_18/OUT3 divbuf_18/OUT4 5.16fF
C1239 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Z4 0.65fF
C1240 divbuf_8/OUT2 divbuf_8/OUT 0.06fF
C1241 divbuf_8/OUT3 divbuf_8/OUT5 0.01fF
C1242 pd_1/tspc_r_1/Qbar1 pd_1/UP 0.11fF
C1243 divider_2/tspc_2/Z2 divider_2/tspc_2/Z3 0.16fF
C1244 divider_2/nor_0/A divider_2/tspc_2/Z4 0.21fF
C1245 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1246 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_5/vin 0.20fF
C1247 ro_complete_1/a3 ro_complete_1/cbank_2/switch_1/vin 0.13fF
C1248 divider_1/tspc_0/Z1 divider_1/nor_1/B 0.03fF
C1249 divbuf_7/a_492_n240# divbuf_7/OUT5 0.01fF
C1250 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z3 0.25fF
C1251 pd_0/DOWN pd_0/UP 0.46fF
C1252 pd_0/tspc_r_1/Z2 pd_0/tspc_r_1/Z4 0.14fF
C1253 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z4 0.00fF
C1254 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Q 0.21fF
C1255 divbuf_19/OUT3 divbuf_19/OUT4 5.16fF
C1256 divider_2/and_0/B divider_2/and_0/Z1 0.07fF
C1257 ro_complete_1/a2 ro_complete_1/cbank_0/switch_2/vin 0.14fF
C1258 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/a4 0.09fF
C1259 divbuf_0/OUT divbuf_0/OUT2 0.06fF
C1260 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_0/vin 0.19fF
C1261 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/v 1.30fF
C1262 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/v 1.30fF
C1263 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C1264 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z3 0.11fF
C1265 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/D 0.09fF
C1266 divbuf_11/OUT3 divbuf_11/OUT 0.26fF
C1267 divbuf_11/OUT4 divbuf_11/OUT5 20.26fF
C1268 divider_2/prescaler_0/tspc_1/Z4 divider_2/clk 0.12fF
C1269 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C1270 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z1 0.17fF
C1271 divider_0/tspc_2/Q divider_0/tspc_2/a_630_n680# 0.04fF
C1272 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/D 0.03fF
C1273 divbuf_1/OUT5 divbuf_1/IN 0.00fF
C1274 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1275 divbuf_4/a_492_n240# divbuf_4/IN 0.13fF
C1276 ro_complete_1/cbank_2/switch_2/vin ro_complete_1/cbank_2/v 1.30fF
C1277 divider_1/tspc_0/Z1 divider_1/tspc_0/Z2 1.07fF
C1278 divbuf_20/a_492_n240# divbuf_20/OUT 0.00fF
C1279 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z2 0.11fF
C1280 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C1281 divbuf_16/OUT2 divbuf_16/OUT 0.06fF
C1282 pd_0/DOWN pd_0/R 0.36fF
C1283 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z4 0.20fF
C1284 pd_0/DIV pd_0/tspc_r_0/z5 0.04fF
C1285 pd_0/tspc_r_0/Z1 pd_0/tspc_r_0/Z2 0.71fF
C1286 divider_2/prescaler_0/tspc_0/Z2 divider_2/and_0/OUT 0.06fF
C1287 divider_2/prescaler_0/tspc_1/Q divider_2/clk 0.60fF
C1288 divbuf_13/OUT2 divbuf_13/OUT 0.06fF
C1289 divbuf_13/OUT3 divbuf_13/OUT5 0.01fF
C1290 divbuf_0/OUT5 divbuf_0/a_492_n240# 0.01fF
C1291 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_4/vin 0.20fF
C1292 divider_0/nor_0/B divider_0/tspc_1/Z1 0.03fF
C1293 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/UP 0.03fF
C1294 divider_0/prescaler_0/tspc_1/Q divider_0/nor_0/A 0.03fF
C1295 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C1296 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z3 0.06fF
C1297 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C1298 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1299 divider_1/prescaler_0/Out divider_1/prescaler_0/m1_2700_2190# 0.11fF
C1300 divbuf_21/OUT4 divbuf_21/OUT 1.11fF
C1301 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C1302 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/clk 0.01fF
C1303 divider_2/prescaler_0/Out divider_2/clk 0.51fF
C1304 divbuf_12/a_492_n240# divbuf_12/OUT5 0.01fF
C1305 pd_0/tspc_r_0/Z4 pd_0/tspc_r_1/Z4 0.02fF
C1306 pd_0/DOWN pd_0/and_pd_0/Out1 0.12fF
C1307 pd_0/REF pd_0/tspc_r_1/Z1 0.17fF
C1308 divider_2/nor_1/B divider_2/tspc_0/Z1 0.03fF
C1309 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_2/D 0.16fF
C1310 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/clk 0.01fF
C1311 divbuf_2/OUT divbuf_2/OUT5 43.38fF
C1312 divbuf_4/OUT ro_complete_0/cbank_1/v 0.05fF
C1313 divider_0/nor_0/B divider_0/tspc_1/Z2 0.30fF
C1314 divider_1/mc2 divider_1/nor_0/A 0.04fF
C1315 divbuf_14/OUT5 divbuf_14/OUT3 0.01fF
C1316 divbuf_6/OUT divbuf_6/OUT5 43.38fF
C1317 divbuf_3/IN divbuf_3/OUT5 0.00fF
C1318 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C1319 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1320 divbuf_6/OUT2 divbuf_6/OUT3 1.37fF
C1321 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Q 0.22fF
C1322 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/nor_1/B 0.35fF
C1323 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C1324 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C1325 divider_1/nor_0/B divider_1/nor_1/B 0.47fF
C1326 divider_1/tspc_0/Z3 divider_1/tspc_0/Z4 0.65fF
C1327 divider_1/nor_0/Z1 divider_1/and_0/A 0.80fF
C1328 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/nor_0/A 0.35fF
C1329 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/clk 0.29fF
C1330 divbuf_16/OUT divbuf_16/OUT5 43.38fF
C1331 divider_1/tspc_2/Z3 divider_1/tspc_2/Z4 0.65fF
C1332 divbuf_23/OUT3 divbuf_23/OUT 0.26fF
C1333 divbuf_23/OUT4 divbuf_23/OUT5 20.26fF
C1334 cp_0/a_1710_0# cp_0/out 0.84fF
C1335 pd_1/R pd_1/tspc_r_1/Qbar 0.03fF
C1336 pd_0/tspc_r_1/Z3 pd_0/UP 0.03fF
C1337 divbuf_18/OUT5 divbuf_18/OUT4 20.26fF
C1338 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z3 0.29fF
C1339 divbuf_0/a_492_n240# divbuf_0/OUT2 0.42fF
C1340 divbuf_25/OUT4 divbuf_25/OUT5 20.26fF
C1341 divider_0/prescaler_0/Out divider_0/tspc_2/Z3 0.45fF
C1342 divider_0/nor_0/B divider_0/nor_0/A 1.21fF
C1343 divider_2/tspc_0/Z4 divider_2/nor_1/B 0.22fF
C1344 ro_complete_1/a1 ro_complete_1/cbank_2/v 0.05fF
C1345 divbuf_10/OUT5 divbuf_10/OUT 43.38fF
C1346 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_1/B 0.00fF
C1347 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C1348 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1349 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C1350 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C1351 divbuf_16/OUT3 divbuf_16/OUT 0.26fF
C1352 divider_1/nor_0/B divider_1/tspc_2/a_630_n680# 0.01fF
C1353 divbuf_22/a_492_n240# divbuf_22/OUT 0.00fF
C1354 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/A 0.01fF
C1355 divider_2/prescaler_0/tspc_2/Z4 divider_2/clk 0.12fF
C1356 io_analog[4] io_clamp_low[0] 0.53fF
C1357 divbuf_0/OUT4 divbuf_0/OUT3 5.16fF
C1358 divider_0/tspc_0/Z1 divider_0/tspc_1/Q 0.01fF
C1359 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z3 0.06fF
C1360 divbuf_4/OUT divbuf_4/OUT4 1.11fF
C1361 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT 0.00fF
C1362 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/a_492_n240# 0.01fF
C1363 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C1364 divider_1/tspc_0/Z2 divider_1/nor_0/B 0.20fF
C1365 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/Out 0.04fF
C1366 divbuf_21/a_492_n240# divbuf_21/IN 0.13fF
C1367 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C1368 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/A 0.26fF
C1369 divbuf_8/OUT4 divbuf_8/OUT 1.11fF
C1370 pd_0/R pd_0/tspc_r_1/Z3 0.29fF
C1371 divbuf_24/a_492_n240# divbuf_24/OUT5 0.01fF
C1372 divider_2/tspc_2/Z2 divider_2/tspc_2/Z4 0.36fF
C1373 divbuf_2/OUT ro_complete_0/cbank_1/switch_0/vin 0.09fF
C1374 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/v 1.30fF
C1375 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/IN 5.26fF
C1376 divider_0/tspc_1/Z1 divider_0/tspc_2/Q 0.01fF
C1377 divider_0/nor_0/B divider_0/tspc_1/a_630_n680# 0.35fF
C1378 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/clk 0.14fF
C1379 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C1380 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z4 0.00fF
C1381 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/divider_0/clk 1.46fF
C1382 filter_0/v divbuf_25/OUT2 0.06fF
C1383 divbuf_7/OUT2 divbuf_7/OUT3 1.37fF
C1384 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/B 0.29fF
C1385 pd_1/R pd_1/tspc_r_0/Z3 0.27fF
C1386 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Z4 0.65fF
C1387 divbuf_15/OUT4 divbuf_15/OUT5 20.26fF
C1388 divbuf_6/OUT ro_complete_0/cbank_1/v 0.05fF
C1389 divbuf_25/OUT3 divbuf_25/OUT2 1.37fF
C1390 divider_0/nor_0/Z1 divider_0/and_0/B 0.18fF
C1391 divider_0/tspc_2/Q divider_0/tspc_1/Z2 0.14fF
C1392 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z2 0.01fF
C1393 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/cbank_1/v 1.43fF
C1394 divider_1/mc2 divider_1/and_0/B 0.20fF
C1395 divider_0/and_0/out1 divider_0/and_0/B 0.18fF
C1396 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/OUT2 0.42fF
C1397 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z4 0.28fF
C1398 divbuf_10/a_492_n240# divbuf_10/OUT2 0.42fF
C1399 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z2 1.07fF
C1400 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z3 0.38fF
C1401 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_1/B 0.22fF
C1402 divbuf_11/OUT5 divbuf_11/OUT 43.38fF
C1403 divbuf_9/a_492_n240# divbuf_9/OUT 0.00fF
C1404 pd_1/R pd_1/and_pd_0/Z1 0.02fF
C1405 divbuf_5/OUT ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1406 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/tspc_r_1/z5 0.02fF
C1407 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z2 0.25fF
C1408 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C1409 pll_full_0/divbuf_0/OUT4 pll_full_0/divbuf_0/OUT3 5.16fF
C1410 divbuf_14/OUT divbuf_14/a_492_n240# 0.00fF
C1411 divider_0/nor_0/B divider_0/and_0/B 0.31fF
C1412 divider_0/tspc_2/Q divider_0/nor_0/A 0.55fF
C1413 divider_0/and_0/OUT divider_0/prescaler_0/nand_0/z1 0.01fF
C1414 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/switch_5/vin 0.20fF
C1415 divider_2/tspc_0/Z4 divider_2/tspc_0/Z1 0.00fF
C1416 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Q 0.91fF
C1417 divider_1/tspc_2/Q divider_1/tspc_2/a_630_n680# 0.04fF
C1418 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/D 0.03fF
C1419 divbuf_20/IN divbuf_20/OUT5 0.00fF
C1420 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/and_0/OUT 0.05fF
C1421 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/z5 0.20fF
C1422 divider_2/tspc_0/Z3 divider_2/nor_1/B 0.38fF
C1423 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z3 0.33fF
C1424 divbuf_8/a_492_n240# divbuf_8/IN 0.13fF
C1425 divbuf_13/OUT4 divbuf_13/OUT 1.11fF
C1426 divbuf_18/OUT divbuf_18/a_492_n240# 0.00fF
C1427 divider_2/and_0/OUT divider_2/and_0/Z1 0.04fF
C1428 divider_2/prescaler_0/tspc_2/Q divider_2/clk 0.05fF
C1429 divbuf_4/OUT divbuf_3/OUT 2.71fF
C1430 divider_0/nor_0/B divider_0/tspc_1/Q 0.51fF
C1431 divbuf_0/OUT divbuf_0/a_492_n240# 0.00fF
C1432 divbuf_1/OUT5 divbuf_1/OUT3 0.01fF
C1433 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C1434 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1435 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z4 0.65fF
C1436 divider_0/and_0/OUT divider_0/clk 0.04fF
C1437 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_0/a_630_n680# 0.04fF
C1438 divider_1/nor_0/B divider_1/tspc_1/Z1 0.03fF
C1439 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1440 divider_1/prescaler_0/tspc_1/Q divider_1/nor_0/A 0.03fF
C1441 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_0/A 0.15fF
C1442 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C1443 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C1444 pd_1/R pd_1/tspc_r_0/Qbar1 0.01fF
C1445 pd_1/tspc_r_0/Qbar pd_1/DOWN 0.21fF
C1446 pd_0/tspc_r_0/z5 pd_0/tspc_r_1/z5 0.02fF
C1447 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z2 0.25fF
C1448 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/nand_0/z1 0.07fF
C1449 divbuf_12/OUT2 divbuf_12/OUT3 1.37fF
C1450 divbuf_6/OUT divbuf_7/OUT 2.98fF
C1451 divider_0/tspc_2/Q divider_0/tspc_1/a_630_n680# 0.01fF
C1452 divider_0/tspc_1/Z1 divider_0/tspc_1/Z3 0.06fF
C1453 divbuf_3/OUT ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1454 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C1455 divider_0/nor_0/A divider_0/and_0/A 0.01fF
C1456 divbuf_6/OUT2 divbuf_6/OUT5 0.02fF
C1457 divbuf_6/OUT3 divbuf_6/OUT4 5.16fF
C1458 divider_1/nor_0/B divider_1/tspc_1/Z2 0.30fF
C1459 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C1460 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1461 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/divider_0/clk 1.46fF
C1462 divbuf_17/a_492_n240# divbuf_17/OUT5 0.01fF
C1463 divbuf_16/OUT divbuf_16/OUT4 1.11fF
C1464 divbuf_11/a_492_n240# divbuf_11/OUT2 0.42fF
C1465 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z2 0.01fF
C1466 pd_1/tspc_r_0/Z4 pd_1/DIV 0.02fF
C1467 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Q 0.05fF
C1468 divider_2/prescaler_0/m1_2700_2190# divider_2/clk 0.01fF
C1469 divbuf_23/OUT5 divbuf_23/OUT 43.38fF
C1470 pll_full_0/cp_0/a_1710_0# pll_full_0/cp_0/down 0.32fF
C1471 divider_0/prescaler_0/m1_2700_2190# divider_0/nor_0/A 0.01fF
C1472 divider_0/prescaler_0/Out divider_0/tspc_2/Z4 0.12fF
C1473 divider_0/tspc_1/Z2 divider_0/tspc_1/Z3 0.16fF
C1474 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/D 0.15fF
C1475 divbuf_3/OUT divbuf_3/OUT2 0.06fF
C1476 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C1477 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/v 1.30fF
C1478 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1479 ro_complete_1/cbank_1/switch_5/vin ro_complete_1/cbank_1/v 1.30fF
C1480 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z4 0.01fF
C1481 divbuf_19/OUT2 divbuf_19/OUT5 0.02fF
C1482 divider_1/prescaler_0/Out divider_1/tspc_2/Z3 0.45fF
C1483 divider_1/nor_0/B divider_1/nor_0/A 1.21fF
C1484 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z2 0.01fF
C1485 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z3 0.45fF
C1486 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1487 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1488 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C1489 pd_0/DIV pd_0/tspc_r_0/Qbar1 0.12fF
C1490 divider_2/nor_0/Z1 divider_2/nor_0/B 0.06fF
C1491 divbuf_22/IN divbuf_22/OUT5 0.00fF
C1492 pd_1/REF pd_1/tspc_r_1/Z4 0.02fF
C1493 divbuf_13/a_492_n240# divbuf_13/IN 0.13fF
C1494 divider_0/tspc_0/Z1 divider_0/tspc_0/Z3 0.06fF
C1495 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1496 divbuf_0/OUT5 divbuf_0/OUT3 0.01fF
C1497 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1498 divbuf_25/a_492_n240# divbuf_25/OUT5 0.01fF
C1499 divbuf_5/OUT divbuf_5/OUT2 0.06fF
C1500 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT5 0.02fF
C1501 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Q 0.15fF
C1502 divider_1/tspc_0/Z1 divider_1/tspc_1/Q 0.01fF
C1503 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z3 0.06fF
C1504 pd_1/tspc_r_0/Z2 pd_1/R 0.21fF
C1505 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z3 0.65fF
C1506 divbuf_17/a_492_n240# divbuf_17/OUT 0.00fF
C1507 divider_2/tspc_2/Q divider_2/tspc_2/a_630_n680# 0.04fF
C1508 divider_2/tspc_0/Z3 divider_2/tspc_0/Z1 0.06fF
C1509 divbuf_24/OUT2 divbuf_24/OUT3 1.37fF
C1510 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/Out 0.21fF
C1511 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z3 0.06fF
C1512 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/a_630_n680# 0.19fF
C1513 divbuf_25/IN divbuf_25/OUT5 0.00fF
C1514 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z3 0.05fF
C1515 divider_0/nor_0/A divider_0/tspc_2/Z1 0.03fF
C1516 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1517 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C1518 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_1/B 0.06fF
C1519 divider_1/tspc_1/Z1 divider_1/tspc_2/Q 0.01fF
C1520 divider_1/nor_0/B divider_1/tspc_1/a_630_n680# 0.35fF
C1521 divbuf_7/OUT2 divbuf_7/OUT5 0.02fF
C1522 divbuf_7/OUT3 divbuf_7/OUT4 5.16fF
C1523 divider_2/mc2 divider_2/and_0/out1 0.06fF
C1524 divider_2/nor_0/Z1 divider_2/and_0/A 0.80fF
C1525 divbuf_23/a_492_n240# divbuf_23/OUT2 0.42fF
C1526 divbuf_15/OUT5 divbuf_15/OUT 43.38fF
C1527 divider_0/mc2 divider_0/and_0/out1 0.06fF
C1528 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z3 0.05fF
C1529 divbuf_0/OUT3 divbuf_0/OUT2 1.37fF
C1530 pll_full_0/pd_0/REF pll_full_0/divbuf_1/OUT5 0.00fF
C1531 divider_2/tspc_0/Z4 divider_2/tspc_0/Z3 0.65fF
C1532 divider_0/and_0/A divider_0/and_0/B 0.18fF
C1533 divbuf_3/a_492_n240# divbuf_3/OUT5 0.01fF
C1534 ro_complete_1/a0 ro_complete_1/cbank_1/switch_5/vin 0.09fF
C1535 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1536 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z4 0.21fF
C1537 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/nor_1/B 0.38fF
C1538 divider_1/tspc_2/Q divider_1/tspc_1/Z2 0.14fF
C1539 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z2 0.01fF
C1540 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/B 0.08fF
C1541 divider_2/nor_1/Z1 divider_2/and_0/B 0.78fF
C1542 divider_1/and_0/out1 divider_1/and_0/B 0.18fF
C1543 pll_full_0/pd_0/DIV pll_full_0/pd_0/R 0.51fF
C1544 divbuf_17/OUT5 divbuf_17/OUT 43.38fF
C1545 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_2/Q 0.19fF
C1546 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/clk 0.01fF
C1547 divider_2/nor_1/B divider_2/and_0/B 0.29fF
C1548 divbuf_9/IN divbuf_9/OUT5 0.00fF
C1549 ro_complete_0/cbank_0/switch_0/vin divbuf_4/OUT 0.12fF
C1550 divbuf_5/OUT ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1551 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Qbar 0.01fF
C1552 divider_0/mc2 divider_0/nor_0/B 0.06fF
C1553 divider_0/prescaler_0/tspc_2/D divider_0/prescaler_0/nand_0/z1 0.24fF
C1554 ro_complete_1/a2 ro_complete_1/cbank_2/switch_2/vin 0.14fF
C1555 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/OUT3 0.01fF
C1556 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1557 divbuf_4/a_492_n240# divbuf_4/OUT5 0.01fF
C1558 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/v 1.30fF
C1559 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z2 1.07fF
C1560 divbuf_20/OUT2 divbuf_20/OUT 0.06fF
C1561 divbuf_20/OUT3 divbuf_20/OUT5 0.01fF
C1562 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C1563 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C1564 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/clk 0.11fF
C1565 divider_1/nor_0/B divider_1/and_0/B 0.31fF
C1566 divider_1/tspc_2/Q divider_1/nor_0/A 0.55fF
C1567 divider_1/and_0/OUT divider_1/prescaler_0/nand_0/z1 0.01fF
C1568 divider_2/tspc_0/Z2 divider_2/nor_0/B 0.20fF
C1569 divider_2/tspc_0/a_630_n680# divider_2/nor_1/B 0.35fF
C1570 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z4 0.08fF
C1571 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z3 0.05fF
C1572 divider_2/tspc_2/a_630_n680# divider_2/nor_0/A 0.35fF
C1573 divider_2/prescaler_0/tspc_0/D divider_2/clk 0.29fF
C1574 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1575 divider_0/tspc_0/Z1 divider_0/tspc_0/Z4 0.00fF
C1576 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1577 divbuf_17/IN divbuf_17/a_492_n240# 0.13fF
C1578 divider_1/mc2 divider_1/and_0/OUT 0.05fF
C1579 divbuf_14/OUT divbuf_14/OUT4 1.11fF
C1580 divider_0/and_0/OUT divider_0/and_0/out1 0.31fF
C1581 divider_0/prescaler_0/tspc_2/D divider_0/clk 0.26fF
C1582 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/switch_0/vin 0.19fF
C1583 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z1 0.06fF
C1584 divider_1/nor_0/B divider_1/tspc_1/Q 0.51fF
C1585 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_1/Q 0.01fF
C1586 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C1587 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/Out 0.05fF
C1588 pll_full_0/ro_complete_0/a2 pll_full_0/divider_0/clk 0.11fF
C1589 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C1590 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C1591 divider_1/and_0/OUT divider_1/clk 0.04fF
C1592 divbuf_12/OUT2 divbuf_12/OUT5 0.02fF
C1593 divbuf_12/OUT3 divbuf_12/OUT4 5.16fF
C1594 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/Qbar 0.01fF
C1595 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Qbar1 0.38fF
C1596 divider_2/prescaler_0/tspc_1/Z2 divider_2/and_0/OUT 0.06fF
C1597 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z3 0.33fF
C1598 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Q 0.38fF
C1599 divider_2/prescaler_0/tspc_0/Z2 divider_2/clk 0.11fF
C1600 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT4 1.11fF
C1601 divider_2/and_0/out1 divider_2/and_0/A 0.01fF
C1602 divbuf_2/OUT ro_complete_0/cbank_1/v 0.10fF
C1603 ro_complete_0/cbank_0/switch_5/vin divbuf_7/OUT 0.09fF
C1604 divbuf_14/OUT2 divbuf_14/OUT 0.06fF
C1605 divider_0/tspc_1/Q divider_0/tspc_1/Z3 0.05fF
C1606 divider_0/tspc_1/Z1 divider_0/tspc_1/Z4 0.00fF
C1607 divider_0/Out divider_0/nor_1/B 0.22fF
C1608 divbuf_16/a_492_n240# divbuf_16/OUT 0.00fF
C1609 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT2 1.37fF
C1610 divider_2/prescaler_0/Out divider_2/prescaler_0/m1_2700_2190# 0.11fF
C1611 divider_1/tspc_2/Q divider_1/tspc_1/a_630_n680# 0.01fF
C1612 divider_1/tspc_1/Z1 divider_1/tspc_1/Z3 0.06fF
C1613 filter_0/v divbuf_25/OUT3 0.26fF
C1614 divbuf_6/OUT4 divbuf_6/OUT5 20.26fF
C1615 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.04fF
C1616 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C1617 pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_0/divider_0/clk 1.58fF
C1618 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z2 0.23fF
C1619 divider_1/nor_0/A divider_1/and_0/A 0.01fF
C1620 pd_1/tspc_r_0/z5 pd_1/tspc_r_0/Z3 0.11fF
C1621 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/DOWN 0.11fF
C1622 divbuf_19/OUT divbuf_19/OUT3 0.26fF
C1623 divbuf_19/OUT5 divbuf_19/OUT4 20.26fF
C1624 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/clk 0.01fF
C1625 divbuf_0/IN divbuf_0/OUT5 0.00fF
C1626 divbuf_1/OUT5 divbuf_1/a_492_n240# 0.01fF
C1627 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a4 0.12fF
C1628 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1629 divider_0/tspc_1/Z2 divider_0/tspc_1/Z4 0.36fF
C1630 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/D 0.05fF
C1631 divider_0/prescaler_0/tspc_0/Z3 divider_0/clk 0.64fF
C1632 divbuf_17/IN divbuf_17/OUT5 0.00fF
C1633 ro_complete_1/cbank_0/v ro_complete_1/cbank_2/v 0.04fF
C1634 divider_1/prescaler_0/m1_2700_2190# divider_1/nor_0/A 0.01fF
C1635 divider_1/prescaler_0/Out divider_1/tspc_2/Z4 0.12fF
C1636 divider_1/tspc_1/Z2 divider_1/tspc_1/Z3 0.16fF
C1637 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/D 0.15fF
C1638 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z4 0.15fF
C1639 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/nor_1/B 0.22fF
C1640 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1641 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1642 pd_0/tspc_r_0/Z3 pd_0/DOWN 0.03fF
C1643 divbuf_22/OUT2 divbuf_22/OUT 0.06fF
C1644 divbuf_22/OUT3 divbuf_22/OUT5 0.01fF
C1645 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/Z1 0.36fF
C1646 divider_2/mc2 divider_2/nor_0/B 0.06fF
C1647 divider_2/tspc_2/Q divider_2/tspc_1/Z2 0.14fF
C1648 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/z5 0.11fF
C1649 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/R 0.01fF
C1650 divbuf_18/OUT5 divbuf_18/a_492_n240# 0.01fF
C1651 divbuf_0/OUT divbuf_0/OUT3 0.26fF
C1652 ro_complete_0/cbank_0/switch_1/vin divbuf_3/OUT 0.13fF
C1653 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1654 divbuf_5/OUT divbuf_5/OUT4 1.11fF
C1655 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT 0.26fF
C1656 pll_full_0/divbuf_1/OUT4 pll_full_0/divbuf_1/OUT5 20.26fF
C1657 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1658 divider_0/tspc_1/Z4 divider_0/nor_0/A 0.02fF
C1659 divider_1/tspc_0/Z1 divider_1/tspc_0/Z3 0.06fF
C1660 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z4 0.00fF
C1661 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C1662 divbuf_21/a_492_n240# divbuf_21/OUT5 0.01fF
C1663 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/Z3 0.05fF
C1664 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/clk 0.11fF
Xpd_0 vdda1 vssa1 pd_0/REF pd_0/DIV pd_0/UP pd_0/DOWN pd_0/R pd
Xpd_1 vdda1 vssa1 pd_1/REF pd_1/DIV pd_1/UP pd_1/DOWN pd_1/R pd
Xcp_0 cp_0/vbias vdda1 gnd cp_0/out cp_0/down cp_0/upbar cp
Xfilter_0 vssa1 filter_0/v filter
Xro_complete_0 divbuf_7/OUT divbuf_6/OUT divbuf_2/OUT divbuf_4/OUT divbuf_3/OUT divbuf_5/OUT
+ ro_complete
Xdivbuf_0 vdda1 divbuf_0/IN divbuf_0/OUT divbuf_0/OUT2 divbuf_0/OUT3 divbuf_0/OUT4
+ divbuf_0/OUT5 gnd divbuf
Xro_complete_1 ro_complete_1/a0 ro_complete_1/a1 ro_complete_1/a5 ro_complete_1/a4
+ ro_complete_1/a3 ro_complete_1/a2 ro_complete
Xdivbuf_1 vdda1 divbuf_1/IN divbuf_1/OUT divbuf_1/OUT2 divbuf_1/OUT3 divbuf_1/OUT4
+ divbuf_1/OUT5 gnd divbuf
Xdivbuf_2 vdda1 divbuf_2/IN divbuf_2/OUT divbuf_2/OUT2 divbuf_2/OUT3 divbuf_2/OUT4
+ divbuf_2/OUT5 gnd divbuf
Xdivbuf_3 vdda1 divbuf_3/IN divbuf_3/OUT divbuf_3/OUT2 divbuf_3/OUT3 divbuf_3/OUT4
+ divbuf_3/OUT5 gnd divbuf
Xdivbuf_4 vdda1 divbuf_4/IN divbuf_4/OUT divbuf_4/OUT2 divbuf_4/OUT3 divbuf_4/OUT4
+ divbuf_4/OUT5 gnd divbuf
Xdivbuf_5 vdda1 divbuf_5/IN divbuf_5/OUT divbuf_5/OUT2 divbuf_5/OUT3 divbuf_5/OUT4
+ divbuf_5/OUT5 gnd divbuf
Xdivbuf_6 vdda1 divbuf_6/IN divbuf_6/OUT divbuf_6/OUT2 divbuf_6/OUT3 divbuf_6/OUT4
+ divbuf_6/OUT5 gnd divbuf
Xdivbuf_10 vdda1 divbuf_10/IN divbuf_10/OUT divbuf_10/OUT2 divbuf_10/OUT3 divbuf_10/OUT4
+ divbuf_10/OUT5 gnd divbuf
Xdivbuf_20 vdda1 divbuf_20/IN divbuf_20/OUT divbuf_20/OUT2 divbuf_20/OUT3 divbuf_20/OUT4
+ divbuf_20/OUT5 vssa1 divbuf
Xdivbuf_21 vdda1 divbuf_21/IN divbuf_21/OUT divbuf_21/OUT2 divbuf_21/OUT3 divbuf_21/OUT4
+ divbuf_21/OUT5 vssa1 divbuf
Xdivbuf_7 vdda1 divbuf_7/IN divbuf_7/OUT divbuf_7/OUT2 divbuf_7/OUT3 divbuf_7/OUT4
+ divbuf_7/OUT5 gnd divbuf
Xdivbuf_11 vdda1 divbuf_11/IN divbuf_11/OUT divbuf_11/OUT2 divbuf_11/OUT3 divbuf_11/OUT4
+ divbuf_11/OUT5 gnd divbuf
Xdivbuf_22 vdda1 divbuf_22/IN divbuf_22/OUT divbuf_22/OUT2 divbuf_22/OUT3 divbuf_22/OUT4
+ divbuf_22/OUT5 vssa1 divbuf
Xdivbuf_8 vdda1 divbuf_8/IN divbuf_8/OUT divbuf_8/OUT2 divbuf_8/OUT3 divbuf_8/OUT4
+ divbuf_8/OUT5 gnd divbuf
Xdivbuf_12 vdda1 divbuf_12/IN divbuf_12/OUT divbuf_12/OUT2 divbuf_12/OUT3 divbuf_12/OUT4
+ divbuf_12/OUT5 gnd divbuf
Xdivbuf_23 vdda1 divbuf_23/IN divbuf_23/OUT divbuf_23/OUT2 divbuf_23/OUT3 divbuf_23/OUT4
+ divbuf_23/OUT5 vssa1 divbuf
Xdivbuf_9 vdda1 divbuf_9/IN divbuf_9/OUT divbuf_9/OUT2 divbuf_9/OUT3 divbuf_9/OUT4
+ divbuf_9/OUT5 gnd divbuf
Xdivbuf_13 vdda1 divbuf_13/IN divbuf_13/OUT divbuf_13/OUT2 divbuf_13/OUT3 divbuf_13/OUT4
+ divbuf_13/OUT5 gnd divbuf
Xdivbuf_24 vdda1 divbuf_24/IN divbuf_24/OUT divbuf_24/OUT2 divbuf_24/OUT3 divbuf_24/OUT4
+ divbuf_24/OUT5 vssa1 divbuf
Xdivider_0 gnd vdd divider_0/Out divider_0/clk divider_0/mc2 divider
Xdivbuf_14 vdda1 divbuf_14/IN divbuf_14/OUT divbuf_14/OUT2 divbuf_14/OUT3 divbuf_14/OUT4
+ divbuf_14/OUT5 gnd divbuf
Xdivbuf_25 vdda1 divbuf_25/IN filter_0/v divbuf_25/OUT2 divbuf_25/OUT3 divbuf_25/OUT4
+ divbuf_25/OUT5 vssa1 divbuf
Xdivbuf_15 vdda1 divbuf_15/IN divbuf_15/OUT divbuf_15/OUT2 divbuf_15/OUT3 divbuf_15/OUT4
+ divbuf_15/OUT5 gnd divbuf
Xdivider_1 vssa1 vdda1 divider_1/Out divider_1/clk divider_1/mc2 divider
Xdivbuf_16 vdda1 divbuf_16/IN divbuf_16/OUT divbuf_16/OUT2 divbuf_16/OUT3 divbuf_16/OUT4
+ divbuf_16/OUT5 vssa1 divbuf
Xdivider_2 vssa1 vdda1 divider_2/Out divider_2/clk divider_2/mc2 divider
Xdivbuf_17 vdda1 divbuf_17/IN divbuf_17/OUT divbuf_17/OUT2 divbuf_17/OUT3 divbuf_17/OUT4
+ divbuf_17/OUT5 vssa1 divbuf
Xdivbuf_18 vdda1 divbuf_18/IN divbuf_18/OUT divbuf_18/OUT2 divbuf_18/OUT3 divbuf_18/OUT4
+ divbuf_18/OUT5 vssa1 divbuf
Xdivbuf_19 vdda1 divbuf_19/IN divbuf_19/OUT divbuf_19/OUT2 divbuf_19/OUT3 divbuf_19/OUT4
+ divbuf_19/OUT5 vssa1 divbuf
Xpll_full_0 vdda1 pll_full
C1665 io_analog[4] gnd 43.96fF
C1666 io_analog[5] gnd 44.13fF
C1667 io_analog[6] gnd 43.46fF
C1668 io_in_3v3[0] gnd 0.61fF
C1669 io_oeb[26] gnd 0.61fF
C1670 io_in[0] gnd 0.61fF
C1671 io_out[26] gnd 0.61fF
C1672 io_out[0] gnd 0.61fF
C1673 io_in[26] gnd 0.61fF
C1674 io_oeb[0] gnd 0.61fF
C1675 io_in_3v3[26] gnd 0.61fF
C1676 io_in_3v3[1] gnd 0.61fF
C1677 io_oeb[25] gnd 0.61fF
C1678 io_in[1] gnd 0.61fF
C1679 io_out[25] gnd 0.61fF
C1680 io_out[1] gnd 0.61fF
C1681 io_in[25] gnd 0.61fF
C1682 io_oeb[1] gnd 0.61fF
C1683 io_in_3v3[25] gnd 0.61fF
C1684 io_in_3v3[2] gnd 0.61fF
C1685 io_oeb[24] gnd 0.61fF
C1686 io_in[2] gnd 0.61fF
C1687 io_out[24] gnd 0.61fF
C1688 io_out[2] gnd 0.61fF
C1689 io_in[24] gnd 0.61fF
C1690 io_oeb[2] gnd 0.61fF
C1691 io_in_3v3[24] gnd 0.61fF
C1692 io_in_3v3[3] gnd 0.61fF
C1693 io_in[3] gnd 0.61fF
C1694 gpio_noesd[17] gnd 2.32fF
C1695 gpio_analog[17] gnd 2.30fF
C1696 io_out[3] gnd 0.61fF
C1697 io_oeb[3] gnd 0.61fF
C1698 io_in_3v3[4] gnd 0.61fF
C1699 io_in[4] gnd 0.61fF
C1700 io_out[4] gnd 0.61fF
C1701 io_oeb[4] gnd 0.61fF
C1702 io_oeb[23] gnd 0.61fF
C1703 io_out[23] gnd 0.61fF
C1704 io_in[23] gnd 0.61fF
C1705 io_in_3v3[23] gnd 0.61fF
C1706 gpio_noesd[16] gnd 2.30fF
C1707 gpio_analog[16] gnd 2.30fF
C1708 io_in_3v3[5] gnd 0.61fF
C1709 io_in[5] gnd 0.61fF
C1710 io_out[5] gnd 0.61fF
C1711 io_oeb[5] gnd 0.61fF
C1712 io_oeb[22] gnd 0.61fF
C1713 io_out[22] gnd 0.61fF
C1714 io_in[22] gnd 0.61fF
C1715 io_in_3v3[22] gnd 0.61fF
C1716 gpio_noesd[15] gnd 2.31fF
C1717 gpio_analog[15] gnd 2.30fF
C1718 io_in_3v3[6] gnd 0.61fF
C1719 io_in[6] gnd 0.61fF
C1720 io_out[6] gnd 0.61fF
C1721 io_oeb[6] gnd 0.61fF
C1722 io_oeb[21] gnd 0.61fF
C1723 io_out[21] gnd 0.61fF
C1724 io_in[21] gnd 0.61fF
C1725 io_in_3v3[21] gnd 0.61fF
C1726 gpio_noesd[14] gnd 2.30fF
C1727 gpio_analog[14] gnd 2.29fF
C1728 vssd2 gnd 38.54fF
C1729 vssd1 gnd 13.04fF
C1730 vdda2 gnd 38.30fF
C1731 io_oeb[20] gnd 0.61fF
C1732 io_out[20] gnd 0.61fF
C1733 io_in[20] gnd 0.61fF
C1734 io_in_3v3[20] gnd 0.61fF
C1735 gpio_noesd[13] gnd 2.31fF
C1736 gpio_analog[13] gnd 2.30fF
C1737 gpio_analog[0] gnd 0.61fF
C1738 gpio_noesd[0] gnd 0.61fF
C1739 io_in_3v3[7] gnd 0.61fF
C1740 io_in[7] gnd 0.61fF
C1741 io_out[7] gnd 0.61fF
C1742 io_oeb[7] gnd 0.61fF
C1743 io_oeb[19] gnd 0.61fF
C1744 io_out[19] gnd 0.61fF
C1745 io_in[19] gnd 0.61fF
C1746 io_in_3v3[19] gnd 0.61fF
C1747 gpio_noesd[12] gnd 2.32fF
C1748 gpio_analog[12] gnd 2.30fF
C1749 gpio_analog[1] gnd 0.61fF
C1750 gpio_noesd[1] gnd 0.61fF
C1751 io_in_3v3[8] gnd 0.61fF
C1752 io_in[8] gnd 0.61fF
C1753 io_out[8] gnd 0.61fF
C1754 io_oeb[8] gnd 0.61fF
C1755 io_oeb[18] gnd 0.61fF
C1756 io_out[18] gnd 0.61fF
C1757 io_in[18] gnd 0.61fF
C1758 io_in_3v3[18] gnd 0.61fF
C1759 gpio_noesd[11] gnd 2.30fF
C1760 gpio_analog[11] gnd 2.29fF
C1761 gpio_analog[2] gnd 0.61fF
C1762 gpio_noesd[2] gnd 0.61fF
C1763 io_in_3v3[9] gnd 0.61fF
C1764 io_in[9] gnd 0.61fF
C1765 io_out[9] gnd 0.61fF
C1766 io_oeb[9] gnd 0.61fF
C1767 io_oeb[17] gnd 0.61fF
C1768 io_out[17] gnd 0.61fF
C1769 io_in[17] gnd 0.61fF
C1770 io_in_3v3[17] gnd 0.61fF
C1771 gpio_noesd[10] gnd 2.31fF
C1772 gpio_analog[10] gnd 2.29fF
C1773 gpio_analog[3] gnd 0.61fF
C1774 gpio_noesd[3] gnd 0.61fF
C1775 io_in_3v3[10] gnd 0.61fF
C1776 io_in[10] gnd 0.61fF
C1777 io_out[10] gnd 0.61fF
C1778 io_oeb[10] gnd 0.61fF
C1779 io_oeb[16] gnd 0.61fF
C1780 io_out[16] gnd 0.61fF
C1781 io_in[16] gnd 0.61fF
C1782 io_in_3v3[16] gnd 0.61fF
C1783 gpio_noesd[9] gnd 2.28fF
C1784 gpio_analog[9] gnd 2.28fF
C1785 gpio_analog[4] gnd 0.61fF
C1786 gpio_noesd[4] gnd 0.61fF
C1787 io_in_3v3[11] gnd 0.61fF
C1788 io_in[11] gnd 0.61fF
C1789 io_out[11] gnd 0.61fF
C1790 io_oeb[11] gnd 0.61fF
C1791 io_oeb[15] gnd 0.61fF
C1792 io_out[15] gnd 0.61fF
C1793 io_in[15] gnd 0.61fF
C1794 io_in_3v3[15] gnd 0.61fF
C1795 gpio_noesd[8] gnd 2.28fF
C1796 gpio_analog[8] gnd 2.26fF
C1797 gpio_analog[5] gnd 0.61fF
C1798 gpio_noesd[5] gnd 0.61fF
C1799 io_in_3v3[12] gnd 0.61fF
C1800 io_in[12] gnd 0.61fF
C1801 io_out[12] gnd 0.61fF
C1802 io_oeb[12] gnd 0.61fF
C1803 io_oeb[14] gnd 0.61fF
C1804 io_out[14] gnd 0.61fF
C1805 io_in[14] gnd 0.61fF
C1806 io_in_3v3[14] gnd 0.61fF
C1807 gpio_noesd[7] gnd 2.30fF
C1808 gpio_analog[7] gnd 2.28fF
C1809 vssa2 gnd 38.35fF
C1810 gpio_analog[6] gnd 5.71fF
C1811 gpio_noesd[6] gnd 5.70fF
C1812 io_in_3v3[13] gnd 0.61fF
C1813 io_in[13] gnd 0.61fF
C1814 io_out[13] gnd 0.61fF
C1815 io_oeb[13] gnd 0.61fF
C1816 vccd1 gnd 39.84fF
C1817 vccd2 gnd 38.46fF
C1818 io_analog[0] gnd 19.99fF
C1819 io_analog[10] gnd 19.36fF
C1820 io_analog[1] gnd 13.17fF
C1821 io_analog[2] gnd 12.57fF
C1822 io_analog[3] gnd 12.83fF
C1823 io_clamp_high[0] gnd 3.58fF
C1824 io_clamp_low[0] gnd 3.58fF
C1825 io_clamp_high[1] gnd 3.58fF
C1826 io_clamp_low[1] gnd 3.58fF
C1827 io_clamp_high[2] gnd 3.58fF
C1828 io_clamp_low[2] gnd 3.58fF
C1829 io_analog[7] gnd 12.74fF
C1830 io_analog[8] gnd 13.08fF
C1831 io_analog[9] gnd 13.08fF
C1832 user_irq[2] gnd 0.63fF
C1833 user_irq[1] gnd 0.63fF
C1834 user_irq[0] gnd 0.63fF
C1835 user_clock2 gnd 0.63fF
C1836 la_oenb[127] gnd 0.63fF
C1837 la_data_out[127] gnd 0.63fF
C1838 la_data_in[127] gnd 0.63fF
C1839 la_oenb[126] gnd 0.63fF
C1840 la_data_out[126] gnd 0.63fF
C1841 la_data_in[126] gnd 0.63fF
C1842 la_oenb[125] gnd 0.63fF
C1843 la_data_out[125] gnd 0.63fF
C1844 la_data_in[125] gnd 0.63fF
C1845 la_oenb[124] gnd 0.63fF
C1846 la_data_out[124] gnd 0.63fF
C1847 la_data_in[124] gnd 0.63fF
C1848 la_oenb[123] gnd 0.63fF
C1849 la_data_out[123] gnd 0.63fF
C1850 la_data_in[123] gnd 0.63fF
C1851 la_oenb[122] gnd 0.63fF
C1852 la_data_out[122] gnd 0.63fF
C1853 la_data_in[122] gnd 0.63fF
C1854 la_oenb[121] gnd 0.63fF
C1855 la_data_out[121] gnd 0.63fF
C1856 la_data_in[121] gnd 0.63fF
C1857 la_oenb[120] gnd 0.63fF
C1858 la_data_out[120] gnd 0.63fF
C1859 la_data_in[120] gnd 0.63fF
C1860 la_oenb[119] gnd 0.63fF
C1861 la_data_out[119] gnd 0.63fF
C1862 la_data_in[119] gnd 0.63fF
C1863 la_oenb[118] gnd 0.63fF
C1864 la_data_out[118] gnd 0.63fF
C1865 la_data_in[118] gnd 0.63fF
C1866 la_oenb[117] gnd 0.63fF
C1867 la_data_out[117] gnd 0.63fF
C1868 la_data_in[117] gnd 0.63fF
C1869 la_oenb[116] gnd 0.63fF
C1870 la_data_out[116] gnd 0.63fF
C1871 la_data_in[116] gnd 0.63fF
C1872 la_oenb[115] gnd 0.63fF
C1873 la_data_out[115] gnd 0.63fF
C1874 la_data_in[115] gnd 0.63fF
C1875 la_oenb[114] gnd 0.63fF
C1876 la_data_out[114] gnd 0.63fF
C1877 la_data_in[114] gnd 0.63fF
C1878 la_oenb[113] gnd 0.63fF
C1879 la_data_out[113] gnd 0.63fF
C1880 la_data_in[113] gnd 0.63fF
C1881 la_oenb[112] gnd 0.63fF
C1882 la_data_out[112] gnd 0.63fF
C1883 la_data_in[112] gnd 0.63fF
C1884 la_oenb[111] gnd 0.63fF
C1885 la_data_out[111] gnd 0.63fF
C1886 la_data_in[111] gnd 0.63fF
C1887 la_oenb[110] gnd 0.63fF
C1888 la_data_out[110] gnd 0.63fF
C1889 la_data_in[110] gnd 0.63fF
C1890 la_oenb[109] gnd 0.63fF
C1891 la_data_out[109] gnd 0.63fF
C1892 la_data_in[109] gnd 0.63fF
C1893 la_oenb[108] gnd 0.63fF
C1894 la_data_out[108] gnd 0.63fF
C1895 la_data_in[108] gnd 0.63fF
C1896 la_oenb[107] gnd 0.63fF
C1897 la_data_out[107] gnd 0.63fF
C1898 la_data_in[107] gnd 0.63fF
C1899 la_oenb[106] gnd 0.63fF
C1900 la_data_out[106] gnd 0.63fF
C1901 la_data_in[106] gnd 0.63fF
C1902 la_oenb[105] gnd 0.63fF
C1903 la_data_out[105] gnd 0.63fF
C1904 la_data_in[105] gnd 0.63fF
C1905 la_oenb[104] gnd 0.63fF
C1906 la_data_out[104] gnd 0.63fF
C1907 la_data_in[104] gnd 0.63fF
C1908 la_oenb[103] gnd 0.63fF
C1909 la_data_out[103] gnd 0.63fF
C1910 la_data_in[103] gnd 0.63fF
C1911 la_oenb[102] gnd 0.63fF
C1912 la_data_out[102] gnd 0.63fF
C1913 la_data_in[102] gnd 0.63fF
C1914 la_oenb[101] gnd 0.63fF
C1915 la_data_out[101] gnd 0.63fF
C1916 la_data_in[101] gnd 0.63fF
C1917 la_oenb[100] gnd 0.63fF
C1918 la_data_out[100] gnd 0.63fF
C1919 la_data_in[100] gnd 0.63fF
C1920 la_oenb[99] gnd 0.63fF
C1921 la_data_out[99] gnd 0.63fF
C1922 la_data_in[99] gnd 0.63fF
C1923 la_oenb[98] gnd 0.63fF
C1924 la_data_out[98] gnd 0.63fF
C1925 la_data_in[98] gnd 0.63fF
C1926 la_oenb[97] gnd 0.63fF
C1927 la_data_out[97] gnd 0.63fF
C1928 la_data_in[97] gnd 0.63fF
C1929 la_oenb[96] gnd 0.63fF
C1930 la_data_out[96] gnd 0.63fF
C1931 la_data_in[96] gnd 0.63fF
C1932 la_oenb[95] gnd 0.63fF
C1933 la_data_out[95] gnd 0.63fF
C1934 la_data_in[95] gnd 0.63fF
C1935 la_oenb[94] gnd 0.63fF
C1936 la_data_out[94] gnd 0.63fF
C1937 la_data_in[94] gnd 0.63fF
C1938 la_oenb[93] gnd 0.63fF
C1939 la_data_out[93] gnd 0.63fF
C1940 la_data_in[93] gnd 0.63fF
C1941 la_oenb[92] gnd 0.63fF
C1942 la_data_out[92] gnd 0.63fF
C1943 la_data_in[92] gnd 0.63fF
C1944 la_oenb[91] gnd 0.63fF
C1945 la_data_out[91] gnd 0.63fF
C1946 la_data_in[91] gnd 0.63fF
C1947 la_oenb[90] gnd 0.63fF
C1948 la_data_out[90] gnd 0.63fF
C1949 la_data_in[90] gnd 0.63fF
C1950 la_oenb[89] gnd 0.63fF
C1951 la_data_out[89] gnd 0.63fF
C1952 la_data_in[89] gnd 0.63fF
C1953 la_oenb[88] gnd 0.63fF
C1954 la_data_out[88] gnd 0.63fF
C1955 la_data_in[88] gnd 0.63fF
C1956 la_oenb[87] gnd 0.63fF
C1957 la_data_out[87] gnd 0.63fF
C1958 la_data_in[87] gnd 0.63fF
C1959 la_oenb[86] gnd 0.63fF
C1960 la_data_out[86] gnd 0.63fF
C1961 la_data_in[86] gnd 0.63fF
C1962 la_oenb[85] gnd 0.63fF
C1963 la_data_out[85] gnd 0.63fF
C1964 la_data_in[85] gnd 0.63fF
C1965 la_oenb[84] gnd 0.63fF
C1966 la_data_out[84] gnd 0.63fF
C1967 la_data_in[84] gnd 0.63fF
C1968 la_oenb[83] gnd 0.63fF
C1969 la_data_out[83] gnd 0.63fF
C1970 la_data_in[83] gnd 0.63fF
C1971 la_oenb[82] gnd 0.63fF
C1972 la_data_out[82] gnd 0.63fF
C1973 la_data_in[82] gnd 0.63fF
C1974 la_oenb[81] gnd 0.63fF
C1975 la_data_out[81] gnd 0.63fF
C1976 la_data_in[81] gnd 0.63fF
C1977 la_oenb[80] gnd 0.63fF
C1978 la_data_out[80] gnd 0.63fF
C1979 la_data_in[80] gnd 0.63fF
C1980 la_oenb[79] gnd 0.63fF
C1981 la_data_out[79] gnd 0.63fF
C1982 la_data_in[79] gnd 0.63fF
C1983 la_oenb[78] gnd 0.63fF
C1984 la_data_out[78] gnd 0.63fF
C1985 la_data_in[78] gnd 0.63fF
C1986 la_oenb[77] gnd 0.63fF
C1987 la_data_out[77] gnd 0.63fF
C1988 la_data_in[77] gnd 0.63fF
C1989 la_oenb[76] gnd 0.63fF
C1990 la_data_out[76] gnd 0.63fF
C1991 la_data_in[76] gnd 0.63fF
C1992 la_oenb[75] gnd 0.63fF
C1993 la_data_out[75] gnd 0.63fF
C1994 la_data_in[75] gnd 0.63fF
C1995 la_oenb[74] gnd 0.63fF
C1996 la_data_out[74] gnd 0.63fF
C1997 la_data_in[74] gnd 0.63fF
C1998 la_oenb[73] gnd 0.63fF
C1999 la_data_out[73] gnd 0.63fF
C2000 la_data_in[73] gnd 0.63fF
C2001 la_oenb[72] gnd 0.63fF
C2002 la_data_out[72] gnd 0.63fF
C2003 la_data_in[72] gnd 0.63fF
C2004 la_oenb[71] gnd 0.63fF
C2005 la_data_out[71] gnd 0.63fF
C2006 la_data_in[71] gnd 0.63fF
C2007 la_oenb[70] gnd 0.63fF
C2008 la_data_out[70] gnd 0.63fF
C2009 la_data_in[70] gnd 0.63fF
C2010 la_oenb[69] gnd 0.63fF
C2011 la_data_out[69] gnd 0.63fF
C2012 la_data_in[69] gnd 0.63fF
C2013 la_oenb[68] gnd 0.63fF
C2014 la_data_out[68] gnd 0.63fF
C2015 la_data_in[68] gnd 0.63fF
C2016 la_oenb[67] gnd 0.63fF
C2017 la_data_out[67] gnd 0.63fF
C2018 la_data_in[67] gnd 0.63fF
C2019 la_oenb[66] gnd 0.63fF
C2020 la_data_out[66] gnd 0.63fF
C2021 la_data_in[66] gnd 0.63fF
C2022 la_oenb[65] gnd 0.63fF
C2023 la_data_out[65] gnd 0.63fF
C2024 la_data_in[65] gnd 0.63fF
C2025 la_oenb[64] gnd 0.63fF
C2026 la_data_out[64] gnd 0.63fF
C2027 la_data_in[64] gnd 0.63fF
C2028 la_oenb[63] gnd 0.63fF
C2029 la_data_out[63] gnd 0.63fF
C2030 la_data_in[63] gnd 0.63fF
C2031 la_oenb[62] gnd 0.63fF
C2032 la_data_out[62] gnd 0.63fF
C2033 la_data_in[62] gnd 0.63fF
C2034 la_oenb[61] gnd 0.63fF
C2035 la_data_out[61] gnd 0.63fF
C2036 la_data_in[61] gnd 0.63fF
C2037 la_oenb[60] gnd 0.63fF
C2038 la_data_out[60] gnd 0.63fF
C2039 la_data_in[60] gnd 0.63fF
C2040 la_oenb[59] gnd 0.63fF
C2041 la_data_out[59] gnd 0.63fF
C2042 la_data_in[59] gnd 0.63fF
C2043 la_oenb[58] gnd 0.63fF
C2044 la_data_out[58] gnd 0.63fF
C2045 la_data_in[58] gnd 0.63fF
C2046 la_oenb[57] gnd 0.63fF
C2047 la_data_out[57] gnd 0.63fF
C2048 la_data_in[57] gnd 0.63fF
C2049 la_oenb[56] gnd 0.63fF
C2050 la_data_out[56] gnd 0.63fF
C2051 la_data_in[56] gnd 0.63fF
C2052 la_oenb[55] gnd 0.63fF
C2053 la_data_out[55] gnd 0.63fF
C2054 la_data_in[55] gnd 0.63fF
C2055 la_oenb[54] gnd 0.63fF
C2056 la_data_out[54] gnd 0.63fF
C2057 la_data_in[54] gnd 0.63fF
C2058 la_oenb[53] gnd 0.63fF
C2059 la_data_out[53] gnd 0.63fF
C2060 la_data_in[53] gnd 0.63fF
C2061 la_oenb[52] gnd 0.63fF
C2062 la_data_out[52] gnd 0.63fF
C2063 la_data_in[52] gnd 0.63fF
C2064 la_oenb[51] gnd 0.63fF
C2065 la_data_out[51] gnd 0.63fF
C2066 la_data_in[51] gnd 0.63fF
C2067 la_oenb[50] gnd 0.63fF
C2068 la_data_out[50] gnd 0.63fF
C2069 la_data_in[50] gnd 0.63fF
C2070 la_oenb[49] gnd 0.63fF
C2071 la_data_out[49] gnd 0.63fF
C2072 la_data_in[49] gnd 0.63fF
C2073 la_oenb[48] gnd 0.63fF
C2074 la_data_out[48] gnd 0.63fF
C2075 la_data_in[48] gnd 0.63fF
C2076 la_oenb[47] gnd 0.63fF
C2077 la_data_out[47] gnd 0.63fF
C2078 la_data_in[47] gnd 0.63fF
C2079 la_oenb[46] gnd 0.63fF
C2080 la_data_out[46] gnd 0.63fF
C2081 la_data_in[46] gnd 0.63fF
C2082 la_oenb[45] gnd 0.63fF
C2083 la_data_out[45] gnd 0.63fF
C2084 la_data_in[45] gnd 0.63fF
C2085 la_oenb[44] gnd 0.63fF
C2086 la_data_out[44] gnd 0.63fF
C2087 la_data_in[44] gnd 0.63fF
C2088 la_oenb[43] gnd 0.63fF
C2089 la_data_out[43] gnd 0.63fF
C2090 la_data_in[43] gnd 0.63fF
C2091 la_oenb[42] gnd 0.63fF
C2092 la_data_out[42] gnd 0.63fF
C2093 la_data_in[42] gnd 0.63fF
C2094 la_oenb[41] gnd 0.63fF
C2095 la_data_out[41] gnd 0.63fF
C2096 la_data_in[41] gnd 0.63fF
C2097 la_oenb[40] gnd 0.63fF
C2098 la_data_out[40] gnd 0.63fF
C2099 la_data_in[40] gnd 0.63fF
C2100 la_oenb[39] gnd 0.63fF
C2101 la_data_out[39] gnd 0.63fF
C2102 la_data_in[39] gnd 0.63fF
C2103 la_oenb[38] gnd 0.63fF
C2104 la_data_out[38] gnd 0.63fF
C2105 la_data_in[38] gnd 0.63fF
C2106 la_oenb[37] gnd 0.63fF
C2107 la_data_out[37] gnd 0.63fF
C2108 la_data_in[37] gnd 0.63fF
C2109 la_oenb[36] gnd 0.63fF
C2110 la_data_out[36] gnd 0.63fF
C2111 la_data_in[36] gnd 0.63fF
C2112 la_oenb[35] gnd 0.63fF
C2113 la_data_out[35] gnd 0.63fF
C2114 la_data_in[35] gnd 0.63fF
C2115 la_oenb[34] gnd 0.63fF
C2116 la_data_out[34] gnd 0.63fF
C2117 la_data_in[34] gnd 0.63fF
C2118 la_oenb[33] gnd 0.63fF
C2119 la_data_out[33] gnd 0.63fF
C2120 la_data_in[33] gnd 0.63fF
C2121 la_oenb[32] gnd 0.63fF
C2122 la_data_out[32] gnd 0.63fF
C2123 la_data_in[32] gnd 0.63fF
C2124 la_oenb[31] gnd 0.63fF
C2125 la_data_out[31] gnd 0.63fF
C2126 la_data_in[31] gnd 0.63fF
C2127 la_oenb[30] gnd 0.63fF
C2128 la_data_out[30] gnd 0.63fF
C2129 la_data_in[30] gnd 0.63fF
C2130 la_oenb[29] gnd 0.63fF
C2131 la_data_out[29] gnd 0.63fF
C2132 la_data_in[29] gnd 0.63fF
C2133 la_oenb[28] gnd 0.63fF
C2134 la_data_out[28] gnd 0.63fF
C2135 la_data_in[28] gnd 0.63fF
C2136 la_oenb[27] gnd 0.63fF
C2137 la_data_out[27] gnd 0.63fF
C2138 la_data_in[27] gnd 0.63fF
C2139 la_oenb[26] gnd 0.63fF
C2140 la_data_out[26] gnd 0.63fF
C2141 la_data_in[26] gnd 0.63fF
C2142 la_oenb[25] gnd 0.63fF
C2143 la_data_out[25] gnd 0.63fF
C2144 la_data_in[25] gnd 0.63fF
C2145 la_oenb[24] gnd 0.63fF
C2146 la_data_out[24] gnd 0.63fF
C2147 la_data_in[24] gnd 0.63fF
C2148 la_oenb[23] gnd 0.63fF
C2149 la_data_out[23] gnd 0.63fF
C2150 la_data_in[23] gnd 0.63fF
C2151 la_oenb[22] gnd 0.63fF
C2152 la_data_out[22] gnd 0.63fF
C2153 la_data_in[22] gnd 0.63fF
C2154 la_oenb[21] gnd 0.63fF
C2155 la_data_out[21] gnd 0.63fF
C2156 la_data_in[21] gnd 0.63fF
C2157 la_oenb[20] gnd 0.63fF
C2158 la_data_out[20] gnd 0.63fF
C2159 la_data_in[20] gnd 0.63fF
C2160 la_oenb[19] gnd 0.63fF
C2161 la_data_out[19] gnd 0.63fF
C2162 la_data_in[19] gnd 0.63fF
C2163 la_oenb[18] gnd 0.63fF
C2164 la_data_out[18] gnd 0.63fF
C2165 la_data_in[18] gnd 0.63fF
C2166 la_oenb[17] gnd 0.63fF
C2167 la_data_out[17] gnd 0.63fF
C2168 la_data_in[17] gnd 0.63fF
C2169 la_oenb[16] gnd 0.63fF
C2170 la_data_out[16] gnd 0.63fF
C2171 la_data_in[16] gnd 0.63fF
C2172 la_oenb[15] gnd 0.63fF
C2173 la_data_out[15] gnd 0.63fF
C2174 la_data_in[15] gnd 0.63fF
C2175 la_oenb[14] gnd 0.63fF
C2176 la_data_out[14] gnd 0.63fF
C2177 la_data_in[14] gnd 0.63fF
C2178 la_oenb[13] gnd 0.63fF
C2179 la_data_out[13] gnd 0.63fF
C2180 la_data_in[13] gnd 0.63fF
C2181 la_oenb[12] gnd 0.63fF
C2182 la_data_out[12] gnd 0.63fF
C2183 la_data_in[12] gnd 0.63fF
C2184 la_oenb[11] gnd 0.63fF
C2185 la_data_out[11] gnd 0.63fF
C2186 la_data_in[11] gnd 0.63fF
C2187 la_oenb[10] gnd 0.63fF
C2188 la_data_out[10] gnd 0.63fF
C2189 la_data_in[10] gnd 0.63fF
C2190 la_oenb[9] gnd 0.63fF
C2191 la_data_out[9] gnd 0.63fF
C2192 la_data_in[9] gnd 0.63fF
C2193 la_oenb[8] gnd 0.63fF
C2194 la_data_out[8] gnd 0.63fF
C2195 la_data_in[8] gnd 0.63fF
C2196 la_oenb[7] gnd 0.63fF
C2197 la_data_out[7] gnd 0.63fF
C2198 la_data_in[7] gnd 0.63fF
C2199 la_oenb[6] gnd 0.63fF
C2200 la_data_out[6] gnd 0.63fF
C2201 la_data_in[6] gnd 0.63fF
C2202 la_oenb[5] gnd 0.63fF
C2203 la_data_out[5] gnd 0.63fF
C2204 la_data_in[5] gnd 0.63fF
C2205 la_oenb[4] gnd 0.63fF
C2206 la_data_out[4] gnd 0.63fF
C2207 la_data_in[4] gnd 0.63fF
C2208 la_oenb[3] gnd 0.63fF
C2209 la_data_out[3] gnd 0.63fF
C2210 la_data_in[3] gnd 0.63fF
C2211 la_oenb[2] gnd 0.63fF
C2212 la_data_out[2] gnd 0.63fF
C2213 la_data_in[2] gnd 0.63fF
C2214 la_oenb[1] gnd 0.63fF
C2215 la_data_out[1] gnd 0.63fF
C2216 la_data_in[1] gnd 0.63fF
C2217 la_oenb[0] gnd 0.63fF
C2218 la_data_out[0] gnd 0.63fF
C2219 la_data_in[0] gnd 0.63fF
C2220 wbs_dat_o[31] gnd 0.63fF
C2221 wbs_dat_i[31] gnd 0.63fF
C2222 wbs_adr_i[31] gnd 0.63fF
C2223 wbs_dat_o[30] gnd 0.63fF
C2224 wbs_dat_i[30] gnd 0.63fF
C2225 wbs_adr_i[30] gnd 0.63fF
C2226 wbs_dat_o[29] gnd 0.63fF
C2227 wbs_dat_i[29] gnd 0.63fF
C2228 wbs_adr_i[29] gnd 0.63fF
C2229 wbs_dat_o[28] gnd 0.63fF
C2230 wbs_dat_i[28] gnd 0.63fF
C2231 wbs_adr_i[28] gnd 0.63fF
C2232 wbs_dat_o[27] gnd 0.63fF
C2233 wbs_dat_i[27] gnd 0.63fF
C2234 wbs_adr_i[27] gnd 0.63fF
C2235 wbs_dat_o[26] gnd 0.63fF
C2236 wbs_dat_i[26] gnd 0.63fF
C2237 wbs_adr_i[26] gnd 0.63fF
C2238 wbs_dat_o[25] gnd 0.63fF
C2239 wbs_dat_i[25] gnd 0.63fF
C2240 wbs_adr_i[25] gnd 0.63fF
C2241 wbs_dat_o[24] gnd 0.63fF
C2242 wbs_dat_i[24] gnd 0.63fF
C2243 wbs_adr_i[24] gnd 0.63fF
C2244 wbs_dat_o[23] gnd 0.63fF
C2245 wbs_dat_i[23] gnd 0.63fF
C2246 wbs_adr_i[23] gnd 0.63fF
C2247 wbs_dat_o[22] gnd 0.63fF
C2248 wbs_dat_i[22] gnd 0.63fF
C2249 wbs_adr_i[22] gnd 0.63fF
C2250 wbs_dat_o[21] gnd 0.63fF
C2251 wbs_dat_i[21] gnd 0.63fF
C2252 wbs_adr_i[21] gnd 0.63fF
C2253 wbs_dat_o[20] gnd 0.63fF
C2254 wbs_dat_i[20] gnd 0.63fF
C2255 wbs_adr_i[20] gnd 0.63fF
C2256 wbs_dat_o[19] gnd 0.63fF
C2257 wbs_dat_i[19] gnd 0.63fF
C2258 wbs_adr_i[19] gnd 0.63fF
C2259 wbs_dat_o[18] gnd 0.63fF
C2260 wbs_dat_i[18] gnd 0.63fF
C2261 wbs_adr_i[18] gnd 0.63fF
C2262 wbs_dat_o[17] gnd 0.63fF
C2263 wbs_dat_i[17] gnd 0.63fF
C2264 wbs_adr_i[17] gnd 0.63fF
C2265 wbs_dat_o[16] gnd 0.63fF
C2266 wbs_dat_i[16] gnd 0.63fF
C2267 wbs_adr_i[16] gnd 0.63fF
C2268 wbs_dat_o[15] gnd 0.63fF
C2269 wbs_dat_i[15] gnd 0.63fF
C2270 wbs_adr_i[15] gnd 0.63fF
C2271 wbs_dat_o[14] gnd 0.63fF
C2272 wbs_dat_i[14] gnd 0.63fF
C2273 wbs_adr_i[14] gnd 0.63fF
C2274 wbs_dat_o[13] gnd 0.63fF
C2275 wbs_dat_i[13] gnd 0.63fF
C2276 wbs_adr_i[13] gnd 0.63fF
C2277 wbs_dat_o[12] gnd 0.63fF
C2278 wbs_dat_i[12] gnd 0.63fF
C2279 wbs_adr_i[12] gnd 0.63fF
C2280 wbs_dat_o[11] gnd 0.63fF
C2281 wbs_dat_i[11] gnd 0.63fF
C2282 wbs_adr_i[11] gnd 0.63fF
C2283 wbs_dat_o[10] gnd 0.63fF
C2284 wbs_dat_i[10] gnd 0.63fF
C2285 wbs_adr_i[10] gnd 0.63fF
C2286 wbs_dat_o[9] gnd 0.63fF
C2287 wbs_dat_i[9] gnd 0.63fF
C2288 wbs_adr_i[9] gnd 0.63fF
C2289 wbs_dat_o[8] gnd 0.63fF
C2290 wbs_dat_i[8] gnd 0.63fF
C2291 wbs_adr_i[8] gnd 0.63fF
C2292 wbs_dat_o[7] gnd 0.63fF
C2293 wbs_dat_i[7] gnd 0.63fF
C2294 wbs_adr_i[7] gnd 0.63fF
C2295 wbs_dat_o[6] gnd 0.63fF
C2296 wbs_dat_i[6] gnd 0.63fF
C2297 wbs_adr_i[6] gnd 0.63fF
C2298 wbs_dat_o[5] gnd 0.63fF
C2299 wbs_dat_i[5] gnd 0.63fF
C2300 wbs_adr_i[5] gnd 0.63fF
C2301 wbs_dat_o[4] gnd 0.63fF
C2302 wbs_dat_i[4] gnd 0.63fF
C2303 wbs_adr_i[4] gnd 0.63fF
C2304 wbs_sel_i[3] gnd 0.63fF
C2305 wbs_dat_o[3] gnd 0.63fF
C2306 wbs_dat_i[3] gnd 0.63fF
C2307 wbs_adr_i[3] gnd 0.63fF
C2308 wbs_sel_i[2] gnd 0.63fF
C2309 wbs_dat_o[2] gnd 0.63fF
C2310 wbs_dat_i[2] gnd 0.63fF
C2311 wbs_adr_i[2] gnd 0.63fF
C2312 wbs_sel_i[1] gnd 0.63fF
C2313 wbs_dat_o[1] gnd 0.63fF
C2314 wbs_dat_i[1] gnd 0.63fF
C2315 wbs_adr_i[1] gnd 0.63fF
C2316 wbs_sel_i[0] gnd 0.63fF
C2317 wbs_dat_o[0] gnd 0.63fF
C2318 wbs_dat_i[0] gnd 0.63fF
C2319 wbs_adr_i[0] gnd 0.63fF
C2320 wbs_we_i gnd 0.63fF
C2321 wbs_stb_i gnd 0.63fF
C2322 wbs_cyc_i gnd 0.63fF
C2323 wbs_ack_o gnd 0.63fF
C2324 wb_rst_i gnd 0.63fF
C2325 wb_clk_i gnd 0.63fF
C2326 m2_494098_659718# gnd 0.80fF **FLOATING
C2327 pll_full_0/divider_0/and_0/Z1 gnd 0.65fF
C2328 pll_full_0/divider_0/and_0/B gnd 2.45fF
C2329 pll_full_0/divider_0/and_0/A gnd 2.35fF
C2330 pll_full_0/divider_0/and_0/out1 gnd 2.99fF
C2331 pll_full_0/divider_0/tspc_2/Z4 gnd 0.86fF
C2332 pll_full_0/divider_0/tspc_2/Z3 gnd 2.26fF
C2333 pll_full_0/divider_0/tspc_2/Z2 gnd 1.46fF
C2334 pll_full_0/divider_0/tspc_2/Z1 gnd 0.99fF
C2335 pll_full_0/divider_0/nor_0/A gnd 7.08fF
C2336 pll_full_0/divider_0/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2337 pll_full_0/divider_0/tspc_1/Z4 gnd 0.86fF
C2338 pll_full_0/divider_0/tspc_1/Z3 gnd 2.26fF
C2339 pll_full_0/divider_0/tspc_1/Z2 gnd 1.46fF
C2340 pll_full_0/divider_0/tspc_1/Z1 gnd 0.99fF
C2341 pll_full_0/divider_0/nor_0/B gnd 7.12fF
C2342 pll_full_0/divider_0/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2343 pll_full_0/divider_0/tspc_2/Q gnd 3.14fF
C2344 pll_full_0/divider_0/tspc_0/Z4 gnd 0.86fF
C2345 pll_full_0/divbuf_0/IN gnd 9.89fF
C2346 pll_full_0/divider_0/tspc_0/Z3 gnd 2.26fF
C2347 pll_full_0/divider_0/tspc_0/Z2 gnd 1.46fF
C2348 pll_full_0/divider_0/tspc_0/Z1 gnd 0.99fF
C2349 pll_full_0/divider_0/nor_1/B gnd 6.48fF
C2350 pll_full_0/divider_0/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2351 pll_full_0/divider_0/tspc_1/Q gnd 3.12fF
C2352 pll_full_0/divider_0/clk gnd 33.42fF
C2353 pll_full_0/divider_0/prescaler_0/nand_1/z1 gnd 0.36fF
C2354 pll_full_0/divider_0/prescaler_0/tspc_0/D gnd 2.64fF
C2355 pll_full_0/divider_0/prescaler_0/tspc_2/Q gnd 3.72fF
C2356 pll_full_0/divider_0/prescaler_0/tspc_1/Q gnd 3.61fF
C2357 pll_full_0/divider_0/prescaler_0/nand_0/z1 gnd 0.36fF
C2358 pll_full_0/divider_0/prescaler_0/tspc_2/D gnd 3.12fF
C2359 pll_full_0/divider_0/and_0/OUT gnd 5.67fF
C2360 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2361 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2362 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 gnd 1.19fF
C2363 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2364 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# gnd 1.47fF **FLOATING
C2365 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2366 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2367 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2368 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2369 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2370 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2371 pll_full_0/divider_0/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2372 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2373 pll_full_0/divider_0/prescaler_0/Out gnd 4.59fF
C2374 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2375 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2376 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2377 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2378 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2379 pll_full_0/divider_0/nor_1/Z1 gnd 1.34fF
C2380 pll_full_0/divider_0/nor_0/Z1 gnd 1.34fF
C2381 pll_full_0/divbuf_1/OUT gnd 363.82fF
C2382 pll_full_0/divbuf_1/OUT5 gnd 350.37fF
C2383 pll_full_0/divbuf_1/OUT4 gnd 133.72fF
C2384 pll_full_0/divbuf_1/OUT3 gnd 34.03fF
C2385 pll_full_0/divbuf_1/OUT2 gnd 8.71fF
C2386 pll_full_0/divbuf_1/a_492_n240# gnd 2.46fF **FLOATING
C2387 pll_full_0/divbuf_0/OUT5 gnd 350.37fF
C2388 pll_full_0/divbuf_0/OUT4 gnd 133.72fF
C2389 pll_full_0/divbuf_0/OUT3 gnd 34.03fF
C2390 pll_full_0/divbuf_0/OUT2 gnd 8.71fF
C2391 pll_full_0/divbuf_0/a_492_n240# gnd 2.46fF **FLOATING
C2392 pll_full_0/ro_complete_0/cbank_2/v gnd 16.43fF
C2393 pll_full_0/ro_complete_0/cbank_2/switch_5/vin gnd 0.78fF
C2394 pll_full_0/ro_complete_0/cbank_2/switch_4/vin gnd 1.50fF
C2395 pll_full_0/ro_complete_0/cbank_2/switch_2/vin gnd 1.30fF
C2396 pll_full_0/ro_complete_0/cbank_2/switch_3/vin gnd 0.56fF
C2397 pll_full_0/ro_complete_0/cbank_2/switch_1/vin gnd 1.14fF
C2398 pll_full_0/ro_complete_0/cbank_2/switch_0/vin gnd 1.02fF
C2399 pll_full_0/ro_complete_0/cbank_1/switch_5/vin gnd 0.78fF
C2400 pll_full_0/ro_complete_0/a0 gnd 5.35fF
C2401 pll_full_0/ro_complete_0/cbank_1/switch_4/vin gnd 1.50fF
C2402 pll_full_0/ro_complete_0/a1 gnd 6.54fF
C2403 pll_full_0/ro_complete_0/cbank_1/switch_2/vin gnd 1.30fF
C2404 pll_full_0/ro_complete_0/a3 gnd 5.96fF
C2405 pll_full_0/ro_complete_0/cbank_1/switch_3/vin gnd 0.56fF
C2406 pll_full_0/ro_complete_0/a2 gnd 5.21fF
C2407 pll_full_0/ro_complete_0/cbank_1/switch_1/vin gnd 1.14fF
C2408 pll_full_0/ro_complete_0/a4 gnd 5.81fF
C2409 pll_full_0/ro_complete_0/cbank_1/switch_0/vin gnd 1.02fF
C2410 pll_full_0/ro_complete_0/a5 gnd 6.74fF
C2411 pll_full_0/ro_complete_0/cbank_0/v gnd 15.12fF
C2412 pll_full_0/ro_complete_0/cbank_0/switch_5/vin gnd 0.78fF
C2413 pll_full_0/ro_complete_0/cbank_0/switch_4/vin gnd 1.50fF
C2414 pll_full_0/ro_complete_0/cbank_0/switch_2/vin gnd 1.30fF
C2415 pll_full_0/ro_complete_0/cbank_0/switch_3/vin gnd 0.56fF
C2416 pll_full_0/ro_complete_0/cbank_0/switch_1/vin gnd 1.14fF
C2417 pll_full_0/ro_complete_0/cbank_0/switch_0/vin gnd 1.02fF
C2418 pll_full_0/ro_complete_0/ro_var_extend_0/vcont gnd 0.27fF
C2419 pll_full_0/filter_0/a_4216_n5230# gnd 418.90fF **FLOATING
C2420 pll_full_0/filter_0/a_4216_n2998# gnd 1.39fF **FLOATING
C2421 pll_full_0/cp_0/down gnd 1.54fF
C2422 pll_full_0/cp_0/upbar gnd 1.79fF
C2423 pll_full_0/cp_0/a_7110_n2840# gnd 0.17fF **FLOATING
C2424 pll_full_0/cp_0/a_3060_n2840# gnd 1.71fF **FLOATING
C2425 pll_full_0/cp_0/a_7110_0# gnd 0.17fF **FLOATING
C2426 pll_full_0/cp_0/a_6370_0# gnd 0.40fF **FLOATING
C2427 pll_full_0/cp_0/a_3060_0# gnd 2.49fF **FLOATING
C2428 pll_full_0/cp_0/a_1710_0# gnd 7.47fF **FLOATING
C2429 pll_full_0/pd_0/UP gnd 6.41fF
C2430 pll_full_0/pd_0/and_pd_0/Z1 gnd 0.39fF
C2431 pll_full_0/pd_0/and_pd_0/Out1 gnd 2.22fF
C2432 pll_full_0/pd_0/tspc_r_1/z5 gnd 1.10fF
C2433 pll_full_0/pd_0/tspc_r_1/Z4 gnd 1.07fF
C2434 pll_full_0/pd_0/tspc_r_1/Qbar gnd 0.88fF
C2435 pll_full_0/pd_0/tspc_r_1/Z2 gnd 1.22fF
C2436 pll_full_0/pd_0/tspc_r_1/Z1 gnd 0.67fF
C2437 pll_full_0/pd_0/tspc_r_1/Qbar1 gnd 1.34fF
C2438 pll_full_0/pd_0/tspc_r_1/Z3 gnd 2.12fF
C2439 pll_full_0/pd_0/REF gnd 6.48fF
C2440 pll_full_0/pd_0/tspc_r_0/z5 gnd 1.10fF
C2441 pll_full_0/pd_0/tspc_r_0/Z4 gnd 1.07fF
C2442 pll_full_0/pd_0/R gnd 3.05fF
C2443 pll_full_0/pd_0/tspc_r_0/Qbar gnd 0.79fF
C2444 pll_full_0/pd_0/tspc_r_0/Z2 gnd 1.22fF
C2445 pll_full_0/pd_0/tspc_r_0/Z1 gnd 0.67fF
C2446 pll_full_0/pd_0/DOWN gnd 7.34fF
C2447 pll_full_0/pd_0/tspc_r_0/Qbar1 gnd 1.34fF
C2448 pll_full_0/pd_0/tspc_r_0/Z3 gnd 2.12fF
C2449 pll_full_0/pd_0/DIV gnd 372.69fF
C2450 divbuf_19/OUT gnd 363.82fF
C2451 divbuf_19/OUT5 gnd 350.37fF
C2452 divbuf_19/OUT4 gnd 133.72fF
C2453 divbuf_19/OUT3 gnd 34.03fF
C2454 divbuf_19/OUT2 gnd 8.71fF
C2455 divbuf_19/IN gnd 0.89fF
C2456 divbuf_19/a_492_n240# gnd 2.46fF **FLOATING
C2457 divbuf_18/OUT gnd 363.82fF
C2458 divbuf_18/OUT5 gnd 350.37fF
C2459 divbuf_18/OUT4 gnd 133.72fF
C2460 divbuf_18/OUT3 gnd 34.03fF
C2461 divbuf_18/OUT2 gnd 8.71fF
C2462 divbuf_18/IN gnd 0.89fF
C2463 divbuf_18/a_492_n240# gnd 2.46fF **FLOATING
C2464 divbuf_17/OUT gnd 363.82fF
C2465 divbuf_17/OUT5 gnd 350.37fF
C2466 divbuf_17/OUT4 gnd 133.72fF
C2467 divbuf_17/OUT3 gnd 34.03fF
C2468 divbuf_17/OUT2 gnd 8.71fF
C2469 divbuf_17/IN gnd 0.89fF
C2470 divbuf_17/a_492_n240# gnd 2.46fF **FLOATING
C2471 divider_2/and_0/Z1 gnd 0.74fF
C2472 divider_2/and_0/B gnd 2.25fF
C2473 divider_2/and_0/A gnd 2.19fF
C2474 divider_2/and_0/out1 gnd 2.93fF
C2475 divider_2/tspc_2/Z4 gnd 0.86fF
C2476 divider_2/tspc_2/Z3 gnd 2.26fF
C2477 divider_2/tspc_2/Z2 gnd 1.46fF
C2478 divider_2/tspc_2/Z1 gnd 0.99fF
C2479 divider_2/nor_0/A gnd 7.04fF
C2480 divider_2/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2481 divider_2/tspc_1/Z4 gnd 0.86fF
C2482 divider_2/tspc_1/Z3 gnd 2.26fF
C2483 divider_2/tspc_1/Z2 gnd 1.46fF
C2484 divider_2/tspc_1/Z1 gnd 0.99fF
C2485 divider_2/nor_0/B gnd 7.05fF
C2486 divider_2/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2487 divider_2/tspc_2/Q gnd 3.14fF
C2488 divider_2/tspc_0/Z4 gnd 0.86fF
C2489 divider_2/Out gnd 1.60fF
C2490 divider_2/tspc_0/Z3 gnd 2.26fF
C2491 divider_2/tspc_0/Z2 gnd 1.46fF
C2492 divider_2/tspc_0/Z1 gnd 0.99fF
C2493 divider_2/nor_1/B gnd 6.44fF
C2494 divider_2/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2495 divider_2/tspc_1/Q gnd 3.12fF
C2496 divider_2/clk gnd 5.63fF
C2497 divider_2/prescaler_0/nand_1/z1 gnd 0.36fF
C2498 divider_2/prescaler_0/tspc_0/D gnd 2.64fF
C2499 divider_2/prescaler_0/tspc_2/Q gnd 3.74fF
C2500 divider_2/prescaler_0/tspc_1/Q gnd 3.61fF
C2501 divider_2/prescaler_0/nand_0/z1 gnd 0.36fF
C2502 divider_2/prescaler_0/tspc_2/D gnd 3.12fF
C2503 divider_2/and_0/OUT gnd 5.62fF
C2504 divider_2/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2505 divider_2/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2506 divider_2/prescaler_0/tspc_2/Z2 gnd 1.46fF
C2507 divider_2/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2508 divider_2/prescaler_0/tspc_2/a_630_n680# gnd 1.14fF **FLOATING
C2509 divider_2/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2510 divider_2/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2511 divider_2/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2512 divider_2/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2513 divider_2/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2514 divider_2/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2515 divider_2/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2516 divider_2/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2517 divider_2/prescaler_0/Out gnd 4.59fF
C2518 divider_2/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2519 divider_2/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2520 divider_2/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2521 divider_2/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2522 divider_2/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2523 divider_2/nor_1/Z1 gnd 1.34fF
C2524 divider_2/mc2 gnd 5.29fF
C2525 divider_2/nor_0/Z1 gnd 1.34fF
C2526 divbuf_16/OUT gnd 363.82fF
C2527 divbuf_16/OUT5 gnd 350.37fF
C2528 divbuf_16/OUT4 gnd 133.72fF
C2529 divbuf_16/OUT3 gnd 34.03fF
C2530 divbuf_16/OUT2 gnd 8.71fF
C2531 divbuf_16/IN gnd 0.89fF
C2532 divbuf_16/a_492_n240# gnd 2.46fF **FLOATING
C2533 divider_1/and_0/Z1 gnd 0.74fF
C2534 divider_1/and_0/B gnd 2.25fF
C2535 divider_1/and_0/A gnd 2.19fF
C2536 divider_1/and_0/out1 gnd 2.93fF
C2537 divider_1/tspc_2/Z4 gnd 0.86fF
C2538 divider_1/tspc_2/Z3 gnd 2.26fF
C2539 divider_1/tspc_2/Z2 gnd 1.46fF
C2540 divider_1/tspc_2/Z1 gnd 0.99fF
C2541 divider_1/nor_0/A gnd 7.04fF
C2542 divider_1/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2543 divider_1/tspc_1/Z4 gnd 0.86fF
C2544 divider_1/tspc_1/Z3 gnd 2.26fF
C2545 divider_1/tspc_1/Z2 gnd 1.46fF
C2546 divider_1/tspc_1/Z1 gnd 0.99fF
C2547 divider_1/nor_0/B gnd 7.05fF
C2548 divider_1/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2549 divider_1/tspc_2/Q gnd 3.14fF
C2550 divider_1/tspc_0/Z4 gnd 0.86fF
C2551 divider_1/Out gnd 1.60fF
C2552 divider_1/tspc_0/Z3 gnd 2.26fF
C2553 divider_1/tspc_0/Z2 gnd 1.46fF
C2554 divider_1/tspc_0/Z1 gnd 0.99fF
C2555 divider_1/nor_1/B gnd 6.33fF
C2556 divider_1/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2557 divider_1/tspc_1/Q gnd 3.12fF
C2558 divider_1/clk gnd 5.63fF
C2559 divider_1/prescaler_0/nand_1/z1 gnd 0.36fF
C2560 divider_1/prescaler_0/tspc_0/D gnd 2.64fF
C2561 divider_1/prescaler_0/tspc_2/Q gnd 3.74fF
C2562 divider_1/prescaler_0/tspc_1/Q gnd 3.61fF
C2563 divider_1/prescaler_0/nand_0/z1 gnd 0.36fF
C2564 divider_1/prescaler_0/tspc_2/D gnd 3.12fF
C2565 divider_1/and_0/OUT gnd 5.62fF
C2566 divider_1/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2567 divider_1/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2568 divider_1/prescaler_0/tspc_2/Z2 gnd 1.46fF
C2569 divider_1/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2570 divider_1/prescaler_0/tspc_2/a_630_n680# gnd 1.14fF **FLOATING
C2571 divider_1/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2572 divider_1/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2573 divider_1/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2574 divider_1/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2575 divider_1/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2576 divider_1/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2577 divider_1/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2578 divider_1/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2579 divider_1/prescaler_0/Out gnd 4.59fF
C2580 divider_1/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2581 divider_1/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2582 divider_1/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2583 divider_1/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2584 divider_1/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2585 divider_1/nor_1/Z1 gnd 1.34fF
C2586 divider_1/mc2 gnd 5.29fF
C2587 divider_1/nor_0/Z1 gnd 1.34fF
C2588 divbuf_15/OUT gnd 363.82fF
C2589 divbuf_15/OUT5 gnd 350.37fF
C2590 divbuf_15/OUT4 gnd 133.72fF
C2591 divbuf_15/OUT3 gnd 34.03fF
C2592 divbuf_15/OUT2 gnd 8.71fF
C2593 divbuf_15/IN gnd 0.89fF
C2594 divbuf_15/a_492_n240# gnd 2.46fF **FLOATING
C2595 divbuf_25/OUT5 gnd 350.37fF
C2596 divbuf_25/OUT4 gnd 133.72fF
C2597 divbuf_25/OUT3 gnd 34.03fF
C2598 divbuf_25/OUT2 gnd 8.71fF
C2599 divbuf_25/IN gnd 0.89fF
C2600 divbuf_25/a_492_n240# gnd 2.46fF **FLOATING
C2601 divbuf_14/OUT gnd 363.82fF
C2602 divbuf_14/OUT5 gnd 350.37fF
C2603 divbuf_14/OUT4 gnd 133.72fF
C2604 divbuf_14/OUT3 gnd 34.03fF
C2605 divbuf_14/OUT2 gnd 8.71fF
C2606 divbuf_14/IN gnd 0.89fF
C2607 divbuf_14/a_492_n240# gnd 2.46fF **FLOATING
C2608 divider_0/and_0/Z1 gnd 0.74fF
C2609 divider_0/and_0/B gnd 2.25fF
C2610 divider_0/and_0/A gnd 2.19fF
C2611 divider_0/and_0/out1 gnd 2.93fF
C2612 divider_0/tspc_2/Z4 gnd 0.86fF
C2613 divider_0/tspc_2/Z3 gnd 2.26fF
C2614 divider_0/tspc_2/Z2 gnd 1.46fF
C2615 divider_0/tspc_2/Z1 gnd 0.99fF
C2616 divider_0/nor_0/A gnd 7.04fF
C2617 divider_0/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2618 divider_0/tspc_1/Z4 gnd 0.86fF
C2619 divider_0/tspc_1/Z3 gnd 2.26fF
C2620 divider_0/tspc_1/Z2 gnd 1.46fF
C2621 divider_0/tspc_1/Z1 gnd 0.99fF
C2622 divider_0/nor_0/B gnd 7.05fF
C2623 divider_0/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2624 divider_0/tspc_2/Q gnd 3.14fF
C2625 divider_0/tspc_0/Z4 gnd 0.86fF
C2626 divider_0/Out gnd 1.60fF
C2627 divider_0/tspc_0/Z3 gnd 2.26fF
C2628 divider_0/tspc_0/Z2 gnd 1.46fF
C2629 divider_0/tspc_0/Z1 gnd 0.99fF
C2630 divider_0/nor_1/B gnd 6.33fF
C2631 divider_0/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2632 divider_0/tspc_1/Q gnd 3.12fF
C2633 divider_0/clk gnd 5.63fF
C2634 divider_0/prescaler_0/nand_1/z1 gnd 0.36fF
C2635 divider_0/prescaler_0/tspc_0/D gnd 2.64fF
C2636 divider_0/prescaler_0/tspc_2/Q gnd 3.64fF
C2637 divider_0/prescaler_0/tspc_1/Q gnd 3.61fF
C2638 divider_0/prescaler_0/nand_0/z1 gnd 0.36fF
C2639 divider_0/prescaler_0/tspc_2/D gnd 3.12fF
C2640 divider_0/and_0/OUT gnd 5.62fF
C2641 divider_0/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2642 divider_0/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2643 divider_0/prescaler_0/tspc_2/Z2 gnd 1.46fF
C2644 divider_0/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2645 divider_0/prescaler_0/tspc_2/a_630_n680# gnd 1.14fF **FLOATING
C2646 divider_0/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2647 divider_0/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2648 divider_0/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2649 divider_0/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2650 divider_0/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2651 divider_0/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2652 divider_0/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2653 divider_0/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2654 divider_0/prescaler_0/Out gnd 4.59fF
C2655 divider_0/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2656 divider_0/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2657 divider_0/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2658 divider_0/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2659 divider_0/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2660 divider_0/nor_1/Z1 gnd 1.34fF
C2661 divider_0/mc2 gnd 5.29fF
C2662 divider_0/nor_0/Z1 gnd 1.34fF
C2663 divbuf_24/OUT gnd 363.82fF
C2664 divbuf_24/OUT5 gnd 350.37fF
C2665 divbuf_24/OUT4 gnd 133.72fF
C2666 divbuf_24/OUT3 gnd 34.03fF
C2667 divbuf_24/OUT2 gnd 8.71fF
C2668 divbuf_24/IN gnd 0.89fF
C2669 divbuf_24/a_492_n240# gnd 2.46fF **FLOATING
C2670 divbuf_13/OUT gnd 363.82fF
C2671 divbuf_13/OUT5 gnd 350.37fF
C2672 divbuf_13/OUT4 gnd 133.72fF
C2673 divbuf_13/OUT3 gnd 34.03fF
C2674 divbuf_13/OUT2 gnd 8.71fF
C2675 divbuf_13/IN gnd 0.89fF
C2676 divbuf_13/a_492_n240# gnd 2.46fF **FLOATING
C2677 divbuf_9/OUT gnd 363.82fF
C2678 divbuf_9/OUT5 gnd 350.37fF
C2679 divbuf_9/OUT4 gnd 133.72fF
C2680 divbuf_9/OUT3 gnd 34.03fF
C2681 divbuf_9/OUT2 gnd 8.71fF
C2682 divbuf_9/IN gnd 0.89fF
C2683 divbuf_9/a_492_n240# gnd 2.46fF **FLOATING
C2684 divbuf_23/OUT gnd 363.82fF
C2685 divbuf_23/OUT5 gnd 350.37fF
C2686 divbuf_23/OUT4 gnd 133.72fF
C2687 divbuf_23/OUT3 gnd 34.03fF
C2688 divbuf_23/OUT2 gnd 8.71fF
C2689 divbuf_23/IN gnd 0.89fF
C2690 divbuf_23/a_492_n240# gnd 2.46fF **FLOATING
C2691 divbuf_12/OUT gnd 363.82fF
C2692 divbuf_12/OUT5 gnd 350.37fF
C2693 divbuf_12/OUT4 gnd 133.72fF
C2694 divbuf_12/OUT3 gnd 34.03fF
C2695 divbuf_12/OUT2 gnd 8.71fF
C2696 divbuf_12/IN gnd 0.89fF
C2697 divbuf_12/a_492_n240# gnd 2.46fF **FLOATING
C2698 divbuf_8/OUT gnd 363.82fF
C2699 divbuf_8/OUT5 gnd 350.37fF
C2700 divbuf_8/OUT4 gnd 133.72fF
C2701 divbuf_8/OUT3 gnd 34.03fF
C2702 divbuf_8/OUT2 gnd 8.71fF
C2703 divbuf_8/IN gnd 0.89fF
C2704 divbuf_8/a_492_n240# gnd 2.46fF **FLOATING
C2705 divbuf_22/OUT gnd 363.82fF
C2706 divbuf_22/OUT5 gnd 350.37fF
C2707 divbuf_22/OUT4 gnd 133.72fF
C2708 divbuf_22/OUT3 gnd 34.03fF
C2709 divbuf_22/OUT2 gnd 8.71fF
C2710 divbuf_22/IN gnd 0.89fF
C2711 divbuf_22/a_492_n240# gnd 2.46fF **FLOATING
C2712 divbuf_11/OUT gnd 363.82fF
C2713 divbuf_11/OUT5 gnd 350.37fF
C2714 divbuf_11/OUT4 gnd 133.72fF
C2715 divbuf_11/OUT3 gnd 34.03fF
C2716 divbuf_11/OUT2 gnd 8.71fF
C2717 divbuf_11/IN gnd 0.89fF
C2718 divbuf_11/a_492_n240# gnd 2.46fF **FLOATING
C2719 divbuf_7/OUT5 gnd 350.37fF
C2720 divbuf_7/OUT4 gnd 133.72fF
C2721 divbuf_7/OUT3 gnd 34.03fF
C2722 divbuf_7/OUT2 gnd 8.71fF
C2723 divbuf_7/IN gnd 0.89fF
C2724 divbuf_7/a_492_n240# gnd 2.46fF **FLOATING
C2725 divbuf_21/OUT gnd 363.82fF
C2726 divbuf_21/OUT5 gnd 350.37fF
C2727 divbuf_21/OUT4 gnd 133.72fF
C2728 divbuf_21/OUT3 gnd 34.03fF
C2729 divbuf_21/OUT2 gnd 8.71fF
C2730 divbuf_21/IN gnd 0.89fF
C2731 divbuf_21/a_492_n240# gnd 2.46fF **FLOATING
C2732 divbuf_20/OUT gnd 363.82fF
C2733 divbuf_20/OUT5 gnd 350.37fF
C2734 divbuf_20/OUT4 gnd 133.72fF
C2735 divbuf_20/OUT3 gnd 34.03fF
C2736 divbuf_20/OUT2 gnd 8.71fF
C2737 divbuf_20/IN gnd 0.89fF
C2738 divbuf_20/a_492_n240# gnd 2.46fF **FLOATING
C2739 divbuf_10/OUT gnd 363.82fF
C2740 divbuf_10/OUT5 gnd 350.37fF
C2741 divbuf_10/OUT4 gnd 133.72fF
C2742 divbuf_10/OUT3 gnd 34.03fF
C2743 divbuf_10/OUT2 gnd 8.71fF
C2744 divbuf_10/IN gnd 0.89fF
C2745 divbuf_10/a_492_n240# gnd 2.46fF **FLOATING
C2746 divbuf_6/OUT5 gnd 350.37fF
C2747 divbuf_6/OUT4 gnd 133.72fF
C2748 divbuf_6/OUT3 gnd 34.03fF
C2749 divbuf_6/OUT2 gnd 8.71fF
C2750 divbuf_6/IN gnd 0.89fF
C2751 divbuf_6/a_492_n240# gnd 2.46fF **FLOATING
C2752 divbuf_5/OUT5 gnd 350.37fF
C2753 divbuf_5/OUT4 gnd 133.72fF
C2754 divbuf_5/OUT3 gnd 34.03fF
C2755 divbuf_5/OUT2 gnd 8.71fF
C2756 divbuf_5/IN gnd 0.89fF
C2757 divbuf_5/a_492_n240# gnd 2.46fF **FLOATING
C2758 divbuf_4/OUT5 gnd 350.37fF
C2759 divbuf_4/OUT4 gnd 133.72fF
C2760 divbuf_4/OUT3 gnd 34.03fF
C2761 divbuf_4/OUT2 gnd 8.71fF
C2762 divbuf_4/IN gnd 0.89fF
C2763 divbuf_4/a_492_n240# gnd 2.46fF **FLOATING
C2764 divbuf_3/OUT5 gnd 350.37fF
C2765 divbuf_3/OUT4 gnd 133.72fF
C2766 divbuf_3/OUT3 gnd 34.03fF
C2767 divbuf_3/OUT2 gnd 8.71fF
C2768 divbuf_3/IN gnd 0.89fF
C2769 divbuf_3/a_492_n240# gnd 2.46fF **FLOATING
C2770 divbuf_2/OUT5 gnd 350.37fF
C2771 divbuf_2/OUT4 gnd 133.72fF
C2772 divbuf_2/OUT3 gnd 34.03fF
C2773 divbuf_2/OUT2 gnd 8.71fF
C2774 divbuf_2/IN gnd 0.89fF
C2775 divbuf_2/a_492_n240# gnd 2.46fF **FLOATING
C2776 divbuf_1/OUT gnd 363.82fF
C2777 divbuf_1/OUT5 gnd 350.37fF
C2778 divbuf_1/OUT4 gnd 133.72fF
C2779 divbuf_1/OUT3 gnd 34.03fF
C2780 divbuf_1/OUT2 gnd 8.71fF
C2781 divbuf_1/IN gnd 0.89fF
C2782 divbuf_1/a_492_n240# gnd 2.46fF **FLOATING
C2783 ro_complete_1/cbank_2/v gnd 16.43fF
C2784 ro_complete_1/cbank_2/switch_5/vin gnd 0.78fF
C2785 ro_complete_1/cbank_2/switch_4/vin gnd 1.50fF
C2786 ro_complete_1/cbank_2/switch_2/vin gnd 1.30fF
C2787 ro_complete_1/cbank_2/switch_3/vin gnd 0.56fF
C2788 ro_complete_1/cbank_2/switch_1/vin gnd 1.14fF
C2789 ro_complete_1/cbank_2/switch_0/vin gnd 1.02fF
C2790 ro_complete_1/cbank_1/v gnd 16.43fF
C2791 ro_complete_1/cbank_1/switch_5/vin gnd 0.78fF
C2792 ro_complete_1/a0 gnd 5.35fF
C2793 ro_complete_1/cbank_1/switch_4/vin gnd 1.50fF
C2794 ro_complete_1/a1 gnd 6.54fF
C2795 ro_complete_1/cbank_1/switch_2/vin gnd 1.30fF
C2796 ro_complete_1/a3 gnd 5.96fF
C2797 ro_complete_1/cbank_1/switch_3/vin gnd 0.56fF
C2798 ro_complete_1/a2 gnd 5.21fF
C2799 ro_complete_1/cbank_1/switch_1/vin gnd 1.14fF
C2800 ro_complete_1/a4 gnd 5.81fF
C2801 ro_complete_1/cbank_1/switch_0/vin gnd 1.02fF
C2802 ro_complete_1/a5 gnd 6.74fF
C2803 ro_complete_1/cbank_0/v gnd 15.12fF
C2804 ro_complete_1/cbank_0/switch_5/vin gnd 0.78fF
C2805 ro_complete_1/cbank_0/switch_4/vin gnd 1.50fF
C2806 ro_complete_1/cbank_0/switch_2/vin gnd 1.30fF
C2807 ro_complete_1/cbank_0/switch_3/vin gnd 0.56fF
C2808 ro_complete_1/cbank_0/switch_1/vin gnd 1.14fF
C2809 ro_complete_1/cbank_0/switch_0/vin gnd 1.02fF
C2810 ro_complete_1/ro_var_extend_0/vcont gnd 0.27fF
C2811 divbuf_0/OUT gnd 363.82fF
C2812 divbuf_0/OUT5 gnd 350.37fF
C2813 divbuf_0/OUT4 gnd 133.72fF
C2814 divbuf_0/OUT3 gnd 34.03fF
C2815 divbuf_0/OUT2 gnd 8.71fF
C2816 divbuf_0/IN gnd 0.89fF
C2817 divbuf_0/a_492_n240# gnd 2.46fF **FLOATING
C2818 ro_complete_0/cbank_2/v gnd 16.43fF
C2819 ro_complete_0/cbank_2/switch_5/vin gnd 0.78fF
C2820 ro_complete_0/cbank_2/switch_4/vin gnd 1.50fF
C2821 ro_complete_0/cbank_2/switch_2/vin gnd 1.30fF
C2822 ro_complete_0/cbank_2/switch_3/vin gnd 0.56fF
C2823 ro_complete_0/cbank_2/switch_1/vin gnd 1.14fF
C2824 ro_complete_0/cbank_2/switch_0/vin gnd 1.02fF
C2825 ro_complete_0/cbank_1/v gnd 16.46fF
C2826 ro_complete_0/cbank_1/switch_5/vin gnd 0.78fF
C2827 divbuf_7/OUT gnd 405.76fF
C2828 ro_complete_0/cbank_1/switch_4/vin gnd 1.50fF
C2829 divbuf_6/OUT gnd 402.77fF
C2830 ro_complete_0/cbank_1/switch_2/vin gnd 1.30fF
C2831 divbuf_3/OUT gnd 394.74fF
C2832 ro_complete_0/cbank_1/switch_3/vin gnd 0.56fF
C2833 divbuf_5/OUT gnd 397.92fF
C2834 ro_complete_0/cbank_1/switch_1/vin gnd 1.14fF
C2835 divbuf_4/OUT gnd 391.26fF
C2836 ro_complete_0/cbank_1/switch_0/vin gnd 1.02fF
C2837 divbuf_2/OUT gnd 387.66fF
C2838 ro_complete_0/cbank_0/v gnd 15.12fF
C2839 ro_complete_0/cbank_0/switch_5/vin gnd 0.78fF
C2840 ro_complete_0/cbank_0/switch_4/vin gnd 1.50fF
C2841 ro_complete_0/cbank_0/switch_2/vin gnd 1.30fF
C2842 ro_complete_0/cbank_0/switch_3/vin gnd 0.56fF
C2843 ro_complete_0/cbank_0/switch_1/vin gnd 1.14fF
C2844 ro_complete_0/cbank_0/switch_0/vin gnd 1.02fF
C2845 ro_complete_0/ro_var_extend_0/vcont gnd 0.27fF
C2846 filter_0/v gnd 477.90fF
C2847 filter_0/a_4216_n5230# gnd 418.47fF **FLOATING
C2848 filter_0/a_4216_n2998# gnd 1.03fF **FLOATING
C2849 cp_0/down gnd 1.54fF
C2850 cp_0/vbias gnd 2.41fF
C2851 cp_0/out gnd 5.34fF
C2852 cp_0/upbar gnd 1.50fF
C2853 cp_0/a_7110_n2840# gnd 0.17fF **FLOATING
C2854 cp_0/a_3060_n2840# gnd 1.71fF **FLOATING
C2855 cp_0/a_7110_0# gnd 0.17fF **FLOATING
C2856 cp_0/a_6370_0# gnd 0.40fF **FLOATING
C2857 cp_0/a_3060_0# gnd 1.66fF **FLOATING
C2858 cp_0/a_1710_0# gnd 5.89fF **FLOATING
C2859 cp_0/a_1710_n2840# gnd 4.91fF **FLOATING
C2860 cp_0/a_10_n50# gnd 2.96fF **FLOATING
C2861 pd_1/UP gnd 2.21fF
C2862 pd_1/and_pd_0/Z1 gnd 0.39fF
C2863 pd_1/and_pd_0/Out1 gnd 2.22fF
C2864 pd_1/tspc_r_1/z5 gnd 1.10fF
C2865 pd_1/tspc_r_1/Z4 gnd 1.07fF
C2866 pd_1/tspc_r_1/Qbar gnd 0.88fF
C2867 pd_1/tspc_r_1/Z2 gnd 1.22fF
C2868 pd_1/tspc_r_1/Z1 gnd 0.67fF
C2869 pd_1/tspc_r_1/Qbar1 gnd 1.34fF
C2870 pd_1/tspc_r_1/Z3 gnd 2.12fF
C2871 pd_1/REF gnd 1.80fF
C2872 pd_1/tspc_r_0/z5 gnd 1.10fF
C2873 pd_1/tspc_r_0/Z4 gnd 1.07fF
C2874 pd_1/R gnd 3.05fF
C2875 pd_1/tspc_r_0/Qbar gnd 0.79fF
C2876 pd_1/tspc_r_0/Z2 gnd 1.22fF
C2877 pd_1/tspc_r_0/Z1 gnd 0.67fF
C2878 pd_1/DOWN gnd 3.08fF
C2879 pd_1/tspc_r_0/Qbar1 gnd 1.34fF
C2880 pd_1/tspc_r_0/Z3 gnd 2.12fF
C2881 pd_1/DIV gnd 1.82fF
C2882 pd_0/UP gnd 2.21fF
C2883 pd_0/and_pd_0/Z1 gnd 0.39fF
C2884 pd_0/and_pd_0/Out1 gnd 2.22fF
C2885 pd_0/tspc_r_1/z5 gnd 1.10fF
C2886 pd_0/tspc_r_1/Z4 gnd 1.07fF
C2887 pd_0/tspc_r_1/Qbar gnd 0.88fF
C2888 pd_0/tspc_r_1/Z2 gnd 1.22fF
C2889 pd_0/tspc_r_1/Z1 gnd 0.67fF
C2890 pd_0/tspc_r_1/Qbar1 gnd 1.34fF
C2891 pd_0/tspc_r_1/Z3 gnd 2.12fF
C2892 pd_0/REF gnd 1.80fF
C2893 pd_0/tspc_r_0/z5 gnd 1.10fF
C2894 pd_0/tspc_r_0/Z4 gnd 1.07fF
C2895 pd_0/R gnd 3.05fF
C2896 pd_0/tspc_r_0/Qbar gnd 0.79fF
C2897 pd_0/tspc_r_0/Z2 gnd 1.22fF
C2898 pd_0/tspc_r_0/Z1 gnd 0.67fF
C2899 pd_0/DOWN gnd 3.08fF
C2900 pd_0/tspc_r_0/Qbar1 gnd 1.34fF
C2901 pd_0/tspc_r_0/Z3 gnd 2.12fF
C2902 pd_0/DIV gnd 1.82fF
.ends
