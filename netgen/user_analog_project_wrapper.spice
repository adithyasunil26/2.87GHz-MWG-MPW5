* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[5] io_analog[6] io_analog[7]
+ io_analog[8] io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
C0 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C2 divider_1/nor_0/B divider_1/tspc_1/Q 0.51fF
C3 divbuf_11/a_492_n240# divbuf_11/OUT 0.00fF
C4 divider_2/prescaler_0/Out divider_2/prescaler_0/m1_2700_2190# 0.11fF
C5 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z3 0.06fF
C6 cp_0/a_1710_n2840# cp_0/upbar 0.29fF
C7 pd_1/R pd_1/REF 0.61fF
C8 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/switch_1/vin 0.19fF
C9 divbuf_14/OUT3 divbuf_14/OUT5 0.01fF
C10 divbuf_14/OUT2 divbuf_14/OUT 0.06fF
C11 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar 0.03fF
C12 divbuf_16/a_492_n240# divbuf_16/OUT2 0.42fF
C13 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z4 0.36fF
C14 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C15 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C16 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C17 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/Out 0.04fF
C18 divider_0/tspc_2/Z1 divider_0/tspc_2/Z3 0.06fF
C19 divbuf_22/OUT divbuf_22/OUT3 0.26fF
C20 divbuf_10/a_492_n240# divbuf_10/IN 0.13fF
C21 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C22 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C23 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/clk 0.14fF
C24 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/B 0.78fF
C25 divider_1/tspc_1/Z2 divider_1/tspc_1/Z4 0.36fF
C26 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/D 0.05fF
C27 divbuf_7/OUT4 divbuf_7/OUT 1.11fF
C28 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z1 0.09fF
C29 pd_0/DIV pd_0/tspc_r_0/Z2 0.19fF
C30 divbuf_17/OUT5 divbuf_17/OUT2 0.02fF
C31 divider_2/mc2 divider_2/prescaler_0/tspc_2/a_630_n680# 0.33fF
C32 cp_0/upbar cp_0/down 0.02fF
C33 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/z5 0.20fF
C34 divbuf_13/a_492_n240# divbuf_13/OUT5 0.01fF
C35 divbuf_20/OUT ro_complete_0/cbank_1/switch_2/vin 0.14fF
C36 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Out1 0.05fF
C37 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C38 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z3 0.16fF
C39 divider_0/mc2 divider_0/and_0/B 0.20fF
C40 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/v 1.30fF
C41 pll_full_0/divbuf_0/OUT2 pll_full_0/divbuf_0/a_492_n240# 0.42fF
C42 divider_2/tspc_1/Q divider_2/tspc_0/Z4 0.15fF
C43 divbuf_23/OUT divbuf_23/OUT5 43.38fF
C44 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C45 divbuf_6/OUT2 divbuf_6/OUT3 1.37fF
C46 divider_2/nor_1/Z1 divider_2/nor_0/B 0.18fF
C47 divider_1/tspc_1/Z4 divider_1/nor_0/A 0.02fF
C48 pd_0/R pd_0/tspc_r_1/Qbar 0.03fF
C49 divbuf_18/OUT3 divbuf_18/OUT2 1.37fF
C50 pd_1/and_pd_0/Out1 pd_1/and_pd_0/Z1 0.18fF
C51 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/R 0.21fF
C52 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/z5 0.03fF
C53 divider_2/nor_0/A divider_2/and_0/B 0.08fF
C54 divbuf_9/OUT3 divbuf_9/OUT 0.26fF
C55 divbuf_9/OUT4 divbuf_9/OUT5 20.26fF
C56 divider_0/nor_1/Z1 divider_0/nor_0/B 0.18fF
C57 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C58 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z4 0.00fF
C59 divbuf_21/a_492_n240# divbuf_21/OUT2 0.42fF
C60 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z4 0.12fF
C61 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z3 0.45fF
C62 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/nor_1/B 0.40fF
C63 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C64 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/B 0.01fF
C65 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z4 0.12fF
C66 divider_1/tspc_2/Z1 divider_1/tspc_2/Z2 1.07fF
C67 divider_1/nor_0/A divider_1/tspc_2/Z3 0.38fF
C68 divbuf_12/a_492_n240# divbuf_12/OUT 0.00fF
C69 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Out1 0.05fF
C70 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/Qbar 0.01fF
C71 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Q 0.20fF
C72 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/D 0.09fF
C73 filter_0/v divbuf_0/a_492_n240# 0.00fF
C74 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Z1 0.07fF
C75 ro_complete_1/a4 ro_complete_1/cbank_1/v 0.05fF
C76 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C77 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z4 0.12fF
C78 divider_0/tspc_1/Q divider_0/tspc_0/Z3 0.45fF
C79 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z4 0.28fF
C80 divider_1/prescaler_0/Out divider_1/tspc_2/Z3 0.45fF
C81 divider_0/and_0/OUT divider_0/and_0/B 0.01fF
C82 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/switch_5/vin 0.20fF
C83 divider_1/tspc_1/Q divider_1/tspc_1/Z3 0.05fF
C84 divider_1/tspc_1/Z1 divider_1/tspc_1/Z4 0.00fF
C85 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z3 0.06fF
C86 divbuf_20/IN divbuf_20/OUT5 0.00fF
C87 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C88 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C89 divbuf_7/a_492_n240# divbuf_7/IN 0.13fF
C90 divbuf_24/OUT4 divbuf_24/OUT 1.11fF
C91 cp_0/a_1710_n2840# cp_0/out 0.61fF
C92 pd_1/DOWN pd_1/and_pd_0/Out1 0.12fF
C93 pd_1/REF pd_1/tspc_r_1/Qbar1 0.12fF
C94 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/nand_1/z1 0.22fF
C95 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/tspc_0/D 0.04fF
C96 divbuf_20/OUT ro_complete_0/cbank_0/switch_2/vin 0.14fF
C97 ro_complete_0/cbank_0/switch_1/vin divbuf_21/OUT 0.09fF
C98 ro_complete_0/cbank_0/switch_0/vin divbuf_23/OUT 0.09fF
C99 pll_full_0/cp_0/upbar pll_full_0/cp_0/down 0.02fF
C100 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C101 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/z5 0.20fF
C102 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT2 0.02fF
C103 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Q 0.91fF
C104 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C105 divbuf_4/a_492_n240# divbuf_4/OUT 0.00fF
C106 divbuf_17/a_492_n240# divbuf_17/OUT5 0.01fF
C107 divbuf_17/OUT4 divbuf_17/OUT3 5.16fF
C108 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/Q 0.04fF
C109 divider_1/prescaler_0/tspc_1/Z3 divider_1/clk 0.45fF
C110 divbuf_23/OUT2 divbuf_23/OUT3 1.37fF
C111 divider_2/tspc_0/Z4 divider_2/tspc_0/a_630_n680# 0.12fF
C112 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z3 0.16fF
C113 divider_2/nor_0/A divider_2/tspc_2/Z2 0.23fF
C114 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/and_pd_0/Z1 0.18fF
C115 divbuf_21/OUT divbuf_21/OUT2 0.06fF
C116 divbuf_2/OUT4 divbuf_2/OUT 1.11fF
C117 ro_complete_1/a2 ro_complete_1/cbank_2/v 0.05fF
C118 divider_1/mc2 divider_1/prescaler_0/tspc_2/a_630_n680# 0.33fF
C119 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z4 0.12fF
C120 divbuf_5/OUT2 divbuf_5/OUT5 0.02fF
C121 divbuf_5/OUT3 divbuf_5/OUT4 5.16fF
C122 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C123 divbuf_22/a_492_n240# divbuf_22/OUT2 0.42fF
C124 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C125 divbuf_8/OUT5 divbuf_8/OUT 43.38fF
C126 pd_0/R pd_0/and_pd_0/Z1 0.02fF
C127 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/z5 0.20fF
C128 divider_2/nor_0/B divider_2/tspc_1/Z4 0.21fF
C129 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z4 0.12fF
C130 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z2 1.07fF
C131 divbuf_25/a_492_n240# divbuf_25/OUT 0.00fF
C132 divider_2/and_0/out1 divider_2/and_0/Z1 0.36fF
C133 divbuf_0/a_492_n240# divbuf_0/IN 0.13fF
C134 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/a_492_n240# 0.01fF
C135 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C136 ro_complete_1/cbank_1/switch_5/vin ro_complete_1/cbank_1/v 1.30fF
C137 divbuf_15/a_492_n240# divbuf_15/OUT5 0.01fF
C138 divider_0/prescaler_0/tspc_0/D divider_0/prescaler_0/nand_1/z1 0.21fF
C139 divider_1/prescaler_0/m1_2700_2190# divider_1/and_0/OUT 0.14fF
C140 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z4 0.15fF
C141 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C142 pll_full_0/ro_complete_0/a0 pll_full_0/divider_0/clk 0.11fF
C143 divbuf_11/IN divbuf_11/OUT5 0.00fF
C144 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z4 0.00fF
C145 divbuf_24/a_492_n240# divbuf_24/IN 0.13fF
C146 pd_1/R pd_1/tspc_r_1/Qbar1 0.30fF
C147 pd_1/tspc_r_0/Z3 pd_1/tspc_r_0/Qbar1 0.38fF
C148 pd_0/and_pd_0/Out1 pd_0/and_pd_0/Z1 0.18fF
C149 divider_2/tspc_2/Q divider_2/tspc_2/a_630_n680# 0.04fF
C150 divider_2/prescaler_0/tspc_1/Z2 divider_2/clk 0.11fF
C151 divbuf_14/OUT4 divbuf_14/OUT 1.11fF
C152 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Qbar1 0.12fF
C153 divbuf_18/OUT ro_complete_0/cbank_2/switch_5/vin 0.09fF
C154 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C155 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a4 0.09fF
C156 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a5 0.09fF
C157 divider_0/tspc_1/Q divider_0/tspc_0/Z4 0.15fF
C158 divbuf_22/OUT divbuf_22/OUT5 43.38fF
C159 divider_0/tspc_2/Z1 divider_0/tspc_2/Z4 0.00fF
C160 divider_1/prescaler_0/tspc_2/Z4 divider_1/prescaler_0/tspc_2/D 0.11fF
C161 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C162 pd_0/DIV pd_0/R 0.51fF
C163 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/a_630_n680# 0.19fF
C164 divbuf_13/OUT2 divbuf_13/OUT3 1.37fF
C165 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/tspc_r_0/Z2 0.71fF
C166 divbuf_21/OUT divbuf_23/OUT 1.95fF
C167 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/a2 0.09fF
C168 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/v 1.30fF
C169 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/IN 5.26fF
C170 ro_complete_1/a5 ro_complete_1/cbank_1/v 0.10fF
C171 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_0/vin 0.19fF
C172 divider_1/tspc_0/Z4 divider_1/tspc_0/Z2 0.36fF
C173 divider_1/Out divider_1/tspc_0/Z3 0.05fF
C174 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z4 0.36fF
C175 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C176 divbuf_18/OUT divbuf_18/OUT4 1.11fF
C177 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z2 0.01fF
C178 divider_1/prescaler_0/tspc_2/Z3 divider_1/clk 0.45fF
C179 divbuf_6/OUT2 divbuf_6/OUT5 0.02fF
C180 divbuf_6/OUT3 divbuf_6/OUT4 5.16fF
C181 pd_1/DIV pd_1/tspc_r_0/Qbar1 0.12fF
C182 pd_0/REF pd_0/tspc_r_1/Qbar1 0.12fF
C183 divbuf_18/OUT5 divbuf_18/OUT2 0.02fF
C184 divider_2/prescaler_0/Out divider_2/tspc_2/Z3 0.45fF
C185 divbuf_8/a_492_n240# divbuf_8/OUT2 0.42fF
C186 divbuf_9/OUT5 divbuf_9/OUT 43.38fF
C187 filter_0/a_4216_n2998# filter_0/v 0.36fF
C188 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z4 0.14fF
C189 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z2 0.01fF
C190 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/Out 0.21fF
C191 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/a2 0.09fF
C192 ro_complete_1/a4 ro_complete_1/cbank_2/switch_1/vin 0.09fF
C193 ro_complete_1/a0 ro_complete_1/cbank_1/switch_5/vin 0.09fF
C194 divbuf_16/OUT5 divbuf_16/OUT4 20.26fF
C195 pll_full_0/ro_complete_0/a3 pll_full_0/divider_0/clk 0.11fF
C196 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Z4 0.65fF
C197 divider_1/tspc_2/Z2 divider_1/tspc_2/Z3 0.16fF
C198 divider_1/nor_0/A divider_1/tspc_2/Z4 0.21fF
C199 pd_1/DOWN pd_1/tspc_r_0/Z3 0.03fF
C200 divider_2/tspc_1/Z3 divider_2/tspc_1/Z4 0.65fF
C201 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Q 0.04fF
C202 divbuf_12/IN divbuf_12/OUT5 0.00fF
C203 divbuf_14/a_492_n240# divbuf_14/IN 0.13fF
C204 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C205 divider_0/mc2 divider_0/and_0/OUT 0.05fF
C206 divider_0/tspc_0/Z1 divider_0/nor_1/B 0.03fF
C207 divbuf_3/a_492_n240# divbuf_3/OUT5 0.01fF
C208 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/v 1.30fF
C209 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C210 divider_1/prescaler_0/Out divider_1/tspc_2/Z4 0.12fF
C211 divbuf_20/OUT3 divbuf_20/OUT5 0.01fF
C212 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C213 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z4 0.00fF
C214 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Q 0.21fF
C215 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z3 0.65fF
C216 divbuf_19/OUT3 divbuf_19/OUT4 5.16fF
C217 divider_1/and_0/B divider_1/and_0/Z1 0.07fF
C218 pd_1/tspc_r_1/Z3 pd_1/UP 0.03fF
C219 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/nand_1/z1 0.01fF
C220 divider_2/prescaler_0/tspc_2/Z2 divider_2/clk 0.11fF
C221 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/D 0.09fF
C222 ro_complete_0/cbank_1/v ro_complete_0/cbank_2/v 1.36fF
C223 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT3 0.26fF
C224 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT4 20.26fF
C225 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C226 pll_full_0/filter_0/a_4216_n5230# pll_full_0/divider_0/clk 1.58fF
C227 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C228 divider_1/prescaler_0/tspc_1/Z4 divider_1/clk 0.12fF
C229 pd_0/DOWN pd_0/UP 0.46fF
C230 pd_0/tspc_r_0/Z4 pd_0/tspc_r_0/z5 0.04fF
C231 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z4 0.36fF
C232 divbuf_23/OUT2 divbuf_23/OUT5 0.02fF
C233 divbuf_23/OUT3 divbuf_23/OUT4 5.16fF
C234 divider_2/tspc_2/Z1 divider_2/tspc_2/Z3 0.06fF
C235 divbuf_9/a_492_n240# divbuf_9/OUT2 0.42fF
C236 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_0/vin 0.19fF
C237 divider_0/tspc_0/Z1 divider_0/tspc_0/Z2 1.07fF
C238 divbuf_16/OUT5 divbuf_16/OUT2 0.02fF
C239 divider_1/tspc_0/Z4 divider_1/nor_0/B 0.02fF
C240 divider_1/nor_1/Z1 divider_1/nor_1/B 0.06fF
C241 divbuf_15/IN divbuf_15/OUT5 0.00fF
C242 divbuf_20/OUT divbuf_20/OUT3 0.26fF
C243 divbuf_21/OUT divbuf_21/OUT4 1.11fF
C244 ro_complete_1/cbank_1/switch_2/vin ro_complete_1/cbank_1/v 1.30fF
C245 divbuf_5/OUT3 divbuf_5/OUT 0.26fF
C246 divbuf_5/OUT4 divbuf_5/OUT5 20.26fF
C247 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C248 divider_2/tspc_1/Q divider_2/tspc_0/a_630_n680# 0.01fF
C249 divider_1/prescaler_0/tspc_1/Q divider_1/clk 0.60fF
C250 pd_1/tspc_r_0/Z1 pd_1/tspc_r_0/Z3 0.09fF
C251 divider_2/tspc_2/Q divider_2/tspc_1/Z2 0.14fF
C252 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C253 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z3 0.16fF
C254 divbuf_25/IN divbuf_25/OUT5 0.00fF
C255 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/v 1.30fF
C256 divider_0/prescaler_0/Out divider_0/prescaler_0/m1_2700_2190# 0.11fF
C257 ro_complete_1/cbank_0/v ro_complete_1/cbank_2/v 0.04fF
C258 io_clamp_low[2] io_analog[6] 0.53fF
C259 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_1/B 0.47fF
C260 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/Z4 0.65fF
C261 divbuf_17/OUT4 divbuf_17/OUT5 20.26fF
C262 divider_1/nor_1/B divider_1/tspc_0/Z1 0.03fF
C263 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_2/D 0.16fF
C264 divbuf_11/OUT3 divbuf_11/OUT5 0.01fF
C265 divbuf_11/OUT2 divbuf_11/OUT 0.06fF
C266 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divider_0/tspc_2/Z4 0.65fF
C267 divider_2/tspc_2/Q divider_2/nor_0/A 0.55fF
C268 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/UP 0.03fF
C269 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_4/vin 0.20fF
C270 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_4/vin 0.20fF
C271 divbuf_18/OUT ro_complete_0/cbank_2/v 0.05fF
C272 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/a_630_n680# 0.19fF
C273 divider_0/nor_0/B divider_0/nor_1/B 0.47fF
C274 divider_0/tspc_0/Z3 divider_0/tspc_0/Z4 0.65fF
C275 divbuf_15/OUT5 divbuf_15/OUT4 20.26fF
C276 divider_0/tspc_2/Z3 divider_0/tspc_2/Z4 0.65fF
C277 divbuf_10/a_492_n240# divbuf_10/OUT5 0.01fF
C278 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C279 pd_1/DIV pd_1/tspc_r_0/Z1 0.17fF
C280 pd_0/tspc_r_0/Qbar1 pd_0/R 0.01fF
C281 pd_0/DIV pd_0/tspc_r_0/Z4 0.02fF
C282 pd_0/DOWN pd_0/tspc_r_0/Qbar 0.21fF
C283 divider_2/and_0/OUT divider_2/and_0/B 0.01fF
C284 divbuf_13/OUT2 divbuf_13/OUT5 0.02fF
C285 divbuf_13/OUT3 divbuf_13/OUT4 5.16fF
C286 ro_complete_0/cbank_1/switch_3/vin divbuf_19/OUT 0.14fF
C287 pll_full_0/pd_0/REF pll_full_0/divbuf_1/OUT5 0.00fF
C288 divbuf_2/OUT2 divbuf_2/a_492_n240# 0.42fF
C289 divider_1/Out divider_1/tspc_0/a_630_n680# 0.04fF
C290 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z2 0.19fF
C291 divbuf_15/OUT2 divbuf_15/OUT5 0.02fF
C292 divider_0/nor_0/B divider_0/tspc_2/a_630_n680# 0.01fF
C293 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C294 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_1/Q 0.14fF
C295 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/Out 0.04fF
C296 divbuf_6/OUT3 divbuf_6/OUT 0.26fF
C297 divbuf_6/OUT4 divbuf_6/OUT5 20.26fF
C298 divider_1/prescaler_0/tspc_2/Z4 divider_1/clk 0.12fF
C299 pd_0/tspc_r_1/Z3 pd_0/UP 0.03fF
C300 divider_2/tspc_1/Z1 divider_2/tspc_2/Q 0.01fF
C301 divider_2/prescaler_0/Out divider_2/tspc_2/Z4 0.12fF
C302 divider_2/nor_0/B divider_2/tspc_1/a_630_n680# 0.35fF
C303 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/a_630_n680# 0.19fF
C304 pll_full_0/pd_0/DOWN pll_full_0/pd_0/REF 1.48fF
C305 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/v 1.30fF
C306 divbuf_21/OUT ro_complete_0/cbank_2/switch_0/vin 0.12fF
C307 divider_0/tspc_0/Z2 divider_0/nor_0/B 0.20fF
C308 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/Out 0.04fF
C309 ro_complete_1/a0 ro_complete_1/cbank_1/v 0.05fF
C310 ro_complete_1/a3 ro_complete_1/cbank_2/v 0.05fF
C311 divbuf_16/OUT5 divbuf_16/OUT3 0.01fF
C312 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/B 0.18fF
C313 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C314 divbuf_17/OUT5 divbuf_17/OUT3 0.01fF
C315 divider_1/tspc_2/Z2 divider_1/tspc_2/Z4 0.36fF
C316 divbuf_12/OUT3 divbuf_12/OUT5 0.01fF
C317 divbuf_12/OUT2 divbuf_12/OUT 0.06fF
C318 pll_full_0/pd_0/DIV pll_full_0/pd_0/R 0.51fF
C319 pll_full_0/pd_0/R pll_full_0/pd_0/REF 0.61fF
C320 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/switch_5/vin 0.20fF
C321 divbuf_22/OUT ro_complete_0/cbank_2/v 0.05fF
C322 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C323 divbuf_3/OUT2 divbuf_3/OUT3 1.37fF
C324 divider_1/prescaler_0/tspc_0/Z3 divider_1/clk 0.64fF
C325 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C326 divbuf_19/OUT2 divbuf_19/OUT5 0.02fF
C327 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Z4 0.65fF
C328 divbuf_7/a_492_n240# divbuf_7/OUT5 0.01fF
C329 cp_0/a_10_n50# cp_0/vbias 0.19fF
C330 pd_1/R pd_1/and_pd_0/Out1 0.33fF
C331 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z1 0.09fF
C332 pd_1/REF pd_1/tspc_r_1/Z2 0.19fF
C333 divider_2/prescaler_0/tspc_0/D divider_2/prescaler_0/nand_1/z1 0.21fF
C334 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_0/a_740_n680# 0.21fF
C335 divbuf_1/OUT3 divbuf_1/OUT4 5.16fF
C336 divbuf_23/OUT divbuf_23/a_492_n240# 0.00fF
C337 divbuf_4/OUT2 divbuf_4/OUT3 1.37fF
C338 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C339 divbuf_17/OUT divbuf_17/OUT2 0.06fF
C340 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/a_630_n680# 0.04fF
C341 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C342 pd_0/R pd_0/REF 0.61fF
C343 divbuf_23/OUT4 divbuf_23/OUT5 20.26fF
C344 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT3 0.26fF
C345 divider_2/tspc_2/Z1 divider_2/tspc_2/Z4 0.00fF
C346 divbuf_22/OUT ro_complete_0/cbank_1/switch_2/vin 0.09fF
C347 divbuf_20/OUT divbuf_20/OUT5 43.38fF
C348 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/switch_5/vin 0.20fF
C349 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C350 divider_0/tspc_2/Q divider_0/tspc_2/a_630_n680# 0.04fF
C351 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/D 0.03fF
C352 divbuf_5/OUT5 divbuf_5/OUT 43.38fF
C353 divider_1/tspc_0/Z3 divider_1/nor_1/B 0.38fF
C354 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z3 0.33fF
C355 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z1 0.03fF
C356 pll_full_0/ro_complete_0/a4 pll_full_0/divider_0/clk 0.01fF
C357 divbuf_18/OUT3 divbuf_18/OUT5 0.01fF
C358 divider_2/tspc_0/Z2 divider_2/tspc_0/Z1 1.07fF
C359 divider_1/and_0/OUT divider_1/and_0/Z1 0.04fF
C360 divider_1/prescaler_0/tspc_2/Q divider_1/clk 0.05fF
C361 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/nor_0/A 0.03fF
C362 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z3 0.05fF
C363 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z4 0.36fF
C364 divbuf_25/OUT3 divbuf_25/OUT5 0.01fF
C365 divbuf_25/OUT2 divbuf_25/OUT 0.06fF
C366 divider_0/nor_0/B divider_0/tspc_1/Z1 0.03fF
C367 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_5/vin 0.20fF
C368 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C369 divider_0/prescaler_0/tspc_1/Q divider_0/nor_0/A 0.03fF
C370 divbuf_20/a_492_n240# divbuf_20/IN 0.13fF
C371 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/nand_0/z1 0.07fF
C372 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z2 0.30fF
C373 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z2 0.19fF
C374 divbuf_11/OUT4 divbuf_11/OUT 1.11fF
C375 pd_1/R pd_1/tspc_r_1/Z2 0.21fF
C376 divbuf_24/a_492_n240# divbuf_24/OUT5 0.01fF
C377 divbuf_18/OUT divbuf_18/OUT2 0.06fF
C378 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z1 0.09fF
C379 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z2 0.19fF
C380 divider_0/nor_0/B divider_0/tspc_1/Z2 0.30fF
C381 divbuf_2/OUT2 divbuf_2/OUT3 1.37fF
C382 ro_complete_1/cbank_2/switch_5/vin ro_complete_1/cbank_2/v 1.30fF
C383 divbuf_16/OUT4 divbuf_16/OUT3 5.16fF
C384 divbuf_15/OUT5 divbuf_15/OUT3 0.01fF
C385 divbuf_10/OUT2 divbuf_10/OUT3 1.37fF
C386 divider_2/nor_1/B divider_2/mc2 0.15fF
C387 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Q 0.05fF
C388 divider_1/prescaler_0/m1_2700_2190# divider_1/clk 0.01fF
C389 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z3 0.45fF
C390 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_0/A 1.21fF
C391 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/z5 0.11fF
C392 divbuf_19/a_492_n240# divbuf_19/OUT5 0.01fF
C393 divbuf_13/OUT3 divbuf_13/OUT 0.26fF
C394 divbuf_13/OUT4 divbuf_13/OUT5 20.26fF
C395 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/a5 0.09fF
C396 ro_complete_0/cbank_0/switch_3/vin divbuf_19/OUT 0.14fF
C397 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/v 1.30fF
C398 ro_complete_0/cbank_0/switch_2/vin divbuf_22/OUT 0.09fF
C399 divider_0/prescaler_0/Out divider_0/tspc_2/Z3 0.45fF
C400 divider_0/nor_0/B divider_0/nor_0/A 1.21fF
C401 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C402 divbuf_5/a_492_n240# divbuf_5/OUT2 0.42fF
C403 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z3 0.16fF
C404 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C405 divbuf_17/OUT divbuf_17/a_492_n240# 0.00fF
C406 divider_1/mc2 divider_1/nor_1/B 0.15fF
C407 divbuf_6/OUT5 divbuf_6/OUT 43.38fF
C408 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z1 0.09fF
C409 pd_0/REF pd_0/tspc_r_1/Z2 0.19fF
C410 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z1 0.17fF
C411 divider_2/prescaler_0/tspc_0/Z3 divider_2/clk 0.64fF
C412 divbuf_8/a_492_n240# divbuf_8/OUT 0.00fF
C413 divider_0/tspc_0/Z1 divider_0/tspc_1/Q 0.01fF
C414 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z3 0.06fF
C415 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/v 1.30fF
C416 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/cbank_0/v 1.30fF
C417 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_1/Q 0.13fF
C418 divbuf_1/OUT divbuf_1/a_492_n240# 0.00fF
C419 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT3 1.37fF
C420 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C421 divbuf_21/IN divbuf_21/OUT5 0.00fF
C422 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_2/Q 0.01fF
C423 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/a_630_n680# 0.35fF
C424 pll_full_0/ro_complete_0/a1 pll_full_0/divider_0/clk 0.11fF
C425 divider_2/nor_1/B divider_2/tspc_0/Z2 0.40fF
C426 divider_1/tspc_0/Z3 divider_1/tspc_0/Z1 0.06fF
C427 divbuf_11/a_492_n240# divbuf_11/IN 0.13fF
C428 divider_2/tspc_0/Z2 divider_2/tspc_0/Z3 0.16fF
C429 pd_1/R pd_1/tspc_r_0/Z3 0.27fF
C430 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z4 0.02fF
C431 divbuf_12/OUT4 divbuf_12/OUT 1.11fF
C432 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar1 0.30fF
C433 divbuf_14/a_492_n240# divbuf_14/OUT5 0.01fF
C434 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/a_630_n680# 0.01fF
C435 divider_0/tspc_1/Z1 divider_0/tspc_2/Q 0.01fF
C436 divider_0/nor_0/B divider_0/tspc_1/a_630_n680# 0.35fF
C437 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/v 1.30fF
C438 divbuf_16/OUT2 divbuf_16/OUT3 1.37fF
C439 divider_1/prescaler_0/tspc_0/Z4 divider_1/clk 0.12fF
C440 divbuf_22/OUT divbuf_22/a_492_n240# 0.00fF
C441 divbuf_3/OUT2 divbuf_3/OUT5 0.02fF
C442 divbuf_3/OUT3 divbuf_3/OUT4 5.16fF
C443 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z2 0.14fF
C444 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C445 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z3 0.33fF
C446 divbuf_7/OUT2 divbuf_7/OUT3 1.37fF
C447 pd_0/DIV pd_0/tspc_r_0/Z3 0.65fF
C448 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/B 0.18fF
C449 divider_0/nor_0/Z1 divider_0/and_0/B 0.18fF
C450 divider_0/tspc_2/Q divider_0/tspc_1/Z2 0.14fF
C451 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z2 0.01fF
C452 divbuf_1/OUT3 divbuf_1/OUT 0.26fF
C453 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C454 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C455 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/a3 0.09fF
C456 divider_1/tspc_1/a_630_n680# divider_1/nor_1/B 0.00fF
C457 divider_0/and_0/out1 divider_0/and_0/B 0.18fF
C458 divbuf_4/OUT2 divbuf_4/OUT5 0.02fF
C459 divbuf_4/OUT3 divbuf_4/OUT4 5.16fF
C460 divbuf_6/a_492_n240# divbuf_6/OUT2 0.42fF
C461 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/B 0.31fF
C462 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/nor_0/A 0.55fF
C463 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C464 divider_2/nor_1/B divider_2/Out 0.22fF
C465 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_2/Q 0.19fF
C466 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/clk 0.01fF
C467 divider_1/nor_1/B divider_1/and_0/B 0.29fF
C468 pd_1/tspc_r_0/Z1 pd_1/tspc_r_0/Z2 0.71fF
C469 pd_1/DIV pd_1/R 0.51fF
C470 pd_0/DOWN pd_0/tspc_r_1/Qbar 0.02fF
C471 pd_0/R pd_0/tspc_r_1/Qbar1 0.30fF
C472 divider_2/Out divider_2/tspc_0/Z3 0.05fF
C473 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT4 1.11fF
C474 divider_2/tspc_2/Z3 divider_2/tspc_2/Z4 0.65fF
C475 divbuf_9/a_492_n240# divbuf_9/OUT 0.00fF
C476 filter_0/v divbuf_0/OUT5 43.38fF
C477 divbuf_22/OUT ro_complete_0/cbank_2/switch_1/vin 0.13fF
C478 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C479 divbuf_15/OUT divbuf_15/a_492_n240# 0.00fF
C480 divider_0/nor_0/B divider_0/and_0/B 0.31fF
C481 divider_0/tspc_2/Q divider_0/nor_0/A 0.55fF
C482 divider_0/and_0/OUT divider_0/prescaler_0/nand_0/z1 0.01fF
C483 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/v 1.30fF
C484 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C485 divbuf_19/OUT2 divbuf_19/a_492_n240# 0.42fF
C486 divider_1/tspc_0/Z2 divider_1/nor_0/B 0.20fF
C487 divider_1/tspc_0/a_630_n680# divider_1/nor_1/B 0.35fF
C488 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z3 0.05fF
C489 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z4 0.08fF
C490 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Q 0.51fF
C491 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z4 0.36fF
C492 divbuf_22/IN divbuf_22/OUT5 0.00fF
C493 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/clk 0.06fF
C494 divider_1/tspc_2/a_630_n680# divider_1/nor_0/A 0.35fF
C495 divider_1/prescaler_0/tspc_0/D divider_1/clk 0.29fF
C496 divbuf_12/a_492_n240# divbuf_12/IN 0.13fF
C497 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/DOWN 0.03fF
C498 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z4 0.12fF
C499 filter_0/v divbuf_0/OUT3 0.26fF
C500 pll_full_0/cp_0/a_1710_0# pll_full_0/cp_0/down 0.32fF
C501 divbuf_25/OUT4 divbuf_25/OUT 1.11fF
C502 io_clamp_low[2] io_clamp_high[2] 0.53fF
C503 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/cbank_1/v 1.43fF
C504 ro_complete_1/a2 ro_complete_1/cbank_1/switch_3/vin 0.09fF
C505 divbuf_21/OUT ro_complete_0/cbank_2/v 0.05fF
C506 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/v 1.30fF
C507 divider_0/nor_0/B divider_0/tspc_1/Q 0.51fF
C508 divider_1/prescaler_0/Out divider_1/tspc_2/a_630_n680# 0.01fF
C509 divider_0/and_0/OUT divider_0/clk 0.04fF
C510 io_clamp_high[1] io_analog[5] 0.53fF
C511 divider_1/prescaler_0/tspc_1/Z2 divider_1/and_0/OUT 0.06fF
C512 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z3 0.33fF
C513 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Q 0.38fF
C514 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C515 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z3 0.06fF
C516 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/A 0.01fF
C517 divider_1/and_0/out1 divider_1/and_0/A 0.01fF
C518 divbuf_24/OUT2 divbuf_24/OUT3 1.37fF
C519 cp_0/a_10_n50# cp_0/a_1710_0# 0.04fF
C520 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/R 0.27fF
C521 divbuf_2/OUT2 divbuf_2/OUT5 0.02fF
C522 divbuf_2/OUT3 divbuf_2/OUT4 5.16fF
C523 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/v 1.30fF
C524 ro_complete_0/cbank_2/switch_2/vin ro_complete_0/cbank_2/v 1.30fF
C525 divider_0/tspc_2/Q divider_0/tspc_1/a_630_n680# 0.01fF
C526 divider_0/tspc_1/Z1 divider_0/tspc_1/Z3 0.06fF
C527 divider_1/nor_1/Z1 divider_1/and_0/B 0.78fF
C528 divider_0/nor_0/A divider_0/and_0/A 0.01fF
C529 divbuf_4/a_492_n240# divbuf_4/IN 0.13fF
C530 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/Z2 1.07fF
C531 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/clk 0.01fF
C532 divbuf_10/OUT2 divbuf_10/OUT5 0.02fF
C533 divbuf_10/OUT3 divbuf_10/OUT4 5.16fF
C534 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/nor_0/A 0.01fF
C535 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z4 0.12fF
C536 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z3 0.16fF
C537 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C538 divbuf_23/a_492_n240# divbuf_23/OUT2 0.42fF
C539 pd_0/tspc_r_0/Z2 pd_0/R 0.21fF
C540 pd_0/DOWN pd_0/tspc_r_0/z5 0.03fF
C541 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_1/Q 0.13fF
C542 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z2 0.01fF
C543 divbuf_19/OUT divbuf_19/OUT4 1.11fF
C544 divbuf_13/OUT5 divbuf_13/OUT 43.38fF
C545 pd_1/tspc_r_1/Z4 pd_1/tspc_r_1/z5 0.04fF
C546 ro_complete_0/cbank_1/switch_1/vin divbuf_22/OUT 0.14fF
C547 ro_complete_0/cbank_2/switch_3/vin divbuf_19/OUT 0.14fF
C548 divbuf_0/OUT5 divbuf_0/IN 0.00fF
C549 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C550 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C551 divider_0/prescaler_0/m1_2700_2190# divider_0/nor_0/A 0.01fF
C552 divider_0/prescaler_0/Out divider_0/tspc_2/Z4 0.12fF
C553 divider_0/tspc_1/Z2 divider_0/tspc_1/Z3 0.16fF
C554 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/D 0.15fF
C555 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C556 divider_2/nor_1/B divider_2/nor_0/B 0.47fF
C557 divider_2/tspc_0/Z2 divider_2/tspc_0/Z4 0.36fF
C558 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_0/Z3 0.16fF
C559 pd_0/DOWN pd_0/and_pd_0/Z1 0.07fF
C560 divbuf_8/IN divbuf_8/OUT5 0.00fF
C561 divider_2/mc2 divider_2/nor_0/A 0.04fF
C562 divider_2/prescaler_0/tspc_0/Z4 divider_2/clk 0.12fF
C563 divbuf_25/a_492_n240# divbuf_25/IN 0.13fF
C564 filter_0/a_4216_n5230# filter_0/v 0.91fF
C565 ro_complete_0/cbank_1/switch_4/vin divbuf_18/OUT 0.13fF
C566 divbuf_1/IN divbuf_1/OUT5 0.00fF
C567 divbuf_0/a_492_n240# divbuf_0/OUT5 0.01fF
C568 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/cbank_0/v 1.30fF
C569 divbuf_23/OUT ro_complete_0/cbank_2/switch_0/vin 0.09fF
C570 divider_0/tspc_0/Z1 divider_0/tspc_0/Z3 0.06fF
C571 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z4 0.00fF
C572 ro_complete_1/a1 ro_complete_1/cbank_2/v 0.05fF
C573 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT4 5.16fF
C574 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C575 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_1/Q 0.21fF
C576 divider_1/nor_1/B divider_1/tspc_1/Q 0.22fF
C577 divbuf_21/OUT3 divbuf_21/OUT5 0.01fF
C578 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C579 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z3 0.05fF
C580 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z1 0.03fF
C581 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/Z3 0.20fF
C582 divbuf_19/OUT3 divbuf_19/OUT5 0.01fF
C583 divider_2/nor_0/B divider_2/tspc_2/a_630_n680# 0.01fF
C584 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/D 0.03fF
C585 divbuf_14/OUT2 divbuf_14/OUT3 1.37fF
C586 filter_0/v divbuf_0/OUT4 1.11fF
C587 divbuf_1/OUT2 divbuf_1/OUT5 0.02fF
C588 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/a3 0.13fF
C589 divbuf_19/OUT ro_complete_0/cbank_2/v 0.05fF
C590 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_0/a_630_n680# 0.04fF
C591 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z3 0.06fF
C592 divbuf_3/OUT3 divbuf_3/OUT 0.26fF
C593 divbuf_3/OUT4 divbuf_3/OUT5 20.26fF
C594 pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C595 divbuf_17/OUT divbuf_17/OUT4 1.11fF
C596 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z3 0.05fF
C597 divider_0/nor_0/A divider_0/tspc_2/Z1 0.03fF
C598 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z4 0.08fF
C599 divider_1/prescaler_0/tspc_2/Z2 divider_1/and_0/OUT 0.05fF
C600 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z3 0.05fF
C601 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Qbar1 0.38fF
C602 divbuf_7/OUT2 divbuf_7/OUT5 0.02fF
C603 divbuf_7/OUT3 divbuf_7/OUT4 5.16fF
C604 pll_full_0/divider_0/and_0/A pll_full_0/divider_0/and_0/B 0.18fF
C605 pd_1/REF pd_1/tspc_r_1/Z4 0.02fF
C606 pd_1/UP pd_1/tspc_r_1/Qbar 0.21fF
C607 divbuf_18/OUT divbuf_18/OUT3 0.26fF
C608 divbuf_13/a_492_n240# divbuf_13/OUT2 0.42fF
C609 divider_2/prescaler_0/tspc_1/Q divider_2/nor_0/A 0.03fF
C610 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C611 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/v 1.30fF
C612 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C613 divider_0/mc2 divider_0/and_0/out1 0.06fF
C614 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z3 0.05fF
C615 divbuf_23/OUT divbuf_23/OUT2 0.06fF
C616 divbuf_4/OUT3 divbuf_4/OUT 0.26fF
C617 divbuf_4/OUT4 divbuf_4/OUT5 20.26fF
C618 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_0/B 0.18fF
C619 divider_1/tspc_2/Q divider_1/nor_0/B 0.22fF
C620 divider_0/and_0/A divider_0/and_0/B 0.18fF
C621 divider_1/tspc_1/Z2 divider_1/nor_0/A 0.15fF
C622 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_0/D 0.32fF
C623 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/clk 0.01fF
C624 divider_1/nor_0/B divider_1/and_0/A 0.26fF
C625 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C626 pd_1/DIV pd_1/tspc_r_0/Z4 0.02fF
C627 divider_2/prescaler_0/Out divider_2/tspc_2/a_630_n680# 0.01fF
C628 divbuf_9/IN divbuf_9/OUT5 0.00fF
C629 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT5 43.38fF
C630 pll_full_0/pd_0/DOWN pll_full_0/pd_0/R 0.36fF
C631 divider_0/mc2 divider_0/nor_0/B 0.06fF
C632 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/a1 0.14fF
C633 divbuf_20/OUT ro_complete_0/cbank_1/v 0.05fF
C634 ro_complete_0/cbank_0/switch_4/vin divbuf_18/OUT 0.13fF
C635 divbuf_1/OUT4 divbuf_1/OUT 1.11fF
C636 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C637 divider_1/nor_0/Z1 divider_1/nor_0/B 0.06fF
C638 divider_0/prescaler_0/tspc_2/D divider_0/prescaler_0/nand_0/z1 0.24fF
C639 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C640 pll_full_0/ro_complete_0/a5 pll_full_0/divider_0/clk 0.15fF
C641 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z4 0.12fF
C642 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z2 1.07fF
C643 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z2 0.01fF
C644 divbuf_22/OUT3 divbuf_22/OUT5 0.01fF
C645 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/out1 0.31fF
C646 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/clk 0.26fF
C647 pd_0/tspc_r_1/Z4 pd_0/tspc_r_1/z5 0.04fF
C648 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z1 0.09fF
C649 divider_2/mc2 divider_2/and_0/B 0.20fF
C650 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Out1 0.12fF
C651 divider_0/tspc_0/Z1 divider_0/tspc_0/Z4 0.00fF
C652 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z2 0.19fF
C653 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/a1 0.14fF
C654 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/v 1.43fF
C655 pll_full_0/ro_complete_0/a1 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C656 divider_1/prescaler_0/Out divider_1/nor_0/A 0.15fF
C657 divbuf_15/OUT divbuf_15/OUT4 1.11fF
C658 divider_0/and_0/OUT divider_0/and_0/out1 0.31fF
C659 divider_0/prescaler_0/tspc_2/D divider_0/clk 0.26fF
C660 io_clamp_low[0] io_analog[4] 0.53fF
C661 divbuf_20/a_492_n240# divbuf_20/OUT5 0.01fF
C662 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_1/Z3 0.05fF
C663 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z4 0.00fF
C664 pll_full_0/divbuf_0/IN pll_full_0/divider_0/nor_1/B 0.27fF
C665 divbuf_17/OUT divbuf_17/OUT3 0.26fF
C666 divider_1/tspc_1/Q divider_1/tspc_0/Z1 0.01fF
C667 divider_1/mc2 divider_1/nor_0/A 0.04fF
C668 divider_1/tspc_1/Z1 divider_1/tspc_1/Z2 1.07fF
C669 divider_1/nor_0/B divider_1/tspc_1/Z3 0.38fF
C670 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z3 0.05fF
C671 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z4 0.08fF
C672 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Q 0.04fF
C673 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z4 0.20fF
C674 divbuf_24/OUT2 divbuf_24/OUT5 0.02fF
C675 divbuf_24/OUT3 divbuf_24/OUT4 5.16fF
C676 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/Z4 0.65fF
C677 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C678 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C679 pll_full_0/pd_0/UP pll_full_0/pd_0/tspc_r_1/Qbar 0.21fF
C680 divbuf_15/OUT2 divbuf_15/OUT 0.06fF
C681 divider_0/tspc_1/Q divider_0/tspc_1/Z3 0.05fF
C682 divider_0/tspc_1/Z1 divider_0/tspc_1/Z4 0.00fF
C683 divider_0/Out divider_0/nor_1/B 0.22fF
C684 divbuf_2/OUT4 divbuf_2/OUT5 20.26fF
C685 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/switch_5/vin 0.20fF
C686 divbuf_19/OUT2 divbuf_19/OUT3 1.37fF
C687 divider_1/nor_0/Z1 divider_1/and_0/A 0.80fF
C688 divbuf_10/OUT3 divbuf_10/OUT 0.26fF
C689 divbuf_10/OUT4 divbuf_10/OUT5 20.26fF
C690 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z4 0.36fF
C691 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C692 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/clk 0.64fF
C693 pd_0/tspc_r_0/Z2 pd_0/tspc_r_0/Z4 0.14fF
C694 divider_2/tspc_0/Z4 divider_2/nor_0/B 0.02fF
C695 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_1/Q 0.21fF
C696 pd_1/UP pd_1/and_pd_0/Z1 0.06fF
C697 divbuf_21/OUT ro_complete_0/cbank_2/switch_1/vin 0.09fF
C698 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/v 1.30fF
C699 divider_0/tspc_1/Z2 divider_0/tspc_1/Z4 0.36fF
C700 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/D 0.05fF
C701 divider_0/prescaler_0/tspc_0/Z3 divider_0/clk 0.64fF
C702 divbuf_20/OUT divbuf_20/a_492_n240# 0.00fF
C703 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C704 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/a0 0.13fF
C705 divbuf_5/a_492_n240# divbuf_5/OUT 0.00fF
C706 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C707 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C708 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/divider_0/clk 1.46fF
C709 divider_2/nor_1/Z1 divider_2/nor_1/B 0.06fF
C710 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z2 0.01fF
C711 divider_1/tspc_2/Q divider_1/tspc_1/Z3 0.45fF
C712 divider_1/tspc_0/Z3 divider_1/tspc_0/a_630_n680# 0.05fF
C713 pll_full_0/divider_0/tspc_1/Z4 pll_full_0/divider_0/nor_0/A 0.02fF
C714 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_0/Z4 0.36fF
C715 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/Out 0.05fF
C716 divbuf_8/OUT3 divbuf_8/OUT5 0.01fF
C717 divbuf_8/OUT2 divbuf_8/OUT 0.06fF
C718 pd_1/tspc_r_0/Z2 pd_1/R 0.21fF
C719 pd_0/R pd_0/and_pd_0/Out1 0.33fF
C720 pd_0/REF pd_0/tspc_r_1/Z4 0.02fF
C721 pd_0/UP pd_0/tspc_r_1/Qbar 0.21fF
C722 divider_2/nor_0/B divider_2/tspc_1/Z2 0.30fF
C723 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z2 0.01fF
C724 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_492_n240# 0.00fF
C725 divider_2/and_0/out1 divider_2/and_0/B 0.18fF
C726 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C727 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/Z4 0.65fF
C728 divider_2/tspc_1/Q divider_2/tspc_0/Z2 0.14fF
C729 divbuf_16/a_492_n240# divbuf_16/IN 0.13fF
C730 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/D 0.05fF
C731 divider_0/tspc_1/Z4 divider_0/nor_0/A 0.02fF
C732 divbuf_2/a_492_n240# divbuf_2/OUT 0.00fF
C733 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_0/Z4 0.02fF
C734 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C735 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/divider_0/clk 1.27fF
C736 divbuf_11/a_492_n240# divbuf_11/OUT5 0.01fF
C737 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z4 0.12fF
C738 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z2 1.07fF
C739 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z3 0.38fF
C740 divider_1/nor_0/A divider_1/and_0/B 0.08fF
C741 pd_1/DOWN pd_1/UP 0.46fF
C742 pd_1/tspc_r_0/z5 pd_1/tspc_r_0/Qbar1 0.20fF
C743 divider_2/and_0/OUT divider_2/prescaler_0/nand_0/z1 0.01fF
C744 divider_2/nor_0/B divider_2/nor_0/A 1.21fF
C745 ro_complete_1/a4 ro_complete_1/cbank_1/switch_1/vin 0.09fF
C746 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z2 0.21fF
C747 divbuf_14/OUT2 divbuf_14/OUT5 0.02fF
C748 divbuf_14/OUT3 divbuf_14/OUT4 5.16fF
C749 ro_complete_0/cbank_1/switch_5/vin ro_complete_0/cbank_1/v 1.30fF
C750 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/Z1 0.06fF
C751 divider_0/nor_0/B divider_0/tspc_0/Z4 0.02fF
C752 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z4 0.00fF
C753 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z3 0.05fF
C754 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z4 0.12fF
C755 divider_0/tspc_2/Z1 divider_0/tspc_2/Z2 1.07fF
C756 divider_0/nor_0/A divider_0/tspc_2/Z3 0.38fF
C757 divbuf_22/OUT divbuf_22/OUT2 0.06fF
C758 divbuf_3/OUT5 divbuf_3/OUT 43.38fF
C759 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C760 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z4 0.12fF
C761 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C762 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Q 0.20fF
C763 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/D 0.09fF
C764 divider_1/mc2 divider_1/and_0/B 0.20fF
C765 divbuf_7/OUT3 divbuf_7/OUT 0.26fF
C766 divbuf_7/OUT4 divbuf_7/OUT5 20.26fF
C767 pd_0/DIV pd_0/tspc_r_0/Z1 0.17fF
C768 pd_0/tspc_r_0/Qbar1 pd_0/DOWN 0.11fF
C769 divbuf_18/OUT divbuf_18/OUT5 43.38fF
C770 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/z5 0.11fF
C771 divider_2/and_0/OUT divider_2/clk 0.04fF
C772 divbuf_20/OUT divbuf_22/OUT 3.09fF
C773 divbuf_21/OUT ro_complete_0/cbank_1/switch_1/vin 0.09fF
C774 pll_full_0/pd_0/UP pll_full_0/pd_0/and_pd_0/Z1 0.06fF
C775 ro_complete_1/a2 ro_complete_1/cbank_1/v 0.05fF
C776 divbuf_15/IN divbuf_15/a_492_n240# 0.13fF
C777 divider_0/mc2 divider_0/and_0/A 0.16fF
C778 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z4 0.12fF
C779 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z3 0.06fF
C780 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C781 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C782 divbuf_23/OUT divbuf_23/OUT4 1.11fF
C783 divbuf_4/OUT5 divbuf_4/OUT 43.38fF
C784 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/Out 0.21fF
C785 divbuf_6/a_492_n240# divbuf_6/OUT 0.00fF
C786 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C787 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/clk 0.45fF
C788 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/nand_1/z1 0.22fF
C789 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/tspc_0/D 0.04fF
C790 pd_0/R pd_0/tspc_r_1/Z2 0.21fF
C791 divider_2/prescaler_0/Out divider_2/nor_0/A 0.15fF
C792 divider_2/nor_0/B divider_2/tspc_1/Z1 0.03fF
C793 divbuf_9/OUT3 divbuf_9/OUT5 0.01fF
C794 divbuf_9/OUT2 divbuf_9/OUT 0.06fF
C795 divider_2/nor_0/A divider_2/and_0/A 0.01fF
C796 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C797 divider_1/prescaler_0/tspc_0/Z2 divider_1/and_0/OUT 0.06fF
C798 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/Q 0.04fF
C799 divider_0/prescaler_0/tspc_1/Z3 divider_0/clk 0.45fF
C800 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C801 divider_1/tspc_0/Z3 divider_1/tspc_1/Q 0.45fF
C802 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z3 0.16fF
C803 divbuf_21/a_492_n240# divbuf_21/IN 0.13fF
C804 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/nor_1/B 0.03fF
C805 divider_2/tspc_0/Z2 divider_2/tspc_0/a_630_n680# 0.01fF
C806 divider_1/nor_0/A divider_1/tspc_2/Z2 0.23fF
C807 divbuf_12/a_492_n240# divbuf_12/OUT5 0.01fF
C808 pd_1/DOWN pd_1/tspc_r_0/z5 0.03fF
C809 pd_0/UP pd_0/and_pd_0/Z1 0.06fF
C810 divider_2/prescaler_0/m1_2700_2190# divider_2/nor_0/A 0.01fF
C811 divider_2/tspc_1/Z2 divider_2/tspc_1/Z3 0.16fF
C812 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/D 0.15fF
C813 io_clamp_low[1] io_clamp_high[1] 0.53fF
C814 ro_complete_1/a2 ro_complete_1/cbank_0/switch_2/vin 0.14fF
C815 divbuf_23/OUT ro_complete_0/cbank_2/v 0.08fF
C816 divbuf_18/OUT ro_complete_0/cbank_1/switch_5/vin 0.09fF
C817 divider_0/nor_1/Z1 divider_0/nor_1/B 0.06fF
C818 divbuf_3/a_492_n240# divbuf_3/OUT2 0.42fF
C819 divider_1/prescaler_0/Out divider_1/tspc_2/Z2 0.11fF
C820 divbuf_15/OUT divbuf_15/OUT3 0.26fF
C821 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/IN 0.00fF
C822 divider_1/nor_0/B divider_1/tspc_1/Z4 0.21fF
C823 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z4 0.12fF
C824 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z2 1.07fF
C825 divbuf_20/OUT2 divbuf_20/OUT3 1.37fF
C826 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C827 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/and_0/OUT 0.14fF
C828 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/D 0.03fF
C829 divider_1/and_0/out1 divider_1/and_0/Z1 0.36fF
C830 divbuf_24/OUT3 divbuf_24/OUT 0.26fF
C831 divbuf_24/OUT4 divbuf_24/OUT5 20.26fF
C832 pd_1/tspc_r_0/Z4 pd_1/tspc_r_1/Z4 0.02fF
C833 pd_1/REF pd_1/tspc_r_1/Z3 0.65fF
C834 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/z5 0.20fF
C835 divider_2/nor_0/B divider_2/and_0/B 0.31fF
C836 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_4/vin 0.20fF
C837 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C838 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/z5 0.11fF
C839 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/v 1.30fF
C840 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C841 divbuf_15/OUT2 divbuf_15/a_492_n240# 0.42fF
C842 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_1/Q 0.13fF
C843 divider_0/prescaler_0/m1_2700_2190# divider_0/and_0/OUT 0.14fF
C844 divbuf_4/a_492_n240# divbuf_4/OUT5 0.01fF
C845 divider_1/prescaler_0/tspc_1/Z2 divider_1/clk 0.11fF
C846 divbuf_10/OUT5 divbuf_10/OUT 43.38fF
C847 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C848 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/clk 0.12fF
C849 divider_2/mc2 divider_2/and_0/OUT 0.05fF
C850 divider_2/Out divider_2/tspc_0/a_630_n680# 0.04fF
C851 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z3 0.06fF
C852 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/D 0.05fF
C853 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z3 0.05fF
C854 divider_2/nor_0/A divider_2/tspc_2/Z1 0.03fF
C855 divbuf_2/OUT3 divbuf_2/OUT 0.26fF
C856 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/a0 0.09fF
C857 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C858 divbuf_16/a_492_n240# divbuf_16/OUT 0.00fF
C859 divider_1/tspc_0/Z4 divider_1/nor_1/B 0.22fF
C860 divider_0/prescaler_0/tspc_2/Z4 divider_0/prescaler_0/tspc_2/D 0.11fF
C861 divider_0/prescaler_0/tspc_0/Z4 divider_0/clk 0.12fF
C862 divbuf_5/IN divbuf_5/OUT5 0.00fF
C863 divbuf_17/OUT divbuf_17/OUT5 43.38fF
C864 divider_2/tspc_1/Q divider_2/nor_0/B 0.51fF
C865 divider_1/tspc_2/Q divider_1/tspc_1/Z4 0.15fF
C866 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/a_630_n680# 0.19fF
C867 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divbuf_0/IN 0.04fF
C868 divider_2/nor_0/Z1 divider_2/and_0/B 0.18fF
C869 divbuf_22/a_492_n240# divbuf_22/IN 0.13fF
C870 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/clk 0.45fF
C871 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z4 0.14fF
C872 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/z5 0.11fF
C873 divbuf_18/OUT5 divbuf_18/IN 0.00fF
C874 divbuf_18/a_492_n240# divbuf_18/OUT2 0.42fF
C875 divider_2/tspc_1/Z1 divider_2/tspc_1/Z3 0.06fF
C876 divbuf_8/OUT4 divbuf_8/OUT 1.11fF
C877 divbuf_25/a_492_n240# divbuf_25/OUT5 0.01fF
C878 divider_2/and_0/A divider_2/and_0/B 0.18fF
C879 divider_0/tspc_0/a_630_n680# divider_0/Out 0.04fF
C880 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/v 0.08fF
C881 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C882 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/D 0.11fF
C883 divider_0/prescaler_0/tspc_2/Z3 divider_0/clk 0.45fF
C884 divider_1/tspc_2/Q divider_1/tspc_2/Z3 0.05fF
C885 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C886 divbuf_11/OUT2 divbuf_11/OUT3 1.37fF
C887 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z3 0.16fF
C888 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z4 0.21fF
C889 pd_1/R pd_1/tspc_r_1/Z3 0.29fF
C890 divider_2/prescaler_0/tspc_2/D divider_2/prescaler_0/nand_0/z1 0.24fF
C891 divbuf_14/OUT3 divbuf_14/OUT 0.26fF
C892 divbuf_14/OUT4 divbuf_14/OUT5 20.26fF
C893 filter_0/v divbuf_0/OUT2 0.06fF
C894 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z3 0.65fF
C895 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/Z1 0.00fF
C896 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Z4 0.65fF
C897 ro_complete_0/cbank_0/v ro_complete_0/cbank_2/v 0.04fF
C898 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT4 5.16fF
C899 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C900 divbuf_22/OUT divbuf_22/OUT4 1.11fF
C901 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/IN 0.13fF
C902 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C903 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z4 0.12fF
C904 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/clk 0.14fF
C905 divider_0/tspc_2/Z2 divider_0/tspc_2/Z3 0.16fF
C906 divider_0/nor_0/A divider_0/tspc_2/Z4 0.21fF
C907 divbuf_10/a_492_n240# divbuf_10/OUT2 0.42fF
C908 divider_1/tspc_1/Z3 divider_1/tspc_1/Z4 0.65fF
C909 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Q 0.04fF
C910 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C911 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C912 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C913 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z2 0.25fF
C914 divider_2/prescaler_0/tspc_0/Z2 divider_2/and_0/OUT 0.06fF
C915 divbuf_7/OUT5 divbuf_7/OUT 43.38fF
C916 pll_full_0/divider_0/and_0/B pll_full_0/divider_0/and_0/Z1 0.07fF
C917 pd_1/UP pd_1/tspc_r_1/z5 0.03fF
C918 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/Qbar 0.21fF
C919 divider_2/and_0/OUT divider_2/and_0/out1 0.31fF
C920 divider_2/prescaler_0/tspc_2/D divider_2/clk 0.26fF
C921 divbuf_13/a_492_n240# divbuf_13/OUT 0.00fF
C922 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C923 divider_0/prescaler_0/Out divider_0/tspc_2/a_630_n680# 0.01fF
C924 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z4 0.00fF
C925 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Q 0.21fF
C926 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/nor_0/B 0.20fF
C927 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Q 0.04fF
C928 divider_0/and_0/B divider_0/and_0/Z1 0.07fF
C929 divbuf_6/IN divbuf_6/OUT5 0.00fF
C930 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/clk 0.12fF
C931 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/nand_1/z1 0.01fF
C932 divider_1/prescaler_0/tspc_2/Z2 divider_1/clk 0.11fF
C933 pd_1/DIV pd_1/tspc_r_0/Z3 0.65fF
C934 pd_0/REF pd_0/tspc_r_1/Z3 0.65fF
C935 divider_2/prescaler_0/Out divider_2/tspc_2/Z2 0.11fF
C936 divbuf_8/a_492_n240# divbuf_8/IN 0.13fF
C937 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT2 0.06fF
C938 divbuf_9/OUT4 divbuf_9/OUT 1.11fF
C939 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z3 0.33fF
C940 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C941 pll_full_0/pd_0/DIV pll_full_0/divider_0/and_0/OUT 0.01fF
C942 divider_1/tspc_0/Z4 divider_1/tspc_0/Z1 0.00fF
C943 divider_0/prescaler_0/tspc_1/Z4 divider_0/clk 0.12fF
C944 ro_complete_1/a0 ro_complete_1/cbank_2/switch_4/vin 0.13fF
C945 ro_complete_1/cbank_0/v ro_complete_1/cbank_1/v 1.27fF
C946 divider_2/tspc_1/Q divider_2/tspc_1/Z3 0.05fF
C947 divider_1/mc2 divider_1/and_0/OUT 0.05fF
C948 divider_1/tspc_0/a_630_n680# divider_1/tspc_1/Q 0.01fF
C949 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z4 0.36fF
C950 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/D 0.03fF
C951 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/clk 0.60fF
C952 divider_1/tspc_2/Z1 divider_1/tspc_2/Z3 0.06fF
C953 divider_2/tspc_1/Z2 divider_2/tspc_1/Z4 0.36fF
C954 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/D 0.05fF
C955 divbuf_12/OUT2 divbuf_12/OUT3 1.37fF
C956 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/v 1.30fF
C957 divbuf_18/OUT ro_complete_0/cbank_1/v 0.05fF
C958 divider_0/prescaler_0/tspc_1/Q divider_0/clk 0.60fF
C959 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_0/B 0.06fF
C960 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/ro_complete_0/cbank_2/v 0.04fF
C961 divbuf_20/OUT2 divbuf_20/OUT5 0.02fF
C962 divbuf_20/OUT3 divbuf_20/OUT4 5.16fF
C963 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C964 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C965 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C966 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C967 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z3 0.16fF
C968 divbuf_7/a_492_n240# divbuf_7/OUT2 0.42fF
C969 divider_2/nor_1/Z1 divider_2/and_0/B 0.78fF
C970 pd_1/tspc_r_0/z5 pd_1/tspc_r_1/z5 0.02fF
C971 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Qbar1 0.38fF
C972 divider_2/tspc_1/Z4 divider_2/nor_0/A 0.02fF
C973 divbuf_24/OUT5 divbuf_24/OUT 43.38fF
C974 divbuf_0/a_492_n240# divbuf_0/OUT2 0.42fF
C975 pll_full_0/pd_0/UP pll_full_0/pd_0/tspc_r_1/z5 0.03fF
C976 divbuf_19/OUT divbuf_19/OUT5 43.38fF
C977 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_1/Q 0.21fF
C978 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_2/D 0.16fF
C979 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/D 0.03fF
C980 ro_complete_1/a3 ro_complete_1/cbank_1/switch_2/vin 0.09fF
C981 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/cbank_0/v 1.30fF
C982 ro_complete_0/cbank_2/switch_0/vin ro_complete_0/cbank_2/v 1.45fF
C983 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT3 0.01fF
C984 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT2 0.06fF
C985 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C986 divbuf_16/OUT5 divbuf_16/IN 0.00fF
C987 divbuf_23/IN divbuf_23/OUT5 0.00fF
C988 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z4 0.00fF
C989 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/D 0.11fF
C990 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Z1 0.02fF
C991 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z4 0.12fF
C992 divider_2/tspc_2/Z1 divider_2/tspc_2/Z2 1.07fF
C993 divider_2/nor_0/A divider_2/tspc_2/Z3 0.38fF
C994 divbuf_9/a_492_n240# divbuf_9/IN 0.13fF
C995 divbuf_21/OUT ro_complete_0/cbank_1/switch_0/vin 0.12fF
C996 divbuf_20/OUT ro_complete_0/cbank_2/switch_2/vin 0.14fF
C997 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/v 1.30fF
C998 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z4 0.01fF
C999 divbuf_20/OUT divbuf_20/OUT2 0.06fF
C1000 divbuf_21/OUT divbuf_21/OUT3 0.26fF
C1001 divbuf_2/OUT5 divbuf_2/OUT 43.38fF
C1002 ro_complete_1/a3 ro_complete_1/cbank_1/v 0.05fF
C1003 divbuf_5/OUT3 divbuf_5/OUT5 0.01fF
C1004 divbuf_5/OUT2 divbuf_5/OUT 0.06fF
C1005 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/clk 0.12fF
C1006 divider_2/nor_1/B divider_2/tspc_1/a_630_n680# 0.00fF
C1007 divider_1/and_0/OUT divider_1/and_0/B 0.01fF
C1008 pd_0/UP pd_0/tspc_r_1/z5 0.03fF
C1009 divider_2/tspc_1/Z1 divider_2/tspc_1/Z4 0.00fF
C1010 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z3 0.06fF
C1011 divbuf_25/OUT2 divbuf_25/OUT3 1.37fF
C1012 divbuf_22/OUT ro_complete_0/cbank_1/v 0.05fF
C1013 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/a_492_n240# 0.00fF
C1014 divider_0/mc2 divider_0/prescaler_0/tspc_2/a_630_n680# 0.33fF
C1015 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Q 0.15fF
C1016 divider_0/prescaler_0/tspc_2/Z4 divider_0/clk 0.12fF
C1017 ro_complete_1/cbank_2/switch_0/vin ro_complete_1/cbank_2/v 1.45fF
C1018 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1019 divbuf_11/OUT2 divbuf_11/OUT5 0.02fF
C1020 divbuf_11/OUT3 divbuf_11/OUT4 5.16fF
C1021 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z4 0.36fF
C1022 divbuf_24/a_492_n240# divbuf_24/OUT2 0.42fF
C1023 pd_1/DOWN pd_1/tspc_r_1/Qbar 0.02fF
C1024 pd_1/R pd_1/UP 0.45fF
C1025 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/Q 0.04fF
C1026 divider_2/prescaler_0/tspc_1/Z3 divider_2/clk 0.45fF
C1027 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Qbar1 0.38fF
C1028 divbuf_14/OUT5 divbuf_14/OUT 43.38fF
C1029 ro_complete_1/a4 ro_complete_1/cbank_2/v 0.05fF
C1030 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/a3 0.09fF
C1031 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT5 0.01fF
C1032 divider_0/tspc_2/Z2 divider_0/tspc_2/Z4 0.36fF
C1033 pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_0/ro_complete_0/cbank_2/v 1.45fF
C1034 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/nor_0/A 0.15fF
C1035 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1036 pll_full_0/ro_complete_0/cbank_2/v pll_full_0/divider_0/clk 1.36fF
C1037 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/Qbar 0.01fF
C1038 pd_0/tspc_r_0/Z3 pd_0/R 0.27fF
C1039 divbuf_13/IN divbuf_13/OUT5 0.00fF
C1040 cp_0/a_1710_0# cp_0/out 0.84fF
C1041 pd_1/tspc_r_1/Z2 pd_1/tspc_r_1/Z4 0.14fF
C1042 divbuf_20/OUT divbuf_19/OUT 3.23fF
C1043 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C1044 divbuf_2/IN divbuf_2/a_492_n240# 0.13fF
C1045 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/v 1.30fF
C1046 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1047 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1048 divider_1/tspc_0/Z4 divider_1/tspc_0/Z3 0.65fF
C1049 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z1 0.08fF
C1050 divider_0/prescaler_0/Out divider_0/nor_0/A 0.15fF
C1051 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1052 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/clk 0.14fF
C1053 divider_0/nor_1/Z1 divider_0/and_0/B 0.78fF
C1054 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_1/Q 0.01fF
C1055 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C1056 divbuf_19/OUT divbuf_19/OUT2 0.06fF
C1057 divider_1/prescaler_0/tspc_0/D divider_1/prescaler_0/nand_1/z1 0.21fF
C1058 divbuf_6/OUT3 divbuf_6/OUT5 0.01fF
C1059 divbuf_6/OUT2 divbuf_6/OUT 0.06fF
C1060 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Qbar1 0.38fF
C1061 divider_2/nor_0/B divider_2/tspc_2/Q 0.22fF
C1062 divider_2/prescaler_0/m1_2700_2190# divider_2/and_0/OUT 0.14fF
C1063 divbuf_0/OUT3 divbuf_0/OUT5 0.01fF
C1064 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z3 0.05fF
C1065 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1066 divbuf_21/a_492_n240# divbuf_21/OUT5 0.01fF
C1067 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divbuf_0/IN 0.05fF
C1068 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C1069 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/A 0.80fF
C1070 pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_0/divider_0/clk 1.46fF
C1071 divider_1/tspc_2/Z1 divider_1/tspc_2/Z4 0.00fF
C1072 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/Z1 0.04fF
C1073 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/clk 0.05fF
C1074 pd_1/DOWN pd_1/tspc_r_0/Qbar1 0.11fF
C1075 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Z1 0.02fF
C1076 divbuf_12/OUT2 divbuf_12/OUT5 0.02fF
C1077 divbuf_12/OUT3 divbuf_12/OUT4 5.16fF
C1078 divider_2/prescaler_0/tspc_2/Z4 divider_2/prescaler_0/tspc_2/D 0.11fF
C1079 divbuf_14/a_492_n240# divbuf_14/OUT2 0.42fF
C1080 io_clamp_low[0] io_clamp_high[0] 0.53fF
C1081 divider_0/tspc_0/Z3 divider_0/Out 0.05fF
C1082 divider_0/tspc_0/Z2 divider_0/nor_1/B 0.40fF
C1083 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z3 0.33fF
C1084 divbuf_3/a_492_n240# divbuf_3/OUT 0.00fF
C1085 divbuf_16/OUT5 divbuf_16/OUT 43.38fF
C1086 divider_1/prescaler_0/tspc_0/Z2 divider_1/clk 0.11fF
C1087 divider_0/and_0/OUT divider_0/and_0/Z1 0.04fF
C1088 divider_0/prescaler_0/tspc_2/Q divider_0/clk 0.05fF
C1089 divbuf_20/OUT4 divbuf_20/OUT5 20.26fF
C1090 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z4 0.36fF
C1091 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C1092 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C1093 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Qbar1 0.12fF
C1094 divbuf_17/a_492_n240# divbuf_17/IN 0.13fF
C1095 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/clk 0.14fF
C1096 pd_1/DOWN pd_1/and_pd_0/Z1 0.07fF
C1097 pd_1/REF pd_1/tspc_r_1/Z1 0.17fF
C1098 pd_1/tspc_r_1/Qbar1 pd_1/UP 0.11fF
C1099 divider_2/prescaler_0/tspc_2/Z3 divider_2/clk 0.45fF
C1100 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/a_740_n680# 0.33fF
C1101 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1102 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/tspc_r_1/Z4 0.14fF
C1103 ro_complete_1/a2 ro_complete_1/cbank_2/switch_2/vin 0.14fF
C1104 ro_complete_1/a3 ro_complete_1/cbank_2/switch_1/vin 0.13fF
C1105 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT4 1.11fF
C1106 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/nand_0/z1 0.07fF
C1107 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/D 0.05fF
C1108 pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1109 divbuf_15/OUT4 divbuf_15/OUT3 5.16fF
C1110 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C1111 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/clk 0.01fF
C1112 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Z4 0.65fF
C1113 divbuf_23/OUT3 divbuf_23/OUT5 0.01fF
C1114 divider_2/tspc_2/Z2 divider_2/tspc_2/Z3 0.16fF
C1115 divider_2/nor_0/A divider_2/tspc_2/Z4 0.21fF
C1116 divider_0/nor_0/Z1 divider_0/nor_0/B 0.06fF
C1117 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_5/vin 0.20fF
C1118 divbuf_20/OUT divbuf_20/OUT4 1.11fF
C1119 divbuf_21/OUT divbuf_21/OUT5 43.38fF
C1120 ro_complete_1/a5 ro_complete_1/cbank_2/v 0.08fF
C1121 divbuf_15/OUT2 divbuf_15/OUT3 1.37fF
C1122 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Q 0.05fF
C1123 divider_0/prescaler_0/m1_2700_2190# divider_0/clk 0.01fF
C1124 divbuf_5/OUT4 divbuf_5/OUT 1.11fF
C1125 divider_1/tspc_0/Z2 divider_1/nor_1/B 0.40fF
C1126 divbuf_22/a_492_n240# divbuf_22/OUT5 0.01fF
C1127 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z3 0.25fF
C1128 pd_0/tspc_r_1/Z2 pd_0/tspc_r_1/Z4 0.14fF
C1129 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z2 0.01fF
C1130 divider_2/tspc_2/Q divider_2/tspc_1/Z3 0.45fF
C1131 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z4 0.00fF
C1132 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Q 0.21fF
C1133 divbuf_19/OUT divbuf_19/a_492_n240# 0.00fF
C1134 divbuf_25/OUT2 divbuf_25/OUT5 0.02fF
C1135 divbuf_25/OUT3 divbuf_25/OUT4 5.16fF
C1136 divider_2/and_0/B divider_2/and_0/Z1 0.07fF
C1137 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z4 0.01fF
C1138 divbuf_1/IN divbuf_1/a_492_n240# 0.13fF
C1139 divbuf_0/OUT4 divbuf_0/OUT5 20.26fF
C1140 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_0/vin 0.19fF
C1141 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/v 1.30fF
C1142 ro_complete_1/a0 ro_complete_1/cbank_2/switch_5/vin 0.09fF
C1143 io_clamp_high[2] io_analog[6] 0.53fF
C1144 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C1145 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/clk 0.01fF
C1146 divbuf_11/OUT3 divbuf_11/OUT 0.26fF
C1147 divbuf_11/OUT4 divbuf_11/OUT5 20.26fF
C1148 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z1 0.08fF
C1149 cp_0/a_1710_n2840# cp_0/a_1710_0# 0.83fF
C1150 divider_2/prescaler_0/tspc_1/Z4 divider_2/clk 0.12fF
C1151 divbuf_0/OUT3 divbuf_0/OUT4 5.16fF
C1152 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C1153 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z1 0.17fF
C1154 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/UP 0.11fF
C1155 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Q 0.15fF
C1156 divider_0/prescaler_0/tspc_0/Z2 divider_0/and_0/OUT 0.06fF
C1157 divbuf_1/OUT2 divbuf_1/a_492_n240# 0.42fF
C1158 pll_full_0/divbuf_0/OUT4 pll_full_0/divbuf_0/OUT5 20.26fF
C1159 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1160 divbuf_10/a_492_n240# divbuf_10/OUT 0.00fF
C1161 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z2 0.11fF
C1162 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C1163 pd_1/DIV pd_1/tspc_r_0/Z2 0.19fF
C1164 pd_0/DOWN pd_0/R 0.36fF
C1165 pd_0/tspc_r_0/Z1 pd_0/tspc_r_0/Z2 0.71fF
C1166 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z4 0.20fF
C1167 pd_0/DIV pd_0/tspc_r_0/z5 0.04fF
C1168 cp_0/a_1710_0# cp_0/down 0.32fF
C1169 divider_2/prescaler_0/tspc_1/Q divider_2/clk 0.60fF
C1170 divbuf_13/OUT3 divbuf_13/OUT5 0.01fF
C1171 divbuf_13/OUT2 divbuf_13/OUT 0.06fF
C1172 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/cbank_0/switch_1/vin 0.19fF
C1173 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_4/vin 0.20fF
C1174 divider_1/tspc_0/Z4 divider_1/tspc_0/a_630_n680# 0.12fF
C1175 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z3 0.11fF
C1176 divider_0/prescaler_0/Out divider_0/tspc_2/Z2 0.11fF
C1177 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/clk 0.01fF
C1178 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C1179 divbuf_16/OUT4 divbuf_16/OUT 1.11fF
C1180 divbuf_5/a_492_n240# divbuf_5/IN 0.13fF
C1181 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z3 0.06fF
C1182 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C1183 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1184 divbuf_6/OUT4 divbuf_6/OUT 1.11fF
C1185 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C1186 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/clk 0.01fF
C1187 divider_2/nor_1/B divider_2/tspc_0/Z1 0.03fF
C1188 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z4 0.01fF
C1189 divbuf_8/a_492_n240# divbuf_8/OUT5 0.01fF
C1190 pd_0/tspc_r_0/Z4 pd_0/tspc_r_1/Z4 0.02fF
C1191 pd_0/DOWN pd_0/and_pd_0/Out1 0.12fF
C1192 pd_0/REF pd_0/tspc_r_1/Z1 0.17fF
C1193 pd_0/tspc_r_1/Qbar1 pd_0/UP 0.11fF
C1194 divider_2/tspc_0/Z1 divider_2/tspc_0/Z3 0.06fF
C1195 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_2/D 0.16fF
C1196 divider_2/prescaler_0/tspc_0/Z2 divider_2/clk 0.11fF
C1197 divbuf_19/IN divbuf_19/OUT5 0.00fF
C1198 divbuf_1/OUT2 divbuf_1/OUT3 1.37fF
C1199 divbuf_21/OUT ro_complete_0/cbank_1/v 0.05fF
C1200 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z4 0.12fF
C1201 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1202 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C1203 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_2/Q 0.19fF
C1204 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/clk 0.01fF
C1205 divbuf_1/OUT5 divbuf_1/a_492_n240# 0.01fF
C1206 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C1207 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1208 divider_1/nor_1/B divider_1/nor_0/B 0.47fF
C1209 divider_1/tspc_0/Z2 divider_1/tspc_0/Z1 1.07fF
C1210 divbuf_21/OUT2 divbuf_21/OUT3 1.37fF
C1211 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Q 0.22fF
C1212 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/nor_1/B 0.35fF
C1213 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C1214 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C1215 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/nor_0/A 0.35fF
C1216 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/clk 0.29fF
C1217 divbuf_18/OUT5 divbuf_18/a_492_n240# 0.01fF
C1218 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Q 0.15fF
C1219 divider_1/tspc_2/Z3 divider_1/tspc_2/Z4 0.65fF
C1220 divbuf_12/OUT3 divbuf_12/OUT 0.26fF
C1221 divbuf_12/OUT4 divbuf_12/OUT5 20.26fF
C1222 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/z5 0.04fF
C1223 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/cbank_1/switch_1/vin 0.19fF
C1224 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z3 0.29fF
C1225 divider_0/nor_0/B divider_0/tspc_2/Q 0.22fF
C1226 divider_0/tspc_0/a_630_n680# divider_0/nor_1/B 0.35fF
C1227 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z3 0.05fF
C1228 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z4 0.08fF
C1229 pll_full_0/pd_0/DIV pll_full_0/divider_0/clk 2.26fF
C1230 divider_1/prescaler_0/Out divider_1/clk 0.51fF
C1231 divider_0/tspc_2/a_630_n680# divider_0/nor_0/A 0.35fF
C1232 divider_0/prescaler_0/tspc_0/D divider_0/clk 0.29fF
C1233 divbuf_3/IN divbuf_3/OUT5 0.00fF
C1234 ro_complete_1/cbank_1/v ro_complete_1/cbank_2/v 1.36fF
C1235 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_1/B 0.00fF
C1236 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C1237 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1238 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C1239 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C1240 divbuf_7/a_492_n240# divbuf_7/OUT 0.00fF
C1241 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/A 0.01fF
C1242 divbuf_17/a_492_n240# divbuf_17/OUT2 0.42fF
C1243 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z2 0.25fF
C1244 divider_2/prescaler_0/tspc_2/Z4 divider_2/clk 0.12fF
C1245 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/a_740_n680# 0.08fF
C1246 divbuf_1/OUT3 divbuf_1/OUT5 0.01fF
C1247 divider_0/tspc_1/a_630_n680# divider_0/nor_1/B 0.00fF
C1248 divider_0/prescaler_0/tspc_1/Z2 divider_0/and_0/OUT 0.06fF
C1249 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1250 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Q 0.38fF
C1251 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_0/D 0.11fF
C1252 divider_0/nor_0/Z1 divider_0/and_0/A 0.80fF
C1253 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT2 0.42fF
C1254 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C1255 divbuf_16/OUT2 divbuf_16/OUT 0.06fF
C1256 divider_0/and_0/out1 divider_0/and_0/A 0.01fF
C1257 divbuf_4/IN divbuf_4/OUT5 0.00fF
C1258 divbuf_6/a_492_n240# divbuf_6/IN 0.13fF
C1259 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C1260 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/A 0.26fF
C1261 pd_0/R pd_0/tspc_r_1/Z3 0.29fF
C1262 divbuf_9/a_492_n240# divbuf_9/OUT5 0.01fF
C1263 divider_2/tspc_2/Z2 divider_2/tspc_2/Z4 0.36fF
C1264 divbuf_23/OUT ro_complete_0/cbank_1/switch_0/vin 0.09fF
C1265 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/v 1.30fF
C1266 divider_0/tspc_0/Z2 divider_0/tspc_0/a_630_n680# 0.01fF
C1267 ro_complete_1/a1 ro_complete_1/cbank_1/v 0.05fF
C1268 divider_1/nor_1/Z1 divider_1/nor_0/B 0.18fF
C1269 divider_1/tspc_0/Z4 divider_1/tspc_1/Q 0.15fF
C1270 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/clk 0.01fF
C1271 divider_0/nor_0/B divider_0/and_0/A 0.26fF
C1272 divider_2/tspc_1/Q divider_2/tspc_1/a_630_n680# 0.04fF
C1273 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C1274 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z4 0.00fF
C1275 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/divider_0/clk 1.46fF
C1276 divider_2/nor_1/B divider_2/tspc_0/Z3 0.38fF
C1277 divbuf_22/OUT2 divbuf_22/OUT3 1.37fF
C1278 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/B 0.29fF
C1279 pd_1/tspc_r_0/Qbar pd_1/tspc_r_0/Qbar1 0.01fF
C1280 divider_2/mc2 divider_2/and_0/out1 0.06fF
C1281 divider_2/tspc_2/Q divider_2/tspc_1/Z4 0.15fF
C1282 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Z4 0.65fF
C1283 divbuf_25/OUT3 divbuf_25/OUT 0.26fF
C1284 divbuf_25/OUT4 divbuf_25/OUT5 20.26fF
C1285 divbuf_19/OUT ro_complete_0/cbank_1/v 0.05fF
C1286 ro_complete_1/a0 ro_complete_1/cbank_2/v 0.05fF
C1287 divider_0/nor_1/B divider_0/and_0/B 0.29fF
C1288 io_clamp_low[1] io_analog[5] 0.53fF
C1289 divbuf_20/a_492_n240# divbuf_20/OUT2 0.42fF
C1290 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z2 1.07fF
C1291 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z3 0.38fF
C1292 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_1/B 0.22fF
C1293 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z3 0.11fF
C1294 divbuf_11/OUT5 divbuf_11/OUT 43.38fF
C1295 divbuf_24/a_492_n240# divbuf_24/OUT 0.00fF
C1296 pd_1/R pd_1/tspc_r_1/Qbar 0.03fF
C1297 divider_2/tspc_2/Q divider_2/tspc_2/Z3 0.05fF
C1298 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z3 0.16fF
C1299 divbuf_20/OUT ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1300 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/tspc_r_1/z5 0.02fF
C1301 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z2 0.25fF
C1302 divbuf_2/IN divbuf_2/OUT5 0.00fF
C1303 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT2 1.37fF
C1304 divider_0/tspc_1/Z1 divider_0/tspc_1/Z2 1.07fF
C1305 divider_0/nor_0/B divider_0/tspc_1/Z3 0.38fF
C1306 divider_0/tspc_1/Q divider_0/nor_1/B 0.22fF
C1307 divider_1/nor_0/B divider_1/tspc_2/a_630_n680# 0.01fF
C1308 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/D 0.03fF
C1309 divbuf_10/IN divbuf_10/OUT5 0.00fF
C1310 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/and_0/OUT 0.05fF
C1311 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/z5 0.20fF
C1312 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Qbar1 0.38fF
C1313 divider_2/tspc_0/Z4 divider_2/tspc_0/Z1 0.00fF
C1314 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C1315 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z3 0.33fF
C1316 divbuf_23/a_492_n240# divbuf_23/IN 0.13fF
C1317 divbuf_19/OUT divbuf_19/OUT3 0.26fF
C1318 divbuf_13/OUT4 divbuf_13/OUT 1.11fF
C1319 pd_1/UP pd_1/and_pd_0/Out1 0.33fF
C1320 divider_2/and_0/OUT divider_2/and_0/Z1 0.04fF
C1321 divider_2/prescaler_0/tspc_2/Q divider_2/clk 0.05fF
C1322 divbuf_21/OUT divbuf_22/OUT 2.71fF
C1323 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C1324 ro_complete_1/a4 ro_complete_1/cbank_0/switch_1/vin 0.09fF
C1325 divbuf_2/OUT5 divbuf_2/a_492_n240# 0.01fF
C1326 ro_complete_1/a3 ro_complete_1/cbank_2/switch_2/vin 0.09fF
C1327 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C1328 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1329 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z4 0.28fF
C1330 divider_0/prescaler_0/tspc_2/Z2 divider_0/and_0/OUT 0.05fF
C1331 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1332 divbuf_16/OUT3 divbuf_16/OUT 0.26fF
C1333 divider_1/tspc_0/Z2 divider_1/tspc_0/Z3 0.16fF
C1334 divider_1/prescaler_0/tspc_1/Q divider_1/nor_0/A 0.03fF
C1335 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_0/A 0.15fF
C1336 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C1337 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C1338 pd_1/tspc_r_0/Qbar pd_1/DOWN 0.21fF
C1339 pd_0/tspc_r_0/z5 pd_0/tspc_r_1/z5 0.02fF
C1340 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z2 0.25fF
C1341 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z2 0.19fF
C1342 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/nand_0/z1 0.07fF
C1343 divider_2/prescaler_0/Out divider_2/clk 0.51fF
C1344 divbuf_8/OUT2 divbuf_8/OUT3 1.37fF
C1345 pll_full_0/pd_0/DOWN pll_full_0/pd_0/UP 4.58fF
C1346 divbuf_19/OUT divbuf_18/OUT 2.98fF
C1347 divider_0/tspc_0/Z2 divider_0/tspc_1/Q 0.14fF
C1348 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1349 divbuf_22/OUT ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1350 pll_full_0/pd_0/DIV pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C1351 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/v 1.30fF
C1352 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Q 0.91fF
C1353 divider_0/tspc_1/Z2 divider_0/nor_0/A 0.15fF
C1354 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_0/D 0.32fF
C1355 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/clk 0.01fF
C1356 divbuf_21/OUT2 divbuf_21/OUT5 0.02fF
C1357 divbuf_21/OUT3 divbuf_21/OUT4 5.16fF
C1358 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C1359 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1360 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/divider_0/clk 1.46fF
C1361 divider_1/tspc_2/Q divider_1/tspc_2/a_630_n680# 0.04fF
C1362 divbuf_11/a_492_n240# divbuf_11/OUT2 0.42fF
C1363 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z2 0.01fF
C1364 pd_1/R pd_1/tspc_r_0/Qbar1 0.01fF
C1365 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C1366 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Q 0.05fF
C1367 divider_2/prescaler_0/m1_2700_2190# divider_2/clk 0.01fF
C1368 divbuf_12/OUT5 divbuf_12/OUT 43.38fF
C1369 divbuf_14/a_492_n240# divbuf_14/OUT 0.00fF
C1370 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a4 0.12fF
C1371 pll_full_0/pd_0/R pll_full_0/pd_0/UP 0.46fF
C1372 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/a_630_n680# 0.05fF
C1373 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z4 0.12fF
C1374 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1375 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/v 1.30fF
C1376 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1377 divbuf_3/OUT3 divbuf_3/OUT5 0.01fF
C1378 divbuf_3/OUT2 divbuf_3/OUT 0.06fF
C1379 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z2 0.01fF
C1380 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z2 0.01fF
C1381 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z3 0.45fF
C1382 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1383 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1384 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C1385 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/clk 0.01fF
C1386 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/Out 0.21fF
C1387 divider_1/mc2 divider_1/and_0/out1 0.06fF
C1388 pd_0/DIV pd_0/tspc_r_0/Qbar1 0.12fF
C1389 divider_2/mc2 divider_2/nor_0/B 0.06fF
C1390 divbuf_7/IN divbuf_7/OUT5 0.00fF
C1391 pd_1/R pd_1/and_pd_0/Z1 0.02fF
C1392 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/Qbar 0.01fF
C1393 divbuf_19/a_492_n240# divbuf_19/IN 0.13fF
C1394 divbuf_13/a_492_n240# divbuf_13/IN 0.13fF
C1395 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1396 pll_full_0/pd_0/UP pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C1397 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z2 0.01fF
C1398 divider_0/tspc_2/Q divider_0/tspc_1/Z3 0.45fF
C1399 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1400 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1401 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Q 0.04fF
C1402 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/a_492_n240# 0.01fF
C1403 divbuf_4/OUT3 divbuf_4/OUT5 0.01fF
C1404 divbuf_4/OUT2 divbuf_4/OUT 0.06fF
C1405 divider_2/nor_1/B divider_2/tspc_0/Z4 0.22fF
C1406 pd_0/R pd_0/UP 0.45fF
C1407 divider_2/tspc_0/Z4 divider_2/tspc_0/Z3 0.65fF
C1408 divbuf_9/OUT2 divbuf_9/OUT3 1.37fF
C1409 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C1410 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/a_740_n680# 0.19fF
C1411 divbuf_1/OUT4 divbuf_1/OUT5 20.26fF
C1412 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1413 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C1414 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_1/B 0.06fF
C1415 divbuf_22/OUT2 divbuf_22/OUT5 0.02fF
C1416 divbuf_22/OUT3 divbuf_22/OUT4 5.16fF
C1417 divider_2/tspc_0/Z2 divider_2/nor_0/B 0.20fF
C1418 pd_1/DOWN pd_1/R 0.36fF
C1419 pd_0/UP pd_0/and_pd_0/Out1 0.33fF
C1420 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/DOWN 0.11fF
C1421 divider_2/mc2 divider_2/and_0/A 0.16fF
C1422 divbuf_12/a_492_n240# divbuf_12/OUT2 0.42fF
C1423 divbuf_25/OUT5 divbuf_25/OUT 43.38fF
C1424 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z1 0.08fF
C1425 divider_0/mc2 divider_0/nor_1/B 0.15fF
C1426 divbuf_0/OUT2 divbuf_0/OUT5 0.02fF
C1427 divbuf_18/OUT4 divbuf_18/OUT3 5.16fF
C1428 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1429 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z4 0.21fF
C1430 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/nor_1/B 0.38fF
C1431 divider_1/nor_0/B divider_1/tspc_1/Z2 0.30fF
C1432 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z2 0.01fF
C1433 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/B 0.08fF
C1434 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z4 0.28fF
C1435 divider_1/and_0/out1 divider_1/and_0/B 0.18fF
C1436 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/R 0.01fF
C1437 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_2/Q 0.19fF
C1438 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/clk 0.01fF
C1439 divbuf_24/IN divbuf_24/OUT5 0.00fF
C1440 divbuf_0/OUT3 divbuf_0/OUT2 1.37fF
C1441 ro_complete_0/cbank_0/switch_0/vin divbuf_21/OUT 0.12fF
C1442 divbuf_20/OUT ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1443 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Qbar 0.01fF
C1444 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z4 0.36fF
C1445 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/Out 0.05fF
C1446 divider_0/nor_0/B divider_0/tspc_1/Z4 0.21fF
C1447 divider_0/tspc_0/Z3 divider_0/nor_1/B 0.38fF
C1448 divbuf_2/OUT3 divbuf_2/OUT5 0.01fF
C1449 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1450 divider_0/nor_0/A divider_0/and_0/B 0.08fF
C1451 divbuf_4/a_492_n240# divbuf_4/OUT2 0.42fF
C1452 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z2 1.07fF
C1453 divbuf_10/OUT3 divbuf_10/OUT5 0.01fF
C1454 divbuf_10/OUT2 divbuf_10/OUT 0.06fF
C1455 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C1456 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C1457 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/clk 0.11fF
C1458 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/Z3 0.06fF
C1459 divider_1/and_0/OUT divider_1/prescaler_0/nand_0/z1 0.01fF
C1460 divider_1/nor_0/B divider_1/nor_0/A 1.21fF
C1461 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Q 0.91fF
C1462 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z3 0.05fF
C1463 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z4 0.08fF
C1464 divbuf_18/OUT divbuf_18/a_492_n240# 0.00fF
C1465 divider_2/tspc_2/a_630_n680# divider_2/nor_0/A 0.35fF
C1466 divider_2/prescaler_0/tspc_0/D divider_2/clk 0.29fF
C1467 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a5 0.09fF
C1468 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1469 pll_full_0/pd_0/REF pll_full_0/divbuf_1/a_492_n240# 0.13fF
C1470 divbuf_21/OUT divbuf_21/a_492_n240# 0.00fF
C1471 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/cbank_0/v 1.30fF
C1472 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Q 0.20fF
C1473 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/D 0.09fF
C1474 divider_0/prescaler_0/tspc_0/Z2 divider_0/clk 0.11fF
C1475 divider_2/tspc_1/Q divider_2/tspc_0/Z1 0.01fF
C1476 divider_1/mc2 divider_1/nor_0/B 0.06fF
C1477 divider_1/tspc_2/Q divider_1/tspc_1/Z2 0.14fF
C1478 divider_1/tspc_0/Z2 divider_1/tspc_0/a_630_n680# 0.01fF
C1479 divbuf_5/a_492_n240# divbuf_5/OUT5 0.01fF
C1480 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_1/Q 0.01fF
C1481 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C1482 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/Out 0.05fF
C1483 pll_full_0/ro_complete_0/a2 pll_full_0/divider_0/clk 0.11fF
C1484 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C1485 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C1486 divider_1/and_0/OUT divider_1/clk 0.04fF
C1487 divbuf_8/OUT2 divbuf_8/OUT5 0.02fF
C1488 divbuf_8/OUT3 divbuf_8/OUT4 5.16fF
C1489 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/Qbar 0.01fF
C1490 divbuf_17/OUT3 divbuf_17/OUT2 1.37fF
C1491 divider_2/tspc_2/Q divider_2/tspc_1/a_630_n680# 0.01fF
C1492 divider_2/prescaler_0/tspc_1/Z2 divider_2/and_0/OUT 0.06fF
C1493 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z3 0.33fF
C1494 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Q 0.38fF
C1495 divider_2/and_0/out1 divider_2/and_0/A 0.01fF
C1496 divbuf_25/a_492_n240# divbuf_25/OUT2 0.42fF
C1497 ro_complete_1/a4 ro_complete_1/cbank_2/switch_0/vin 0.12fF
C1498 divbuf_23/OUT ro_complete_0/cbank_1/v 0.10fF
C1499 ro_complete_0/cbank_0/switch_5/vin divbuf_18/OUT 0.09fF
C1500 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT 43.38fF
C1501 divbuf_16/a_492_n240# divbuf_16/OUT5 0.01fF
C1502 divider_0/tspc_0/a_630_n680# divider_0/tspc_1/Q 0.01fF
C1503 divider_0/tspc_0/Z2 divider_0/tspc_0/Z3 0.16fF
C1504 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z4 0.36fF
C1505 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/Out 0.05fF
C1506 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/D 0.09fF
C1507 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/nand_1/z1 0.22fF
C1508 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/tspc_0/D 0.04fF
C1509 divider_1/tspc_2/Q divider_1/nor_0/A 0.55fF
C1510 divider_1/nor_0/B divider_1/tspc_1/Z1 0.03fF
C1511 divbuf_21/OUT4 divbuf_21/OUT5 20.26fF
C1512 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.04fF
C1513 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C1514 pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_0/divider_0/clk 1.58fF
C1515 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z2 0.23fF
C1516 divider_1/nor_0/A divider_1/and_0/A 0.01fF
C1517 pd_1/tspc_r_0/z5 pd_1/tspc_r_0/Z3 0.11fF
C1518 divbuf_19/OUT4 divbuf_19/OUT5 20.26fF
C1519 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/clk 0.01fF
C1520 divbuf_14/IN divbuf_14/OUT5 0.00fF
C1521 divbuf_1/OUT2 divbuf_1/OUT 0.06fF
C1522 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/a0 0.13fF
C1523 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a4 0.12fF
C1524 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1525 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/a_630_n680# 0.12fF
C1526 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z1 1.07fF
C1527 divider_0/tspc_1/Q divider_0/tspc_1/a_630_n680# 0.04fF
C1528 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z3 0.16fF
C1529 divbuf_3/OUT4 divbuf_3/OUT 1.11fF
C1530 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z2 0.01fF
C1531 divider_0/nor_0/A divider_0/tspc_2/Z2 0.23fF
C1532 divider_1/prescaler_0/m1_2700_2190# divider_1/nor_0/A 0.01fF
C1533 divider_1/mc2 divider_1/and_0/A 0.16fF
C1534 divider_1/tspc_1/Z2 divider_1/tspc_1/Z3 0.16fF
C1535 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/D 0.15fF
C1536 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z4 0.15fF
C1537 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/nor_1/B 0.22fF
C1538 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1539 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1540 pd_0/tspc_r_0/Z3 pd_0/DOWN 0.03fF
C1541 divbuf_7/OUT3 divbuf_7/OUT5 0.01fF
C1542 divbuf_7/OUT2 divbuf_7/OUT 0.06fF
C1543 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/Z1 0.36fF
C1544 divbuf_17/OUT5 divbuf_17/IN 0.00fF
C1545 divider_2/nor_1/B divider_2/and_0/B 0.29fF
C1546 pd_1/tspc_r_1/Z1 pd_1/tspc_r_1/Z2 0.71fF
C1547 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z4 0.20fF
C1548 pd_1/REF pd_1/tspc_r_1/z5 0.04fF
C1549 pll_full_0/pd_0/DOWN pll_full_0/cp_0/a_1710_0# 0.04fF
C1550 ro_complete_0/cbank_0/switch_1/vin divbuf_22/OUT 0.13fF
C1551 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1552 divider_1/prescaler_0/Out divider_1/prescaler_0/m1_2700_2190# 0.11fF
C1553 divider_0/tspc_2/Q divider_0/tspc_1/Z4 0.15fF
C1554 divider_0/tspc_0/Z4 divider_0/nor_1/B 0.22fF
C1555 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1556 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1557 divbuf_23/OUT divbuf_23/OUT3 0.26fF
C1558 divbuf_4/OUT4 divbuf_4/OUT 1.11fF
C1559 divider_1/tspc_2/Q divider_1/tspc_1/Z1 0.01fF
C1560 divider_1/tspc_1/a_630_n680# divider_1/nor_0/B 0.35fF
C1561 divider_0/and_0/out1 divider_0/and_0/Z1 0.36fF
C1562 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C1563 divider_1/nor_0/B divider_1/and_0/B 0.31fF
C1564 divbuf_6/a_492_n240# divbuf_6/OUT5 0.01fF
C1565 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/Z3 0.05fF
C1566 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/clk 0.11fF
C1567 pd_1/DIV pd_1/tspc_r_0/z5 0.04fF
C1568 divbuf_9/OUT2 divbuf_9/OUT5 0.02fF
C1569 divbuf_9/OUT3 divbuf_9/OUT4 5.16fF
C1570 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/v 1.30fF
C1571 divbuf_1/OUT5 divbuf_1/OUT 43.38fF
C1572 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/a0 0.09fF
C1573 divider_2/tspc_1/Q divider_2/nor_1/B 0.22fF
C1574 divider_0/tspc_2/Q divider_0/tspc_2/Z3 0.05fF
C1575 divider_0/prescaler_0/tspc_1/Z2 divider_0/clk 0.11fF
C1576 divider_2/tspc_1/Q divider_2/tspc_0/Z3 0.45fF
C1577 divider_1/tspc_0/Z2 divider_1/tspc_1/Q 0.14fF
C1578 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z3 0.06fF
C1579 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1580 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C1581 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z3 0.05fF
C1582 divider_1/nor_0/A divider_1/tspc_2/Z1 0.03fF
C1583 divbuf_22/OUT4 divbuf_22/OUT5 20.26fF
C1584 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z2 0.25fF
C1585 divbuf_18/a_492_n240# divbuf_18/IN 0.13fF
C1586 divider_2/prescaler_0/tspc_2/Z2 divider_2/and_0/OUT 0.05fF
C1587 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C1588 divbuf_18/OUT ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1589 ro_complete_0/cbank_0/v ro_complete_0/cbank_1/v 1.27fF
C1590 divider_0/tspc_0/Z2 divider_0/tspc_0/Z4 0.36fF
C1591 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1592 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z3 0.11fF
C1593 divbuf_3/a_492_n240# divbuf_3/IN 0.13fF
C1594 ro_complete_1/cbank_2/switch_2/vin ro_complete_1/cbank_2/v 1.30fF
C1595 divbuf_18/OUT4 divbuf_18/OUT5 20.26fF
C1596 divider_1/tspc_2/Q divider_1/tspc_1/a_630_n680# 0.01fF
C1597 io_clamp_high[0] io_analog[4] 0.53fF
C1598 divider_2/nor_0/Z1 divider_2/nor_0/B 0.06fF
C1599 divider_1/tspc_1/Z1 divider_1/tspc_1/Z3 0.06fF
C1600 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1601 pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_0/divider_0/clk 1.46fF
C1602 divider_1/and_0/A divider_1/and_0/B 0.18fF
C1603 divbuf_24/OUT3 divbuf_24/OUT5 0.01fF
C1604 divbuf_24/OUT2 divbuf_24/OUT 0.06fF
C1605 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/z5 0.11fF
C1606 divider_2/tspc_1/Z2 divider_2/nor_0/A 0.15fF
C1607 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_0/D 0.32fF
C1608 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/clk 0.01fF
C1609 divider_2/nor_0/B divider_2/and_0/A 0.26fF
C1610 divbuf_20/OUT ro_complete_0/cbank_2/switch_3/vin 0.09fF
C1611 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/pd_0/tspc_r_1/Z2 0.71fF
C1612 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z4 0.20fF
C1613 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C1614 divider_0/mc2 divider_0/nor_0/A 0.04fF
C1615 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C1616 ro_complete_1/a5 ro_complete_1/cbank_2/switch_0/vin 0.09fF
C1617 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/OUT2 0.02fF
C1618 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a3 0.13fF
C1619 divider_1/nor_0/Z1 divider_1/and_0/B 0.18fF
C1620 divbuf_10/OUT4 divbuf_10/OUT 1.11fF
C1621 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/Z4 0.00fF
C1622 divider_1/prescaler_0/tspc_2/D divider_1/prescaler_0/nand_0/z1 0.24fF
C1623 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Z4 0.65fF
C1624 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1625 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/clk 0.51fF
C1626 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z4 0.12fF
C1627 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z2 1.07fF
C1628 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_0/D 0.09fF
C1629 divbuf_23/a_492_n240# divbuf_23/OUT5 0.01fF
C1630 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Out1 0.05fF
C1631 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z2 0.01fF
C1632 divider_1/Out divider_1/nor_1/B 0.22fF
C1633 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C1634 divider_0/tspc_1/Z3 divider_0/tspc_1/Z4 0.65fF
C1635 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Q 0.04fF
C1636 divider_0/prescaler_0/Out divider_0/clk 0.51fF
C1637 divbuf_2/OUT2 divbuf_2/OUT 0.06fF
C1638 divbuf_5/OUT2 divbuf_5/OUT3 1.37fF
C1639 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z3 0.05fF
C1640 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z3 0.05fF
C1641 divider_2/nor_1/B divider_2/tspc_0/a_630_n680# 0.35fF
C1642 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z4 0.65fF
C1643 divider_2/nor_0/Z1 divider_2/and_0/A 0.80fF
C1644 divider_1/and_0/OUT divider_1/and_0/out1 0.31fF
C1645 divider_1/prescaler_0/tspc_2/D divider_1/clk 0.26fF
C1646 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C1647 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/clk 0.11fF
C1648 pd_0/tspc_r_1/Z1 pd_0/tspc_r_1/Z2 0.71fF
C1649 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z4 0.20fF
C1650 pd_0/REF pd_0/tspc_r_1/z5 0.04fF
C1651 divider_2/tspc_1/Z1 divider_2/tspc_1/Z2 1.07fF
C1652 divider_2/nor_0/B divider_2/tspc_1/Z3 0.38fF
C1653 divider_2/tspc_0/a_630_n680# divider_2/tspc_0/Z3 0.05fF
C1654 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z3 0.05fF
C1655 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z4 0.08fF
C1656 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Q 0.04fF
C1657 divbuf_8/OUT3 divbuf_8/OUT 0.26fF
C1658 divbuf_8/OUT4 divbuf_8/OUT5 20.26fF
C1659 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_1/Qbar 0.02fF
C1660 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z3 0.05fF
C1661 divbuf_20/OUT ro_complete_0/cbank_2/v 0.05fF
C1662 divbuf_15/OUT divbuf_15/OUT5 43.38fF
C1663 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/nand_1/z1 0.01fF
C1664 divider_0/prescaler_0/tspc_2/Z2 divider_0/clk 0.11fF
Xpd_0 vdda1 vssa1 pd_0/REF pd_0/DIV pd_0/UP pd_0/DOWN pd_0/R pd
Xpd_1 vdda1 vssa1 pd_1/REF pd_1/DIV pd_1/UP pd_1/DOWN pd_1/R pd
Xcp_0 cp_0/vbias vdda1 gnd cp_0/out cp_0/down cp_0/upbar cp
Xfilter_0 vssa1 filter_0/v filter
Xro_complete_0 divbuf_18/OUT divbuf_19/OUT divbuf_23/OUT divbuf_21/OUT divbuf_22/OUT
+ divbuf_20/OUT ro_complete
Xro_complete_1 ro_complete_1/a0 ro_complete_1/a1 ro_complete_1/a5 ro_complete_1/a4
+ ro_complete_1/a3 ro_complete_1/a2 ro_complete
Xdivbuf_0 vdda1 divbuf_0/IN filter_0/v divbuf_0/OUT2 divbuf_0/OUT3 divbuf_0/OUT4 divbuf_0/OUT5
+ vssa1 divbuf
Xdivbuf_1 vdda1 divbuf_1/IN divbuf_1/OUT divbuf_1/OUT2 divbuf_1/OUT3 divbuf_1/OUT4
+ divbuf_1/OUT5 vssa1 divbuf
Xdivbuf_2 vdda1 divbuf_2/IN divbuf_2/OUT divbuf_2/OUT2 divbuf_2/OUT3 divbuf_2/OUT4
+ divbuf_2/OUT5 vssa1 divbuf
Xdivbuf_3 vdda1 divbuf_3/IN divbuf_3/OUT divbuf_3/OUT2 divbuf_3/OUT3 divbuf_3/OUT4
+ divbuf_3/OUT5 vssa1 divbuf
Xdivbuf_4 vdda1 divbuf_4/IN divbuf_4/OUT divbuf_4/OUT2 divbuf_4/OUT3 divbuf_4/OUT4
+ divbuf_4/OUT5 vssa1 divbuf
Xdivbuf_5 vdda1 divbuf_5/IN divbuf_5/OUT divbuf_5/OUT2 divbuf_5/OUT3 divbuf_5/OUT4
+ divbuf_5/OUT5 vssa1 divbuf
Xdivbuf_21 vdda1 divbuf_21/IN divbuf_21/OUT divbuf_21/OUT2 divbuf_21/OUT3 divbuf_21/OUT4
+ divbuf_21/OUT5 gnd divbuf
Xdivbuf_20 vdda1 divbuf_20/IN divbuf_20/OUT divbuf_20/OUT2 divbuf_20/OUT3 divbuf_20/OUT4
+ divbuf_20/OUT5 gnd divbuf
Xdivbuf_10 vdda1 divbuf_10/IN divbuf_10/OUT divbuf_10/OUT2 divbuf_10/OUT3 divbuf_10/OUT4
+ divbuf_10/OUT5 gnd divbuf
Xdivbuf_6 vdda1 divbuf_6/IN divbuf_6/OUT divbuf_6/OUT2 divbuf_6/OUT3 divbuf_6/OUT4
+ divbuf_6/OUT5 vssa1 divbuf
Xdivbuf_22 vdda1 divbuf_22/IN divbuf_22/OUT divbuf_22/OUT2 divbuf_22/OUT3 divbuf_22/OUT4
+ divbuf_22/OUT5 gnd divbuf
Xdivbuf_11 vdda1 divbuf_11/IN divbuf_11/OUT divbuf_11/OUT2 divbuf_11/OUT3 divbuf_11/OUT4
+ divbuf_11/OUT5 gnd divbuf
Xdivbuf_7 vdda1 divbuf_7/IN divbuf_7/OUT divbuf_7/OUT2 divbuf_7/OUT3 divbuf_7/OUT4
+ divbuf_7/OUT5 vssa1 divbuf
Xdivbuf_23 vdda1 divbuf_23/IN divbuf_23/OUT divbuf_23/OUT2 divbuf_23/OUT3 divbuf_23/OUT4
+ divbuf_23/OUT5 gnd divbuf
Xdivbuf_8 vdda1 divbuf_8/IN divbuf_8/OUT divbuf_8/OUT2 divbuf_8/OUT3 divbuf_8/OUT4
+ divbuf_8/OUT5 vssa1 divbuf
Xdivbuf_12 vdda1 divbuf_12/IN divbuf_12/OUT divbuf_12/OUT2 divbuf_12/OUT3 divbuf_12/OUT4
+ divbuf_12/OUT5 gnd divbuf
Xdivbuf_24 vdda1 divbuf_24/IN divbuf_24/OUT divbuf_24/OUT2 divbuf_24/OUT3 divbuf_24/OUT4
+ divbuf_24/OUT5 gnd divbuf
Xdivbuf_13 vdda1 divbuf_13/IN divbuf_13/OUT divbuf_13/OUT2 divbuf_13/OUT3 divbuf_13/OUT4
+ divbuf_13/OUT5 gnd divbuf
Xdivbuf_9 vdda1 divbuf_9/IN divbuf_9/OUT divbuf_9/OUT2 divbuf_9/OUT3 divbuf_9/OUT4
+ divbuf_9/OUT5 vssa1 divbuf
Xdivbuf_25 vdda1 divbuf_25/IN divbuf_25/OUT divbuf_25/OUT2 divbuf_25/OUT3 divbuf_25/OUT4
+ divbuf_25/OUT5 gnd divbuf
Xdivbuf_14 vdda1 divbuf_14/IN divbuf_14/OUT divbuf_14/OUT2 divbuf_14/OUT3 divbuf_14/OUT4
+ divbuf_14/OUT5 gnd divbuf
Xdivider_0 gnd vdd divider_0/Out divider_0/clk divider_0/mc2 divider
Xdivbuf_15 vdda1 divbuf_15/IN divbuf_15/OUT divbuf_15/OUT2 divbuf_15/OUT3 divbuf_15/OUT4
+ divbuf_15/OUT5 gnd divbuf
Xdivider_1 vssa1 vdda1 divider_1/Out divider_1/clk divider_1/mc2 divider
Xdivbuf_16 vdda1 divbuf_16/IN divbuf_16/OUT divbuf_16/OUT2 divbuf_16/OUT3 divbuf_16/OUT4
+ divbuf_16/OUT5 gnd divbuf
Xdivider_2 vssa1 vdda1 divider_2/Out divider_2/clk divider_2/mc2 divider
Xdivbuf_17 vdda1 divbuf_17/IN divbuf_17/OUT divbuf_17/OUT2 divbuf_17/OUT3 divbuf_17/OUT4
+ divbuf_17/OUT5 gnd divbuf
Xdivbuf_18 vdda1 divbuf_18/IN divbuf_18/OUT divbuf_18/OUT2 divbuf_18/OUT3 divbuf_18/OUT4
+ divbuf_18/OUT5 gnd divbuf
Xdivbuf_19 vdda1 divbuf_19/IN divbuf_19/OUT divbuf_19/OUT2 divbuf_19/OUT3 divbuf_19/OUT4
+ divbuf_19/OUT5 gnd divbuf
Xpll_full_0 vdda1 pll_full
C1665 io_analog[4] gnd 43.96fF
C1666 io_analog[5] gnd 44.13fF
C1667 io_analog[6] gnd 43.46fF
C1668 io_in_3v3[0] gnd 0.61fF
C1669 io_oeb[26] gnd 0.61fF
C1670 io_in[0] gnd 0.61fF
C1671 io_out[26] gnd 0.61fF
C1672 io_out[0] gnd 0.61fF
C1673 io_in[26] gnd 0.61fF
C1674 io_oeb[0] gnd 0.61fF
C1675 io_in_3v3[26] gnd 0.61fF
C1676 io_in_3v3[1] gnd 0.61fF
C1677 io_oeb[25] gnd 0.61fF
C1678 io_in[1] gnd 0.61fF
C1679 io_out[25] gnd 0.61fF
C1680 io_out[1] gnd 0.61fF
C1681 io_in[25] gnd 0.61fF
C1682 io_oeb[1] gnd 0.61fF
C1683 io_in_3v3[25] gnd 0.61fF
C1684 io_in_3v3[2] gnd 0.61fF
C1685 io_oeb[24] gnd 0.61fF
C1686 io_in[2] gnd 0.61fF
C1687 io_out[24] gnd 0.61fF
C1688 io_out[2] gnd 0.61fF
C1689 io_in[24] gnd 0.61fF
C1690 io_oeb[2] gnd 0.61fF
C1691 io_in_3v3[24] gnd 0.61fF
C1692 io_in_3v3[3] gnd 0.61fF
C1693 io_in[3] gnd 0.61fF
C1694 gpio_noesd[17] gnd 2.32fF
C1695 gpio_analog[17] gnd 2.30fF
C1696 io_out[3] gnd 0.61fF
C1697 io_oeb[3] gnd 0.61fF
C1698 io_in_3v3[4] gnd 0.61fF
C1699 io_in[4] gnd 0.61fF
C1700 io_out[4] gnd 0.61fF
C1701 io_oeb[4] gnd 0.61fF
C1702 io_oeb[23] gnd 0.61fF
C1703 io_out[23] gnd 0.61fF
C1704 io_in[23] gnd 0.61fF
C1705 io_in_3v3[23] gnd 0.61fF
C1706 gpio_noesd[16] gnd 2.30fF
C1707 gpio_analog[16] gnd 2.30fF
C1708 io_in_3v3[5] gnd 0.61fF
C1709 io_in[5] gnd 0.61fF
C1710 io_out[5] gnd 0.61fF
C1711 io_oeb[5] gnd 0.61fF
C1712 io_oeb[22] gnd 0.61fF
C1713 io_out[22] gnd 0.61fF
C1714 io_in[22] gnd 0.61fF
C1715 io_in_3v3[22] gnd 0.61fF
C1716 gpio_noesd[15] gnd 2.31fF
C1717 gpio_analog[15] gnd 2.30fF
C1718 io_in_3v3[6] gnd 0.61fF
C1719 io_in[6] gnd 0.61fF
C1720 io_out[6] gnd 0.61fF
C1721 io_oeb[6] gnd 0.61fF
C1722 io_oeb[21] gnd 0.61fF
C1723 io_out[21] gnd 0.61fF
C1724 io_in[21] gnd 0.61fF
C1725 io_in_3v3[21] gnd 0.61fF
C1726 gpio_noesd[14] gnd 2.30fF
C1727 gpio_analog[14] gnd 2.29fF
C1728 vssd2 gnd 38.54fF
C1729 vssd1 gnd 13.04fF
C1730 vdda2 gnd 38.30fF
C1731 io_oeb[20] gnd 0.61fF
C1732 io_out[20] gnd 0.61fF
C1733 io_in[20] gnd 0.61fF
C1734 io_in_3v3[20] gnd 0.61fF
C1735 gpio_noesd[13] gnd 2.31fF
C1736 gpio_analog[13] gnd 2.30fF
C1737 gpio_analog[0] gnd 0.61fF
C1738 gpio_noesd[0] gnd 0.61fF
C1739 io_in_3v3[7] gnd 0.61fF
C1740 io_in[7] gnd 0.61fF
C1741 io_out[7] gnd 0.61fF
C1742 io_oeb[7] gnd 0.61fF
C1743 io_oeb[19] gnd 0.61fF
C1744 io_out[19] gnd 0.61fF
C1745 io_in[19] gnd 0.61fF
C1746 io_in_3v3[19] gnd 0.61fF
C1747 gpio_noesd[12] gnd 2.32fF
C1748 gpio_analog[12] gnd 2.30fF
C1749 gpio_analog[1] gnd 0.61fF
C1750 gpio_noesd[1] gnd 0.61fF
C1751 io_in_3v3[8] gnd 0.61fF
C1752 io_in[8] gnd 0.61fF
C1753 io_out[8] gnd 0.61fF
C1754 io_oeb[8] gnd 0.61fF
C1755 io_oeb[18] gnd 0.61fF
C1756 io_out[18] gnd 0.61fF
C1757 io_in[18] gnd 0.61fF
C1758 io_in_3v3[18] gnd 0.61fF
C1759 gpio_noesd[11] gnd 2.30fF
C1760 gpio_analog[11] gnd 2.29fF
C1761 gpio_analog[2] gnd 0.61fF
C1762 gpio_noesd[2] gnd 0.61fF
C1763 io_in_3v3[9] gnd 0.61fF
C1764 io_in[9] gnd 0.61fF
C1765 io_out[9] gnd 0.61fF
C1766 io_oeb[9] gnd 0.61fF
C1767 io_oeb[17] gnd 0.61fF
C1768 io_out[17] gnd 0.61fF
C1769 io_in[17] gnd 0.61fF
C1770 io_in_3v3[17] gnd 0.61fF
C1771 gpio_noesd[10] gnd 2.31fF
C1772 gpio_analog[10] gnd 2.29fF
C1773 gpio_analog[3] gnd 0.61fF
C1774 gpio_noesd[3] gnd 0.61fF
C1775 io_in_3v3[10] gnd 0.61fF
C1776 io_in[10] gnd 0.61fF
C1777 io_out[10] gnd 0.61fF
C1778 io_oeb[10] gnd 0.61fF
C1779 io_oeb[16] gnd 0.61fF
C1780 io_out[16] gnd 0.61fF
C1781 io_in[16] gnd 0.61fF
C1782 io_in_3v3[16] gnd 0.61fF
C1783 gpio_noesd[9] gnd 2.28fF
C1784 gpio_analog[9] gnd 2.28fF
C1785 gpio_analog[4] gnd 0.61fF
C1786 gpio_noesd[4] gnd 0.61fF
C1787 io_in_3v3[11] gnd 0.61fF
C1788 io_in[11] gnd 0.61fF
C1789 io_out[11] gnd 0.61fF
C1790 io_oeb[11] gnd 0.61fF
C1791 io_oeb[15] gnd 0.61fF
C1792 io_out[15] gnd 0.61fF
C1793 io_in[15] gnd 0.61fF
C1794 io_in_3v3[15] gnd 0.61fF
C1795 gpio_noesd[8] gnd 2.28fF
C1796 gpio_analog[8] gnd 2.26fF
C1797 gpio_analog[5] gnd 0.61fF
C1798 gpio_noesd[5] gnd 0.61fF
C1799 io_in_3v3[12] gnd 0.61fF
C1800 io_in[12] gnd 0.61fF
C1801 io_out[12] gnd 0.61fF
C1802 io_oeb[12] gnd 0.61fF
C1803 io_oeb[14] gnd 0.61fF
C1804 io_out[14] gnd 0.61fF
C1805 io_in[14] gnd 0.61fF
C1806 io_in_3v3[14] gnd 0.61fF
C1807 gpio_noesd[7] gnd 2.30fF
C1808 gpio_analog[7] gnd 2.28fF
C1809 vssa2 gnd 38.35fF
C1810 gpio_analog[6] gnd 5.71fF
C1811 gpio_noesd[6] gnd 5.70fF
C1812 io_in_3v3[13] gnd 0.61fF
C1813 io_in[13] gnd 0.61fF
C1814 io_out[13] gnd 0.61fF
C1815 io_oeb[13] gnd 0.61fF
C1816 vccd1 gnd 39.84fF
C1817 vccd2 gnd 38.46fF
C1818 io_analog[0] gnd 19.99fF
C1819 io_analog[10] gnd 19.36fF
C1820 io_analog[1] gnd 13.17fF
C1821 io_analog[2] gnd 12.57fF
C1822 io_analog[3] gnd 12.83fF
C1823 io_clamp_high[0] gnd 3.58fF
C1824 io_clamp_low[0] gnd 3.58fF
C1825 io_clamp_high[1] gnd 3.58fF
C1826 io_clamp_low[1] gnd 3.58fF
C1827 io_clamp_high[2] gnd 3.58fF
C1828 io_clamp_low[2] gnd 3.58fF
C1829 io_analog[7] gnd 12.74fF
C1830 io_analog[8] gnd 13.08fF
C1831 io_analog[9] gnd 13.08fF
C1832 user_irq[2] gnd 0.63fF
C1833 user_irq[1] gnd 0.63fF
C1834 user_irq[0] gnd 0.63fF
C1835 user_clock2 gnd 0.63fF
C1836 la_oenb[127] gnd 0.63fF
C1837 la_data_out[127] gnd 0.63fF
C1838 la_data_in[127] gnd 0.63fF
C1839 la_oenb[126] gnd 0.63fF
C1840 la_data_out[126] gnd 0.63fF
C1841 la_data_in[126] gnd 0.63fF
C1842 la_oenb[125] gnd 0.63fF
C1843 la_data_out[125] gnd 0.63fF
C1844 la_data_in[125] gnd 0.63fF
C1845 la_oenb[124] gnd 0.63fF
C1846 la_data_out[124] gnd 0.63fF
C1847 la_data_in[124] gnd 0.63fF
C1848 la_oenb[123] gnd 0.63fF
C1849 la_data_out[123] gnd 0.63fF
C1850 la_data_in[123] gnd 0.63fF
C1851 la_oenb[122] gnd 0.63fF
C1852 la_data_out[122] gnd 0.63fF
C1853 la_data_in[122] gnd 0.63fF
C1854 la_oenb[121] gnd 0.63fF
C1855 la_data_out[121] gnd 0.63fF
C1856 la_data_in[121] gnd 0.63fF
C1857 la_oenb[120] gnd 0.63fF
C1858 la_data_out[120] gnd 0.63fF
C1859 la_data_in[120] gnd 0.63fF
C1860 la_oenb[119] gnd 0.63fF
C1861 la_data_out[119] gnd 0.63fF
C1862 la_data_in[119] gnd 0.63fF
C1863 la_oenb[118] gnd 0.63fF
C1864 la_data_out[118] gnd 0.63fF
C1865 la_data_in[118] gnd 0.63fF
C1866 la_oenb[117] gnd 0.63fF
C1867 la_data_out[117] gnd 0.63fF
C1868 la_data_in[117] gnd 0.63fF
C1869 la_oenb[116] gnd 0.63fF
C1870 la_data_out[116] gnd 0.63fF
C1871 la_data_in[116] gnd 0.63fF
C1872 la_oenb[115] gnd 0.63fF
C1873 la_data_out[115] gnd 0.63fF
C1874 la_data_in[115] gnd 0.63fF
C1875 la_oenb[114] gnd 0.63fF
C1876 la_data_out[114] gnd 0.63fF
C1877 la_data_in[114] gnd 0.63fF
C1878 la_oenb[113] gnd 0.63fF
C1879 la_data_out[113] gnd 0.63fF
C1880 la_data_in[113] gnd 0.63fF
C1881 la_oenb[112] gnd 0.63fF
C1882 la_data_out[112] gnd 0.63fF
C1883 la_data_in[112] gnd 0.63fF
C1884 la_oenb[111] gnd 0.63fF
C1885 la_data_out[111] gnd 0.63fF
C1886 la_data_in[111] gnd 0.63fF
C1887 la_oenb[110] gnd 0.63fF
C1888 la_data_out[110] gnd 0.63fF
C1889 la_data_in[110] gnd 0.63fF
C1890 la_oenb[109] gnd 0.63fF
C1891 la_data_out[109] gnd 0.63fF
C1892 la_data_in[109] gnd 0.63fF
C1893 la_oenb[108] gnd 0.63fF
C1894 la_data_out[108] gnd 0.63fF
C1895 la_data_in[108] gnd 0.63fF
C1896 la_oenb[107] gnd 0.63fF
C1897 la_data_out[107] gnd 0.63fF
C1898 la_data_in[107] gnd 0.63fF
C1899 la_oenb[106] gnd 0.63fF
C1900 la_data_out[106] gnd 0.63fF
C1901 la_data_in[106] gnd 0.63fF
C1902 la_oenb[105] gnd 0.63fF
C1903 la_data_out[105] gnd 0.63fF
C1904 la_data_in[105] gnd 0.63fF
C1905 la_oenb[104] gnd 0.63fF
C1906 la_data_out[104] gnd 0.63fF
C1907 la_data_in[104] gnd 0.63fF
C1908 la_oenb[103] gnd 0.63fF
C1909 la_data_out[103] gnd 0.63fF
C1910 la_data_in[103] gnd 0.63fF
C1911 la_oenb[102] gnd 0.63fF
C1912 la_data_out[102] gnd 0.63fF
C1913 la_data_in[102] gnd 0.63fF
C1914 la_oenb[101] gnd 0.63fF
C1915 la_data_out[101] gnd 0.63fF
C1916 la_data_in[101] gnd 0.63fF
C1917 la_oenb[100] gnd 0.63fF
C1918 la_data_out[100] gnd 0.63fF
C1919 la_data_in[100] gnd 0.63fF
C1920 la_oenb[99] gnd 0.63fF
C1921 la_data_out[99] gnd 0.63fF
C1922 la_data_in[99] gnd 0.63fF
C1923 la_oenb[98] gnd 0.63fF
C1924 la_data_out[98] gnd 0.63fF
C1925 la_data_in[98] gnd 0.63fF
C1926 la_oenb[97] gnd 0.63fF
C1927 la_data_out[97] gnd 0.63fF
C1928 la_data_in[97] gnd 0.63fF
C1929 la_oenb[96] gnd 0.63fF
C1930 la_data_out[96] gnd 0.63fF
C1931 la_data_in[96] gnd 0.63fF
C1932 la_oenb[95] gnd 0.63fF
C1933 la_data_out[95] gnd 0.63fF
C1934 la_data_in[95] gnd 0.63fF
C1935 la_oenb[94] gnd 0.63fF
C1936 la_data_out[94] gnd 0.63fF
C1937 la_data_in[94] gnd 0.63fF
C1938 la_oenb[93] gnd 0.63fF
C1939 la_data_out[93] gnd 0.63fF
C1940 la_data_in[93] gnd 0.63fF
C1941 la_oenb[92] gnd 0.63fF
C1942 la_data_out[92] gnd 0.63fF
C1943 la_data_in[92] gnd 0.63fF
C1944 la_oenb[91] gnd 0.63fF
C1945 la_data_out[91] gnd 0.63fF
C1946 la_data_in[91] gnd 0.63fF
C1947 la_oenb[90] gnd 0.63fF
C1948 la_data_out[90] gnd 0.63fF
C1949 la_data_in[90] gnd 0.63fF
C1950 la_oenb[89] gnd 0.63fF
C1951 la_data_out[89] gnd 0.63fF
C1952 la_data_in[89] gnd 0.63fF
C1953 la_oenb[88] gnd 0.63fF
C1954 la_data_out[88] gnd 0.63fF
C1955 la_data_in[88] gnd 0.63fF
C1956 la_oenb[87] gnd 0.63fF
C1957 la_data_out[87] gnd 0.63fF
C1958 la_data_in[87] gnd 0.63fF
C1959 la_oenb[86] gnd 0.63fF
C1960 la_data_out[86] gnd 0.63fF
C1961 la_data_in[86] gnd 0.63fF
C1962 la_oenb[85] gnd 0.63fF
C1963 la_data_out[85] gnd 0.63fF
C1964 la_data_in[85] gnd 0.63fF
C1965 la_oenb[84] gnd 0.63fF
C1966 la_data_out[84] gnd 0.63fF
C1967 la_data_in[84] gnd 0.63fF
C1968 la_oenb[83] gnd 0.63fF
C1969 la_data_out[83] gnd 0.63fF
C1970 la_data_in[83] gnd 0.63fF
C1971 la_oenb[82] gnd 0.63fF
C1972 la_data_out[82] gnd 0.63fF
C1973 la_data_in[82] gnd 0.63fF
C1974 la_oenb[81] gnd 0.63fF
C1975 la_data_out[81] gnd 0.63fF
C1976 la_data_in[81] gnd 0.63fF
C1977 la_oenb[80] gnd 0.63fF
C1978 la_data_out[80] gnd 0.63fF
C1979 la_data_in[80] gnd 0.63fF
C1980 la_oenb[79] gnd 0.63fF
C1981 la_data_out[79] gnd 0.63fF
C1982 la_data_in[79] gnd 0.63fF
C1983 la_oenb[78] gnd 0.63fF
C1984 la_data_out[78] gnd 0.63fF
C1985 la_data_in[78] gnd 0.63fF
C1986 la_oenb[77] gnd 0.63fF
C1987 la_data_out[77] gnd 0.63fF
C1988 la_data_in[77] gnd 0.63fF
C1989 la_oenb[76] gnd 0.63fF
C1990 la_data_out[76] gnd 0.63fF
C1991 la_data_in[76] gnd 0.63fF
C1992 la_oenb[75] gnd 0.63fF
C1993 la_data_out[75] gnd 0.63fF
C1994 la_data_in[75] gnd 0.63fF
C1995 la_oenb[74] gnd 0.63fF
C1996 la_data_out[74] gnd 0.63fF
C1997 la_data_in[74] gnd 0.63fF
C1998 la_oenb[73] gnd 0.63fF
C1999 la_data_out[73] gnd 0.63fF
C2000 la_data_in[73] gnd 0.63fF
C2001 la_oenb[72] gnd 0.63fF
C2002 la_data_out[72] gnd 0.63fF
C2003 la_data_in[72] gnd 0.63fF
C2004 la_oenb[71] gnd 0.63fF
C2005 la_data_out[71] gnd 0.63fF
C2006 la_data_in[71] gnd 0.63fF
C2007 la_oenb[70] gnd 0.63fF
C2008 la_data_out[70] gnd 0.63fF
C2009 la_data_in[70] gnd 0.63fF
C2010 la_oenb[69] gnd 0.63fF
C2011 la_data_out[69] gnd 0.63fF
C2012 la_data_in[69] gnd 0.63fF
C2013 la_oenb[68] gnd 0.63fF
C2014 la_data_out[68] gnd 0.63fF
C2015 la_data_in[68] gnd 0.63fF
C2016 la_oenb[67] gnd 0.63fF
C2017 la_data_out[67] gnd 0.63fF
C2018 la_data_in[67] gnd 0.63fF
C2019 la_oenb[66] gnd 0.63fF
C2020 la_data_out[66] gnd 0.63fF
C2021 la_data_in[66] gnd 0.63fF
C2022 la_oenb[65] gnd 0.63fF
C2023 la_data_out[65] gnd 0.63fF
C2024 la_data_in[65] gnd 0.63fF
C2025 la_oenb[64] gnd 0.63fF
C2026 la_data_out[64] gnd 0.63fF
C2027 la_data_in[64] gnd 0.63fF
C2028 la_oenb[63] gnd 0.63fF
C2029 la_data_out[63] gnd 0.63fF
C2030 la_data_in[63] gnd 0.63fF
C2031 la_oenb[62] gnd 0.63fF
C2032 la_data_out[62] gnd 0.63fF
C2033 la_data_in[62] gnd 0.63fF
C2034 la_oenb[61] gnd 0.63fF
C2035 la_data_out[61] gnd 0.63fF
C2036 la_data_in[61] gnd 0.63fF
C2037 la_oenb[60] gnd 0.63fF
C2038 la_data_out[60] gnd 0.63fF
C2039 la_data_in[60] gnd 0.63fF
C2040 la_oenb[59] gnd 0.63fF
C2041 la_data_out[59] gnd 0.63fF
C2042 la_data_in[59] gnd 0.63fF
C2043 la_oenb[58] gnd 0.63fF
C2044 la_data_out[58] gnd 0.63fF
C2045 la_data_in[58] gnd 0.63fF
C2046 la_oenb[57] gnd 0.63fF
C2047 la_data_out[57] gnd 0.63fF
C2048 la_data_in[57] gnd 0.63fF
C2049 la_oenb[56] gnd 0.63fF
C2050 la_data_out[56] gnd 0.63fF
C2051 la_data_in[56] gnd 0.63fF
C2052 la_oenb[55] gnd 0.63fF
C2053 la_data_out[55] gnd 0.63fF
C2054 la_data_in[55] gnd 0.63fF
C2055 la_oenb[54] gnd 0.63fF
C2056 la_data_out[54] gnd 0.63fF
C2057 la_data_in[54] gnd 0.63fF
C2058 la_oenb[53] gnd 0.63fF
C2059 la_data_out[53] gnd 0.63fF
C2060 la_data_in[53] gnd 0.63fF
C2061 la_oenb[52] gnd 0.63fF
C2062 la_data_out[52] gnd 0.63fF
C2063 la_data_in[52] gnd 0.63fF
C2064 la_oenb[51] gnd 0.63fF
C2065 la_data_out[51] gnd 0.63fF
C2066 la_data_in[51] gnd 0.63fF
C2067 la_oenb[50] gnd 0.63fF
C2068 la_data_out[50] gnd 0.63fF
C2069 la_data_in[50] gnd 0.63fF
C2070 la_oenb[49] gnd 0.63fF
C2071 la_data_out[49] gnd 0.63fF
C2072 la_data_in[49] gnd 0.63fF
C2073 la_oenb[48] gnd 0.63fF
C2074 la_data_out[48] gnd 0.63fF
C2075 la_data_in[48] gnd 0.63fF
C2076 la_oenb[47] gnd 0.63fF
C2077 la_data_out[47] gnd 0.63fF
C2078 la_data_in[47] gnd 0.63fF
C2079 la_oenb[46] gnd 0.63fF
C2080 la_data_out[46] gnd 0.63fF
C2081 la_data_in[46] gnd 0.63fF
C2082 la_oenb[45] gnd 0.63fF
C2083 la_data_out[45] gnd 0.63fF
C2084 la_data_in[45] gnd 0.63fF
C2085 la_oenb[44] gnd 0.63fF
C2086 la_data_out[44] gnd 0.63fF
C2087 la_data_in[44] gnd 0.63fF
C2088 la_oenb[43] gnd 0.63fF
C2089 la_data_out[43] gnd 0.63fF
C2090 la_data_in[43] gnd 0.63fF
C2091 la_oenb[42] gnd 0.63fF
C2092 la_data_out[42] gnd 0.63fF
C2093 la_data_in[42] gnd 0.63fF
C2094 la_oenb[41] gnd 0.63fF
C2095 la_data_out[41] gnd 0.63fF
C2096 la_data_in[41] gnd 0.63fF
C2097 la_oenb[40] gnd 0.63fF
C2098 la_data_out[40] gnd 0.63fF
C2099 la_data_in[40] gnd 0.63fF
C2100 la_oenb[39] gnd 0.63fF
C2101 la_data_out[39] gnd 0.63fF
C2102 la_data_in[39] gnd 0.63fF
C2103 la_oenb[38] gnd 0.63fF
C2104 la_data_out[38] gnd 0.63fF
C2105 la_data_in[38] gnd 0.63fF
C2106 la_oenb[37] gnd 0.63fF
C2107 la_data_out[37] gnd 0.63fF
C2108 la_data_in[37] gnd 0.63fF
C2109 la_oenb[36] gnd 0.63fF
C2110 la_data_out[36] gnd 0.63fF
C2111 la_data_in[36] gnd 0.63fF
C2112 la_oenb[35] gnd 0.63fF
C2113 la_data_out[35] gnd 0.63fF
C2114 la_data_in[35] gnd 0.63fF
C2115 la_oenb[34] gnd 0.63fF
C2116 la_data_out[34] gnd 0.63fF
C2117 la_data_in[34] gnd 0.63fF
C2118 la_oenb[33] gnd 0.63fF
C2119 la_data_out[33] gnd 0.63fF
C2120 la_data_in[33] gnd 0.63fF
C2121 la_oenb[32] gnd 0.63fF
C2122 la_data_out[32] gnd 0.63fF
C2123 la_data_in[32] gnd 0.63fF
C2124 la_oenb[31] gnd 0.63fF
C2125 la_data_out[31] gnd 0.63fF
C2126 la_data_in[31] gnd 0.63fF
C2127 la_oenb[30] gnd 0.63fF
C2128 la_data_out[30] gnd 0.63fF
C2129 la_data_in[30] gnd 0.63fF
C2130 la_oenb[29] gnd 0.63fF
C2131 la_data_out[29] gnd 0.63fF
C2132 la_data_in[29] gnd 0.63fF
C2133 la_oenb[28] gnd 0.63fF
C2134 la_data_out[28] gnd 0.63fF
C2135 la_data_in[28] gnd 0.63fF
C2136 la_oenb[27] gnd 0.63fF
C2137 la_data_out[27] gnd 0.63fF
C2138 la_data_in[27] gnd 0.63fF
C2139 la_oenb[26] gnd 0.63fF
C2140 la_data_out[26] gnd 0.63fF
C2141 la_data_in[26] gnd 0.63fF
C2142 la_oenb[25] gnd 0.63fF
C2143 la_data_out[25] gnd 0.63fF
C2144 la_data_in[25] gnd 0.63fF
C2145 la_oenb[24] gnd 0.63fF
C2146 la_data_out[24] gnd 0.63fF
C2147 la_data_in[24] gnd 0.63fF
C2148 la_oenb[23] gnd 0.63fF
C2149 la_data_out[23] gnd 0.63fF
C2150 la_data_in[23] gnd 0.63fF
C2151 la_oenb[22] gnd 0.63fF
C2152 la_data_out[22] gnd 0.63fF
C2153 la_data_in[22] gnd 0.63fF
C2154 la_oenb[21] gnd 0.63fF
C2155 la_data_out[21] gnd 0.63fF
C2156 la_data_in[21] gnd 0.63fF
C2157 la_oenb[20] gnd 0.63fF
C2158 la_data_out[20] gnd 0.63fF
C2159 la_data_in[20] gnd 0.63fF
C2160 la_oenb[19] gnd 0.63fF
C2161 la_data_out[19] gnd 0.63fF
C2162 la_data_in[19] gnd 0.63fF
C2163 la_oenb[18] gnd 0.63fF
C2164 la_data_out[18] gnd 0.63fF
C2165 la_data_in[18] gnd 0.63fF
C2166 la_oenb[17] gnd 0.63fF
C2167 la_data_out[17] gnd 0.63fF
C2168 la_data_in[17] gnd 0.63fF
C2169 la_oenb[16] gnd 0.63fF
C2170 la_data_out[16] gnd 0.63fF
C2171 la_data_in[16] gnd 0.63fF
C2172 la_oenb[15] gnd 0.63fF
C2173 la_data_out[15] gnd 0.63fF
C2174 la_data_in[15] gnd 0.63fF
C2175 la_oenb[14] gnd 0.63fF
C2176 la_data_out[14] gnd 0.63fF
C2177 la_data_in[14] gnd 0.63fF
C2178 la_oenb[13] gnd 0.63fF
C2179 la_data_out[13] gnd 0.63fF
C2180 la_data_in[13] gnd 0.63fF
C2181 la_oenb[12] gnd 0.63fF
C2182 la_data_out[12] gnd 0.63fF
C2183 la_data_in[12] gnd 0.63fF
C2184 la_oenb[11] gnd 0.63fF
C2185 la_data_out[11] gnd 0.63fF
C2186 la_data_in[11] gnd 0.63fF
C2187 la_oenb[10] gnd 0.63fF
C2188 la_data_out[10] gnd 0.63fF
C2189 la_data_in[10] gnd 0.63fF
C2190 la_oenb[9] gnd 0.63fF
C2191 la_data_out[9] gnd 0.63fF
C2192 la_data_in[9] gnd 0.63fF
C2193 la_oenb[8] gnd 0.63fF
C2194 la_data_out[8] gnd 0.63fF
C2195 la_data_in[8] gnd 0.63fF
C2196 la_oenb[7] gnd 0.63fF
C2197 la_data_out[7] gnd 0.63fF
C2198 la_data_in[7] gnd 0.63fF
C2199 la_oenb[6] gnd 0.63fF
C2200 la_data_out[6] gnd 0.63fF
C2201 la_data_in[6] gnd 0.63fF
C2202 la_oenb[5] gnd 0.63fF
C2203 la_data_out[5] gnd 0.63fF
C2204 la_data_in[5] gnd 0.63fF
C2205 la_oenb[4] gnd 0.63fF
C2206 la_data_out[4] gnd 0.63fF
C2207 la_data_in[4] gnd 0.63fF
C2208 la_oenb[3] gnd 0.63fF
C2209 la_data_out[3] gnd 0.63fF
C2210 la_data_in[3] gnd 0.63fF
C2211 la_oenb[2] gnd 0.63fF
C2212 la_data_out[2] gnd 0.63fF
C2213 la_data_in[2] gnd 0.63fF
C2214 la_oenb[1] gnd 0.63fF
C2215 la_data_out[1] gnd 0.63fF
C2216 la_data_in[1] gnd 0.63fF
C2217 la_oenb[0] gnd 0.63fF
C2218 la_data_out[0] gnd 0.63fF
C2219 la_data_in[0] gnd 0.63fF
C2220 wbs_dat_o[31] gnd 0.63fF
C2221 wbs_dat_i[31] gnd 0.63fF
C2222 wbs_adr_i[31] gnd 0.63fF
C2223 wbs_dat_o[30] gnd 0.63fF
C2224 wbs_dat_i[30] gnd 0.63fF
C2225 wbs_adr_i[30] gnd 0.63fF
C2226 wbs_dat_o[29] gnd 0.63fF
C2227 wbs_dat_i[29] gnd 0.63fF
C2228 wbs_adr_i[29] gnd 0.63fF
C2229 wbs_dat_o[28] gnd 0.63fF
C2230 wbs_dat_i[28] gnd 0.63fF
C2231 wbs_adr_i[28] gnd 0.63fF
C2232 wbs_dat_o[27] gnd 0.63fF
C2233 wbs_dat_i[27] gnd 0.63fF
C2234 wbs_adr_i[27] gnd 0.63fF
C2235 wbs_dat_o[26] gnd 0.63fF
C2236 wbs_dat_i[26] gnd 0.63fF
C2237 wbs_adr_i[26] gnd 0.63fF
C2238 wbs_dat_o[25] gnd 0.63fF
C2239 wbs_dat_i[25] gnd 0.63fF
C2240 wbs_adr_i[25] gnd 0.63fF
C2241 wbs_dat_o[24] gnd 0.63fF
C2242 wbs_dat_i[24] gnd 0.63fF
C2243 wbs_adr_i[24] gnd 0.63fF
C2244 wbs_dat_o[23] gnd 0.63fF
C2245 wbs_dat_i[23] gnd 0.63fF
C2246 wbs_adr_i[23] gnd 0.63fF
C2247 wbs_dat_o[22] gnd 0.63fF
C2248 wbs_dat_i[22] gnd 0.63fF
C2249 wbs_adr_i[22] gnd 0.63fF
C2250 wbs_dat_o[21] gnd 0.63fF
C2251 wbs_dat_i[21] gnd 0.63fF
C2252 wbs_adr_i[21] gnd 0.63fF
C2253 wbs_dat_o[20] gnd 0.63fF
C2254 wbs_dat_i[20] gnd 0.63fF
C2255 wbs_adr_i[20] gnd 0.63fF
C2256 wbs_dat_o[19] gnd 0.63fF
C2257 wbs_dat_i[19] gnd 0.63fF
C2258 wbs_adr_i[19] gnd 0.63fF
C2259 wbs_dat_o[18] gnd 0.63fF
C2260 wbs_dat_i[18] gnd 0.63fF
C2261 wbs_adr_i[18] gnd 0.63fF
C2262 wbs_dat_o[17] gnd 0.63fF
C2263 wbs_dat_i[17] gnd 0.63fF
C2264 wbs_adr_i[17] gnd 0.63fF
C2265 wbs_dat_o[16] gnd 0.63fF
C2266 wbs_dat_i[16] gnd 0.63fF
C2267 wbs_adr_i[16] gnd 0.63fF
C2268 wbs_dat_o[15] gnd 0.63fF
C2269 wbs_dat_i[15] gnd 0.63fF
C2270 wbs_adr_i[15] gnd 0.63fF
C2271 wbs_dat_o[14] gnd 0.63fF
C2272 wbs_dat_i[14] gnd 0.63fF
C2273 wbs_adr_i[14] gnd 0.63fF
C2274 wbs_dat_o[13] gnd 0.63fF
C2275 wbs_dat_i[13] gnd 0.63fF
C2276 wbs_adr_i[13] gnd 0.63fF
C2277 wbs_dat_o[12] gnd 0.63fF
C2278 wbs_dat_i[12] gnd 0.63fF
C2279 wbs_adr_i[12] gnd 0.63fF
C2280 wbs_dat_o[11] gnd 0.63fF
C2281 wbs_dat_i[11] gnd 0.63fF
C2282 wbs_adr_i[11] gnd 0.63fF
C2283 wbs_dat_o[10] gnd 0.63fF
C2284 wbs_dat_i[10] gnd 0.63fF
C2285 wbs_adr_i[10] gnd 0.63fF
C2286 wbs_dat_o[9] gnd 0.63fF
C2287 wbs_dat_i[9] gnd 0.63fF
C2288 wbs_adr_i[9] gnd 0.63fF
C2289 wbs_dat_o[8] gnd 0.63fF
C2290 wbs_dat_i[8] gnd 0.63fF
C2291 wbs_adr_i[8] gnd 0.63fF
C2292 wbs_dat_o[7] gnd 0.63fF
C2293 wbs_dat_i[7] gnd 0.63fF
C2294 wbs_adr_i[7] gnd 0.63fF
C2295 wbs_dat_o[6] gnd 0.63fF
C2296 wbs_dat_i[6] gnd 0.63fF
C2297 wbs_adr_i[6] gnd 0.63fF
C2298 wbs_dat_o[5] gnd 0.63fF
C2299 wbs_dat_i[5] gnd 0.63fF
C2300 wbs_adr_i[5] gnd 0.63fF
C2301 wbs_dat_o[4] gnd 0.63fF
C2302 wbs_dat_i[4] gnd 0.63fF
C2303 wbs_adr_i[4] gnd 0.63fF
C2304 wbs_sel_i[3] gnd 0.63fF
C2305 wbs_dat_o[3] gnd 0.63fF
C2306 wbs_dat_i[3] gnd 0.63fF
C2307 wbs_adr_i[3] gnd 0.63fF
C2308 wbs_sel_i[2] gnd 0.63fF
C2309 wbs_dat_o[2] gnd 0.63fF
C2310 wbs_dat_i[2] gnd 0.63fF
C2311 wbs_adr_i[2] gnd 0.63fF
C2312 wbs_sel_i[1] gnd 0.63fF
C2313 wbs_dat_o[1] gnd 0.63fF
C2314 wbs_dat_i[1] gnd 0.63fF
C2315 wbs_adr_i[1] gnd 0.63fF
C2316 wbs_sel_i[0] gnd 0.63fF
C2317 wbs_dat_o[0] gnd 0.63fF
C2318 wbs_dat_i[0] gnd 0.63fF
C2319 wbs_adr_i[0] gnd 0.63fF
C2320 wbs_we_i gnd 0.63fF
C2321 wbs_stb_i gnd 0.63fF
C2322 wbs_cyc_i gnd 0.63fF
C2323 wbs_ack_o gnd 0.63fF
C2324 wb_rst_i gnd 0.63fF
C2325 wb_clk_i gnd 0.63fF
C2326 m2_494098_659718# gnd 0.80fF **FLOATING
C2327 pll_full_0/divider_0/and_0/Z1 gnd 0.65fF
C2328 pll_full_0/divider_0/and_0/B gnd 2.45fF
C2329 pll_full_0/divider_0/and_0/A gnd 2.35fF
C2330 pll_full_0/divider_0/and_0/out1 gnd 2.99fF
C2331 pll_full_0/divider_0/tspc_2/Z4 gnd 0.86fF
C2332 pll_full_0/divider_0/tspc_2/Z3 gnd 2.26fF
C2333 pll_full_0/divider_0/tspc_2/Z2 gnd 1.46fF
C2334 pll_full_0/divider_0/tspc_2/Z1 gnd 0.99fF
C2335 pll_full_0/divider_0/nor_0/A gnd 7.08fF
C2336 pll_full_0/divider_0/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2337 pll_full_0/divider_0/tspc_1/Z4 gnd 0.86fF
C2338 pll_full_0/divider_0/tspc_1/Z3 gnd 2.26fF
C2339 pll_full_0/divider_0/tspc_1/Z2 gnd 1.46fF
C2340 pll_full_0/divider_0/tspc_1/Z1 gnd 0.99fF
C2341 pll_full_0/divider_0/nor_0/B gnd 7.12fF
C2342 pll_full_0/divider_0/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2343 pll_full_0/divider_0/tspc_2/Q gnd 3.14fF
C2344 pll_full_0/divider_0/tspc_0/Z4 gnd 0.86fF
C2345 pll_full_0/divbuf_0/IN gnd 9.89fF
C2346 pll_full_0/divider_0/tspc_0/Z3 gnd 2.26fF
C2347 pll_full_0/divider_0/tspc_0/Z2 gnd 1.46fF
C2348 pll_full_0/divider_0/tspc_0/Z1 gnd 0.99fF
C2349 pll_full_0/divider_0/nor_1/B gnd 6.48fF
C2350 pll_full_0/divider_0/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2351 pll_full_0/divider_0/tspc_1/Q gnd 3.12fF
C2352 pll_full_0/divider_0/clk gnd 33.42fF
C2353 pll_full_0/divider_0/prescaler_0/nand_1/z1 gnd 0.36fF
C2354 pll_full_0/divider_0/prescaler_0/tspc_0/D gnd 2.64fF
C2355 pll_full_0/divider_0/prescaler_0/tspc_2/Q gnd 3.72fF
C2356 pll_full_0/divider_0/prescaler_0/tspc_1/Q gnd 3.61fF
C2357 pll_full_0/divider_0/prescaler_0/nand_0/z1 gnd 0.36fF
C2358 pll_full_0/divider_0/prescaler_0/tspc_2/D gnd 3.12fF
C2359 pll_full_0/divider_0/and_0/OUT gnd 5.67fF
C2360 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2361 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2362 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 gnd 1.19fF
C2363 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2364 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# gnd 1.47fF **FLOATING
C2365 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2366 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2367 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2368 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2369 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2370 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2371 pll_full_0/divider_0/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2372 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2373 pll_full_0/divider_0/prescaler_0/Out gnd 4.59fF
C2374 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2375 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2376 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2377 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2378 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2379 pll_full_0/divider_0/nor_1/Z1 gnd 1.34fF
C2380 pll_full_0/divider_0/nor_0/Z1 gnd 1.34fF
C2381 pll_full_0/divbuf_1/OUT gnd 363.82fF
C2382 pll_full_0/divbuf_1/OUT5 gnd 350.37fF
C2383 pll_full_0/divbuf_1/OUT4 gnd 133.72fF
C2384 pll_full_0/divbuf_1/OUT3 gnd 34.03fF
C2385 pll_full_0/divbuf_1/OUT2 gnd 8.71fF
C2386 pll_full_0/divbuf_1/a_492_n240# gnd 2.46fF **FLOATING
C2387 pll_full_0/divbuf_0/OUT5 gnd 350.37fF
C2388 pll_full_0/divbuf_0/OUT4 gnd 133.72fF
C2389 pll_full_0/divbuf_0/OUT3 gnd 34.03fF
C2390 pll_full_0/divbuf_0/OUT2 gnd 8.71fF
C2391 pll_full_0/divbuf_0/a_492_n240# gnd 2.46fF **FLOATING
C2392 pll_full_0/ro_complete_0/cbank_2/v gnd 16.43fF
C2393 pll_full_0/ro_complete_0/cbank_2/switch_5/vin gnd 0.78fF
C2394 pll_full_0/ro_complete_0/cbank_2/switch_4/vin gnd 1.50fF
C2395 pll_full_0/ro_complete_0/cbank_2/switch_2/vin gnd 1.30fF
C2396 pll_full_0/ro_complete_0/cbank_2/switch_3/vin gnd 0.56fF
C2397 pll_full_0/ro_complete_0/cbank_2/switch_1/vin gnd 1.14fF
C2398 pll_full_0/ro_complete_0/cbank_2/switch_0/vin gnd 1.02fF
C2399 pll_full_0/ro_complete_0/cbank_1/switch_5/vin gnd 0.78fF
C2400 pll_full_0/ro_complete_0/a0 gnd 5.35fF
C2401 pll_full_0/ro_complete_0/cbank_1/switch_4/vin gnd 1.50fF
C2402 pll_full_0/ro_complete_0/a1 gnd 6.54fF
C2403 pll_full_0/ro_complete_0/cbank_1/switch_2/vin gnd 1.30fF
C2404 pll_full_0/ro_complete_0/a3 gnd 5.96fF
C2405 pll_full_0/ro_complete_0/cbank_1/switch_3/vin gnd 0.56fF
C2406 pll_full_0/ro_complete_0/a2 gnd 5.21fF
C2407 pll_full_0/ro_complete_0/cbank_1/switch_1/vin gnd 1.14fF
C2408 pll_full_0/ro_complete_0/a4 gnd 5.81fF
C2409 pll_full_0/ro_complete_0/cbank_1/switch_0/vin gnd 1.02fF
C2410 pll_full_0/ro_complete_0/a5 gnd 6.74fF
C2411 pll_full_0/ro_complete_0/cbank_0/v gnd 15.12fF
C2412 pll_full_0/ro_complete_0/cbank_0/switch_5/vin gnd 0.78fF
C2413 pll_full_0/ro_complete_0/cbank_0/switch_4/vin gnd 1.50fF
C2414 pll_full_0/ro_complete_0/cbank_0/switch_2/vin gnd 1.30fF
C2415 pll_full_0/ro_complete_0/cbank_0/switch_3/vin gnd 0.56fF
C2416 pll_full_0/ro_complete_0/cbank_0/switch_1/vin gnd 1.14fF
C2417 pll_full_0/ro_complete_0/cbank_0/switch_0/vin gnd 1.02fF
C2418 pll_full_0/ro_complete_0/ro_var_extend_0/vcont gnd 0.27fF
C2419 pll_full_0/filter_0/a_4216_n5230# gnd 418.90fF **FLOATING
C2420 pll_full_0/filter_0/a_4216_n2998# gnd 1.39fF **FLOATING
C2421 pll_full_0/cp_0/down gnd 1.54fF
C2422 pll_full_0/cp_0/upbar gnd 1.79fF
C2423 pll_full_0/cp_0/a_7110_n2840# gnd 0.17fF **FLOATING
C2424 pll_full_0/cp_0/a_3060_n2840# gnd 1.71fF **FLOATING
C2425 pll_full_0/cp_0/a_7110_0# gnd 0.17fF **FLOATING
C2426 pll_full_0/cp_0/a_6370_0# gnd 0.40fF **FLOATING
C2427 pll_full_0/cp_0/a_3060_0# gnd 2.49fF **FLOATING
C2428 pll_full_0/cp_0/a_1710_0# gnd 7.47fF **FLOATING
C2429 pll_full_0/pd_0/and_pd_0/Z1 gnd 0.39fF
C2430 pll_full_0/pd_0/and_pd_0/Out1 gnd 2.22fF
C2431 pll_full_0/pd_0/tspc_r_1/z5 gnd 1.10fF
C2432 pll_full_0/pd_0/tspc_r_1/Z4 gnd 1.07fF
C2433 pll_full_0/pd_0/tspc_r_1/Qbar gnd 0.88fF
C2434 pll_full_0/pd_0/tspc_r_1/Z2 gnd 1.22fF
C2435 pll_full_0/pd_0/tspc_r_1/Z1 gnd 0.67fF
C2436 pll_full_0/pd_0/UP gnd 6.41fF
C2437 pll_full_0/pd_0/tspc_r_1/Qbar1 gnd 1.34fF
C2438 pll_full_0/pd_0/tspc_r_1/Z3 gnd 2.12fF
C2439 pll_full_0/pd_0/REF gnd 6.48fF
C2440 pll_full_0/pd_0/tspc_r_0/z5 gnd 1.10fF
C2441 pll_full_0/pd_0/tspc_r_0/Z4 gnd 1.07fF
C2442 pll_full_0/pd_0/R gnd 3.05fF
C2443 pll_full_0/pd_0/tspc_r_0/Qbar gnd 0.79fF
C2444 pll_full_0/pd_0/tspc_r_0/Z2 gnd 1.22fF
C2445 pll_full_0/pd_0/tspc_r_0/Z1 gnd 0.67fF
C2446 pll_full_0/pd_0/DOWN gnd 7.34fF
C2447 pll_full_0/pd_0/tspc_r_0/Qbar1 gnd 1.34fF
C2448 pll_full_0/pd_0/tspc_r_0/Z3 gnd 2.12fF
C2449 pll_full_0/pd_0/DIV gnd 372.69fF
C2450 divbuf_19/OUT5 gnd 350.37fF
C2451 divbuf_19/OUT4 gnd 133.72fF
C2452 divbuf_19/OUT3 gnd 34.03fF
C2453 divbuf_19/OUT2 gnd 8.71fF
C2454 divbuf_19/IN gnd 0.89fF
C2455 divbuf_19/a_492_n240# gnd 2.46fF **FLOATING
C2456 divbuf_18/OUT5 gnd 350.37fF
C2457 divbuf_18/OUT4 gnd 133.72fF
C2458 divbuf_18/OUT3 gnd 34.03fF
C2459 divbuf_18/OUT2 gnd 8.71fF
C2460 divbuf_18/IN gnd 0.89fF
C2461 divbuf_18/a_492_n240# gnd 2.46fF **FLOATING
C2462 divbuf_17/OUT gnd 363.82fF
C2463 divbuf_17/OUT5 gnd 350.37fF
C2464 divbuf_17/OUT4 gnd 133.72fF
C2465 divbuf_17/OUT3 gnd 34.03fF
C2466 divbuf_17/OUT2 gnd 8.71fF
C2467 divbuf_17/IN gnd 0.89fF
C2468 divbuf_17/a_492_n240# gnd 2.46fF **FLOATING
C2469 divider_2/and_0/Z1 gnd 0.74fF
C2470 divider_2/and_0/B gnd 2.25fF
C2471 divider_2/and_0/A gnd 2.19fF
C2472 divider_2/and_0/out1 gnd 2.93fF
C2473 divider_2/tspc_2/Z4 gnd 0.86fF
C2474 divider_2/tspc_2/Z3 gnd 2.26fF
C2475 divider_2/tspc_2/Z2 gnd 1.46fF
C2476 divider_2/tspc_2/Z1 gnd 0.99fF
C2477 divider_2/nor_0/A gnd 7.04fF
C2478 divider_2/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2479 divider_2/tspc_1/Z4 gnd 0.86fF
C2480 divider_2/tspc_1/Z3 gnd 2.26fF
C2481 divider_2/tspc_1/Z2 gnd 1.46fF
C2482 divider_2/tspc_1/Z1 gnd 0.99fF
C2483 divider_2/nor_0/B gnd 7.05fF
C2484 divider_2/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2485 divider_2/tspc_2/Q gnd 3.14fF
C2486 divider_2/tspc_0/Z4 gnd 0.86fF
C2487 divider_2/Out gnd 1.60fF
C2488 divider_2/tspc_0/Z3 gnd 2.26fF
C2489 divider_2/tspc_0/Z2 gnd 1.46fF
C2490 divider_2/tspc_0/Z1 gnd 0.99fF
C2491 divider_2/nor_1/B gnd 6.44fF
C2492 divider_2/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2493 divider_2/tspc_1/Q gnd 3.12fF
C2494 divider_2/clk gnd 5.63fF
C2495 divider_2/prescaler_0/nand_1/z1 gnd 0.36fF
C2496 divider_2/prescaler_0/tspc_0/D gnd 2.64fF
C2497 divider_2/prescaler_0/tspc_2/Q gnd 3.74fF
C2498 divider_2/prescaler_0/tspc_1/Q gnd 3.61fF
C2499 divider_2/prescaler_0/nand_0/z1 gnd 0.36fF
C2500 divider_2/prescaler_0/tspc_2/D gnd 3.12fF
C2501 divider_2/and_0/OUT gnd 5.62fF
C2502 divider_2/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2503 divider_2/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2504 divider_2/prescaler_0/tspc_2/Z2 gnd 1.46fF
C2505 divider_2/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2506 divider_2/prescaler_0/tspc_2/a_630_n680# gnd 1.14fF **FLOATING
C2507 divider_2/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2508 divider_2/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2509 divider_2/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2510 divider_2/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2511 divider_2/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2512 divider_2/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2513 divider_2/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2514 divider_2/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2515 divider_2/prescaler_0/Out gnd 4.59fF
C2516 divider_2/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2517 divider_2/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2518 divider_2/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2519 divider_2/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2520 divider_2/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2521 divider_2/nor_1/Z1 gnd 1.34fF
C2522 divider_2/mc2 gnd 5.29fF
C2523 divider_2/nor_0/Z1 gnd 1.34fF
C2524 divbuf_16/OUT gnd 363.82fF
C2525 divbuf_16/OUT5 gnd 350.37fF
C2526 divbuf_16/OUT4 gnd 133.72fF
C2527 divbuf_16/OUT3 gnd 34.03fF
C2528 divbuf_16/OUT2 gnd 8.71fF
C2529 divbuf_16/IN gnd 0.89fF
C2530 divbuf_16/a_492_n240# gnd 2.46fF **FLOATING
C2531 divider_1/and_0/Z1 gnd 0.74fF
C2532 divider_1/and_0/B gnd 2.25fF
C2533 divider_1/and_0/A gnd 2.19fF
C2534 divider_1/and_0/out1 gnd 2.93fF
C2535 divider_1/tspc_2/Z4 gnd 0.86fF
C2536 divider_1/tspc_2/Z3 gnd 2.26fF
C2537 divider_1/tspc_2/Z2 gnd 1.46fF
C2538 divider_1/tspc_2/Z1 gnd 0.99fF
C2539 divider_1/nor_0/A gnd 7.04fF
C2540 divider_1/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2541 divider_1/tspc_1/Z4 gnd 0.86fF
C2542 divider_1/tspc_1/Z3 gnd 2.26fF
C2543 divider_1/tspc_1/Z2 gnd 1.46fF
C2544 divider_1/tspc_1/Z1 gnd 0.99fF
C2545 divider_1/nor_0/B gnd 7.05fF
C2546 divider_1/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2547 divider_1/tspc_2/Q gnd 3.14fF
C2548 divider_1/tspc_0/Z4 gnd 0.86fF
C2549 divider_1/Out gnd 1.60fF
C2550 divider_1/tspc_0/Z3 gnd 2.26fF
C2551 divider_1/tspc_0/Z2 gnd 1.46fF
C2552 divider_1/tspc_0/Z1 gnd 0.99fF
C2553 divider_1/nor_1/B gnd 6.33fF
C2554 divider_1/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2555 divider_1/tspc_1/Q gnd 3.12fF
C2556 divider_1/clk gnd 5.63fF
C2557 divider_1/prescaler_0/nand_1/z1 gnd 0.36fF
C2558 divider_1/prescaler_0/tspc_0/D gnd 2.64fF
C2559 divider_1/prescaler_0/tspc_2/Q gnd 3.74fF
C2560 divider_1/prescaler_0/tspc_1/Q gnd 3.61fF
C2561 divider_1/prescaler_0/nand_0/z1 gnd 0.36fF
C2562 divider_1/prescaler_0/tspc_2/D gnd 3.12fF
C2563 divider_1/and_0/OUT gnd 5.62fF
C2564 divider_1/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2565 divider_1/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2566 divider_1/prescaler_0/tspc_2/Z2 gnd 1.46fF
C2567 divider_1/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2568 divider_1/prescaler_0/tspc_2/a_630_n680# gnd 1.14fF **FLOATING
C2569 divider_1/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2570 divider_1/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2571 divider_1/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2572 divider_1/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2573 divider_1/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2574 divider_1/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2575 divider_1/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2576 divider_1/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2577 divider_1/prescaler_0/Out gnd 4.59fF
C2578 divider_1/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2579 divider_1/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2580 divider_1/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2581 divider_1/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2582 divider_1/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2583 divider_1/nor_1/Z1 gnd 1.34fF
C2584 divider_1/mc2 gnd 5.29fF
C2585 divider_1/nor_0/Z1 gnd 1.34fF
C2586 divbuf_15/OUT gnd 363.82fF
C2587 divbuf_15/OUT5 gnd 350.37fF
C2588 divbuf_15/OUT4 gnd 133.72fF
C2589 divbuf_15/OUT3 gnd 34.03fF
C2590 divbuf_15/OUT2 gnd 8.71fF
C2591 divbuf_15/IN gnd 0.89fF
C2592 divbuf_15/a_492_n240# gnd 2.46fF **FLOATING
C2593 divider_0/and_0/Z1 gnd 0.74fF
C2594 divider_0/and_0/B gnd 2.25fF
C2595 divider_0/and_0/A gnd 2.19fF
C2596 divider_0/and_0/out1 gnd 2.93fF
C2597 divider_0/tspc_2/Z4 gnd 0.86fF
C2598 divider_0/tspc_2/Z3 gnd 2.26fF
C2599 divider_0/tspc_2/Z2 gnd 1.46fF
C2600 divider_0/tspc_2/Z1 gnd 0.99fF
C2601 divider_0/nor_0/A gnd 7.04fF
C2602 divider_0/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2603 divider_0/tspc_1/Z4 gnd 0.86fF
C2604 divider_0/tspc_1/Z3 gnd 2.26fF
C2605 divider_0/tspc_1/Z2 gnd 1.46fF
C2606 divider_0/tspc_1/Z1 gnd 0.99fF
C2607 divider_0/nor_0/B gnd 7.05fF
C2608 divider_0/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2609 divider_0/tspc_2/Q gnd 3.14fF
C2610 divider_0/tspc_0/Z4 gnd 0.86fF
C2611 divider_0/Out gnd 1.60fF
C2612 divider_0/tspc_0/Z3 gnd 2.26fF
C2613 divider_0/tspc_0/Z2 gnd 1.46fF
C2614 divider_0/tspc_0/Z1 gnd 0.99fF
C2615 divider_0/nor_1/B gnd 6.33fF
C2616 divider_0/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2617 divider_0/tspc_1/Q gnd 3.12fF
C2618 divider_0/clk gnd 5.63fF
C2619 divider_0/prescaler_0/nand_1/z1 gnd 0.36fF
C2620 divider_0/prescaler_0/tspc_0/D gnd 2.64fF
C2621 divider_0/prescaler_0/tspc_2/Q gnd 3.64fF
C2622 divider_0/prescaler_0/tspc_1/Q gnd 3.61fF
C2623 divider_0/prescaler_0/nand_0/z1 gnd 0.36fF
C2624 divider_0/prescaler_0/tspc_2/D gnd 3.12fF
C2625 divider_0/and_0/OUT gnd 5.62fF
C2626 divider_0/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2627 divider_0/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2628 divider_0/prescaler_0/tspc_2/Z2 gnd 1.46fF
C2629 divider_0/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2630 divider_0/prescaler_0/tspc_2/a_630_n680# gnd 1.14fF **FLOATING
C2631 divider_0/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2632 divider_0/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2633 divider_0/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2634 divider_0/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2635 divider_0/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2636 divider_0/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2637 divider_0/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2638 divider_0/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2639 divider_0/prescaler_0/Out gnd 4.59fF
C2640 divider_0/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2641 divider_0/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2642 divider_0/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2643 divider_0/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2644 divider_0/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2645 divider_0/nor_1/Z1 gnd 1.34fF
C2646 divider_0/mc2 gnd 5.29fF
C2647 divider_0/nor_0/Z1 gnd 1.34fF
C2648 divbuf_14/OUT gnd 363.82fF
C2649 divbuf_14/OUT5 gnd 350.37fF
C2650 divbuf_14/OUT4 gnd 133.72fF
C2651 divbuf_14/OUT3 gnd 34.03fF
C2652 divbuf_14/OUT2 gnd 8.71fF
C2653 divbuf_14/IN gnd 0.89fF
C2654 divbuf_14/a_492_n240# gnd 2.46fF **FLOATING
C2655 divbuf_25/OUT gnd 363.82fF
C2656 divbuf_25/OUT5 gnd 350.37fF
C2657 divbuf_25/OUT4 gnd 133.72fF
C2658 divbuf_25/OUT3 gnd 34.03fF
C2659 divbuf_25/OUT2 gnd 8.71fF
C2660 divbuf_25/IN gnd 0.89fF
C2661 divbuf_25/a_492_n240# gnd 2.46fF **FLOATING
C2662 divbuf_9/OUT gnd 363.82fF
C2663 divbuf_9/OUT5 gnd 350.37fF
C2664 divbuf_9/OUT4 gnd 133.72fF
C2665 divbuf_9/OUT3 gnd 34.03fF
C2666 divbuf_9/OUT2 gnd 8.71fF
C2667 divbuf_9/IN gnd 0.89fF
C2668 divbuf_9/a_492_n240# gnd 2.46fF **FLOATING
C2669 divbuf_13/OUT gnd 363.82fF
C2670 divbuf_13/OUT5 gnd 350.37fF
C2671 divbuf_13/OUT4 gnd 133.72fF
C2672 divbuf_13/OUT3 gnd 34.03fF
C2673 divbuf_13/OUT2 gnd 8.71fF
C2674 divbuf_13/IN gnd 0.89fF
C2675 divbuf_13/a_492_n240# gnd 2.46fF **FLOATING
C2676 divbuf_24/OUT gnd 363.82fF
C2677 divbuf_24/OUT5 gnd 350.37fF
C2678 divbuf_24/OUT4 gnd 133.72fF
C2679 divbuf_24/OUT3 gnd 34.03fF
C2680 divbuf_24/OUT2 gnd 8.71fF
C2681 divbuf_24/IN gnd 0.89fF
C2682 divbuf_24/a_492_n240# gnd 2.46fF **FLOATING
C2683 divbuf_12/OUT gnd 363.82fF
C2684 divbuf_12/OUT5 gnd 350.37fF
C2685 divbuf_12/OUT4 gnd 133.72fF
C2686 divbuf_12/OUT3 gnd 34.03fF
C2687 divbuf_12/OUT2 gnd 8.71fF
C2688 divbuf_12/IN gnd 0.89fF
C2689 divbuf_12/a_492_n240# gnd 2.46fF **FLOATING
C2690 divbuf_8/OUT gnd 363.82fF
C2691 divbuf_8/OUT5 gnd 350.37fF
C2692 divbuf_8/OUT4 gnd 133.72fF
C2693 divbuf_8/OUT3 gnd 34.03fF
C2694 divbuf_8/OUT2 gnd 8.71fF
C2695 divbuf_8/IN gnd 0.89fF
C2696 divbuf_8/a_492_n240# gnd 2.46fF **FLOATING
C2697 divbuf_23/OUT5 gnd 350.37fF
C2698 divbuf_23/OUT4 gnd 133.72fF
C2699 divbuf_23/OUT3 gnd 34.03fF
C2700 divbuf_23/OUT2 gnd 8.71fF
C2701 divbuf_23/IN gnd 0.89fF
C2702 divbuf_23/a_492_n240# gnd 2.46fF **FLOATING
C2703 divbuf_7/OUT gnd 363.82fF
C2704 divbuf_7/OUT5 gnd 350.37fF
C2705 divbuf_7/OUT4 gnd 133.72fF
C2706 divbuf_7/OUT3 gnd 34.03fF
C2707 divbuf_7/OUT2 gnd 8.71fF
C2708 divbuf_7/IN gnd 0.89fF
C2709 divbuf_7/a_492_n240# gnd 2.46fF **FLOATING
C2710 divbuf_11/OUT gnd 363.82fF
C2711 divbuf_11/OUT5 gnd 350.37fF
C2712 divbuf_11/OUT4 gnd 133.72fF
C2713 divbuf_11/OUT3 gnd 34.03fF
C2714 divbuf_11/OUT2 gnd 8.71fF
C2715 divbuf_11/IN gnd 0.89fF
C2716 divbuf_11/a_492_n240# gnd 2.46fF **FLOATING
C2717 divbuf_22/OUT5 gnd 350.37fF
C2718 divbuf_22/OUT4 gnd 133.72fF
C2719 divbuf_22/OUT3 gnd 34.03fF
C2720 divbuf_22/OUT2 gnd 8.71fF
C2721 divbuf_22/IN gnd 0.89fF
C2722 divbuf_22/a_492_n240# gnd 2.46fF **FLOATING
C2723 divbuf_6/OUT gnd 363.82fF
C2724 divbuf_6/OUT5 gnd 350.37fF
C2725 divbuf_6/OUT4 gnd 133.72fF
C2726 divbuf_6/OUT3 gnd 34.03fF
C2727 divbuf_6/OUT2 gnd 8.71fF
C2728 divbuf_6/IN gnd 0.89fF
C2729 divbuf_6/a_492_n240# gnd 2.46fF **FLOATING
C2730 divbuf_10/OUT gnd 363.82fF
C2731 divbuf_10/OUT5 gnd 350.37fF
C2732 divbuf_10/OUT4 gnd 133.72fF
C2733 divbuf_10/OUT3 gnd 34.03fF
C2734 divbuf_10/OUT2 gnd 8.71fF
C2735 divbuf_10/IN gnd 0.89fF
C2736 divbuf_10/a_492_n240# gnd 2.46fF **FLOATING
C2737 divbuf_20/OUT5 gnd 350.37fF
C2738 divbuf_20/OUT4 gnd 133.72fF
C2739 divbuf_20/OUT3 gnd 34.03fF
C2740 divbuf_20/OUT2 gnd 8.71fF
C2741 divbuf_20/IN gnd 0.89fF
C2742 divbuf_20/a_492_n240# gnd 2.46fF **FLOATING
C2743 divbuf_21/OUT5 gnd 350.37fF
C2744 divbuf_21/OUT4 gnd 133.72fF
C2745 divbuf_21/OUT3 gnd 34.03fF
C2746 divbuf_21/OUT2 gnd 8.71fF
C2747 divbuf_21/IN gnd 0.89fF
C2748 divbuf_21/a_492_n240# gnd 2.46fF **FLOATING
C2749 divbuf_5/OUT gnd 363.82fF
C2750 divbuf_5/OUT5 gnd 350.37fF
C2751 divbuf_5/OUT4 gnd 133.72fF
C2752 divbuf_5/OUT3 gnd 34.03fF
C2753 divbuf_5/OUT2 gnd 8.71fF
C2754 divbuf_5/IN gnd 0.89fF
C2755 divbuf_5/a_492_n240# gnd 2.46fF **FLOATING
C2756 divbuf_4/OUT gnd 363.82fF
C2757 divbuf_4/OUT5 gnd 350.37fF
C2758 divbuf_4/OUT4 gnd 133.72fF
C2759 divbuf_4/OUT3 gnd 34.03fF
C2760 divbuf_4/OUT2 gnd 8.71fF
C2761 divbuf_4/IN gnd 0.89fF
C2762 divbuf_4/a_492_n240# gnd 2.46fF **FLOATING
C2763 divbuf_3/OUT gnd 363.82fF
C2764 divbuf_3/OUT5 gnd 350.37fF
C2765 divbuf_3/OUT4 gnd 133.72fF
C2766 divbuf_3/OUT3 gnd 34.03fF
C2767 divbuf_3/OUT2 gnd 8.71fF
C2768 divbuf_3/IN gnd 0.89fF
C2769 divbuf_3/a_492_n240# gnd 2.46fF **FLOATING
C2770 divbuf_2/OUT gnd 363.82fF
C2771 divbuf_2/OUT5 gnd 350.37fF
C2772 divbuf_2/OUT4 gnd 133.72fF
C2773 divbuf_2/OUT3 gnd 34.03fF
C2774 divbuf_2/OUT2 gnd 8.71fF
C2775 divbuf_2/IN gnd 0.89fF
C2776 divbuf_2/a_492_n240# gnd 2.46fF **FLOATING
C2777 divbuf_1/OUT gnd 363.82fF
C2778 divbuf_1/OUT5 gnd 350.37fF
C2779 divbuf_1/OUT4 gnd 133.72fF
C2780 divbuf_1/OUT3 gnd 34.03fF
C2781 divbuf_1/OUT2 gnd 8.71fF
C2782 divbuf_1/IN gnd 0.89fF
C2783 divbuf_1/a_492_n240# gnd 2.46fF **FLOATING
C2784 divbuf_0/OUT5 gnd 350.37fF
C2785 divbuf_0/OUT4 gnd 133.72fF
C2786 divbuf_0/OUT3 gnd 34.03fF
C2787 divbuf_0/OUT2 gnd 8.71fF
C2788 divbuf_0/IN gnd 0.89fF
C2789 divbuf_0/a_492_n240# gnd 2.46fF **FLOATING
C2790 ro_complete_1/cbank_2/v gnd 16.43fF
C2791 ro_complete_1/cbank_2/switch_5/vin gnd 0.78fF
C2792 ro_complete_1/cbank_2/switch_4/vin gnd 1.50fF
C2793 ro_complete_1/cbank_2/switch_2/vin gnd 1.30fF
C2794 ro_complete_1/cbank_2/switch_3/vin gnd 0.56fF
C2795 ro_complete_1/cbank_2/switch_1/vin gnd 1.14fF
C2796 ro_complete_1/cbank_2/switch_0/vin gnd 1.02fF
C2797 ro_complete_1/cbank_1/v gnd 16.43fF
C2798 ro_complete_1/cbank_1/switch_5/vin gnd 0.78fF
C2799 ro_complete_1/a0 gnd 5.35fF
C2800 ro_complete_1/cbank_1/switch_4/vin gnd 1.50fF
C2801 ro_complete_1/a1 gnd 6.54fF
C2802 ro_complete_1/cbank_1/switch_2/vin gnd 1.30fF
C2803 ro_complete_1/a3 gnd 5.96fF
C2804 ro_complete_1/cbank_1/switch_3/vin gnd 0.56fF
C2805 ro_complete_1/a2 gnd 5.21fF
C2806 ro_complete_1/cbank_1/switch_1/vin gnd 1.14fF
C2807 ro_complete_1/a4 gnd 5.81fF
C2808 ro_complete_1/cbank_1/switch_0/vin gnd 1.02fF
C2809 ro_complete_1/a5 gnd 6.74fF
C2810 ro_complete_1/cbank_0/v gnd 15.12fF
C2811 ro_complete_1/cbank_0/switch_5/vin gnd 0.78fF
C2812 ro_complete_1/cbank_0/switch_4/vin gnd 1.50fF
C2813 ro_complete_1/cbank_0/switch_2/vin gnd 1.30fF
C2814 ro_complete_1/cbank_0/switch_3/vin gnd 0.56fF
C2815 ro_complete_1/cbank_0/switch_1/vin gnd 1.14fF
C2816 ro_complete_1/cbank_0/switch_0/vin gnd 1.02fF
C2817 ro_complete_1/ro_var_extend_0/vcont gnd 0.27fF
C2818 ro_complete_0/cbank_2/v gnd 16.43fF
C2819 ro_complete_0/cbank_2/switch_5/vin gnd 0.78fF
C2820 ro_complete_0/cbank_2/switch_4/vin gnd 1.50fF
C2821 ro_complete_0/cbank_2/switch_2/vin gnd 1.30fF
C2822 ro_complete_0/cbank_2/switch_3/vin gnd 0.56fF
C2823 ro_complete_0/cbank_2/switch_1/vin gnd 1.14fF
C2824 ro_complete_0/cbank_2/switch_0/vin gnd 1.02fF
C2825 ro_complete_0/cbank_1/v gnd 16.46fF
C2826 ro_complete_0/cbank_1/switch_5/vin gnd 0.78fF
C2827 divbuf_18/OUT gnd 405.76fF
C2828 ro_complete_0/cbank_1/switch_4/vin gnd 1.50fF
C2829 divbuf_19/OUT gnd 402.77fF
C2830 ro_complete_0/cbank_1/switch_2/vin gnd 1.30fF
C2831 divbuf_22/OUT gnd 394.74fF
C2832 ro_complete_0/cbank_1/switch_3/vin gnd 0.56fF
C2833 divbuf_20/OUT gnd 397.92fF
C2834 ro_complete_0/cbank_1/switch_1/vin gnd 1.14fF
C2835 divbuf_21/OUT gnd 391.26fF
C2836 ro_complete_0/cbank_1/switch_0/vin gnd 1.02fF
C2837 divbuf_23/OUT gnd 387.66fF
C2838 ro_complete_0/cbank_0/v gnd 15.12fF
C2839 ro_complete_0/cbank_0/switch_5/vin gnd 0.78fF
C2840 ro_complete_0/cbank_0/switch_4/vin gnd 1.50fF
C2841 ro_complete_0/cbank_0/switch_2/vin gnd 1.30fF
C2842 ro_complete_0/cbank_0/switch_3/vin gnd 0.56fF
C2843 ro_complete_0/cbank_0/switch_1/vin gnd 1.14fF
C2844 ro_complete_0/cbank_0/switch_0/vin gnd 1.02fF
C2845 ro_complete_0/ro_var_extend_0/vcont gnd 0.27fF
C2846 filter_0/v gnd 477.90fF
C2847 filter_0/a_4216_n5230# gnd 418.47fF **FLOATING
C2848 filter_0/a_4216_n2998# gnd 1.03fF **FLOATING
C2849 cp_0/down gnd 1.54fF
C2850 cp_0/vbias gnd 2.41fF
C2851 cp_0/out gnd 5.34fF
C2852 cp_0/upbar gnd 1.50fF
C2853 cp_0/a_7110_n2840# gnd 0.17fF **FLOATING
C2854 cp_0/a_3060_n2840# gnd 1.71fF **FLOATING
C2855 cp_0/a_7110_0# gnd 0.17fF **FLOATING
C2856 cp_0/a_6370_0# gnd 0.40fF **FLOATING
C2857 cp_0/a_3060_0# gnd 1.66fF **FLOATING
C2858 cp_0/a_1710_0# gnd 5.89fF **FLOATING
C2859 cp_0/a_1710_n2840# gnd 4.91fF **FLOATING
C2860 cp_0/a_10_n50# gnd 2.96fF **FLOATING
C2861 pd_1/and_pd_0/Z1 gnd 0.39fF
C2862 pd_1/and_pd_0/Out1 gnd 2.22fF
C2863 pd_1/tspc_r_1/z5 gnd 1.10fF
C2864 pd_1/tspc_r_1/Z4 gnd 1.07fF
C2865 pd_1/tspc_r_1/Qbar gnd 0.88fF
C2866 pd_1/tspc_r_1/Z2 gnd 1.22fF
C2867 pd_1/tspc_r_1/Z1 gnd 0.67fF
C2868 pd_1/UP gnd 2.21fF
C2869 pd_1/tspc_r_1/Qbar1 gnd 1.34fF
C2870 pd_1/tspc_r_1/Z3 gnd 2.12fF
C2871 pd_1/REF gnd 1.80fF
C2872 pd_1/tspc_r_0/z5 gnd 1.10fF
C2873 pd_1/tspc_r_0/Z4 gnd 1.07fF
C2874 pd_1/R gnd 3.05fF
C2875 pd_1/tspc_r_0/Qbar gnd 0.79fF
C2876 pd_1/tspc_r_0/Z2 gnd 1.22fF
C2877 pd_1/tspc_r_0/Z1 gnd 0.67fF
C2878 pd_1/DOWN gnd 3.08fF
C2879 pd_1/tspc_r_0/Qbar1 gnd 1.34fF
C2880 pd_1/tspc_r_0/Z3 gnd 2.12fF
C2881 pd_1/DIV gnd 1.82fF
C2882 pd_0/and_pd_0/Z1 gnd 0.39fF
C2883 pd_0/and_pd_0/Out1 gnd 2.22fF
C2884 pd_0/tspc_r_1/z5 gnd 1.10fF
C2885 pd_0/tspc_r_1/Z4 gnd 1.07fF
C2886 pd_0/tspc_r_1/Qbar gnd 0.88fF
C2887 pd_0/tspc_r_1/Z2 gnd 1.22fF
C2888 pd_0/tspc_r_1/Z1 gnd 0.67fF
C2889 pd_0/UP gnd 2.21fF
C2890 pd_0/tspc_r_1/Qbar1 gnd 1.34fF
C2891 pd_0/tspc_r_1/Z3 gnd 2.12fF
C2892 pd_0/REF gnd 1.80fF
C2893 pd_0/tspc_r_0/z5 gnd 1.10fF
C2894 pd_0/tspc_r_0/Z4 gnd 1.07fF
C2895 pd_0/R gnd 3.05fF
C2896 pd_0/tspc_r_0/Qbar gnd 0.79fF
C2897 pd_0/tspc_r_0/Z2 gnd 1.22fF
C2898 pd_0/tspc_r_0/Z1 gnd 0.67fF
C2899 pd_0/DOWN gnd 3.08fF
C2900 pd_0/tspc_r_0/Qbar1 gnd 1.34fF
C2901 pd_0/tspc_r_0/Z3 gnd 2.12fF
C2902 pd_0/DIV gnd 1.82fF
.ends
